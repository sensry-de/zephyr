

base edap:0x00000000


tree "M4ROM"
base e:0x0
width 80.
tree.end

tree "M85ITCM_ALIAS"
base e:0x1000000
width 80.
tree.end

tree "SRAM1_ALIAS"
base e:0x2000000
width 80.
tree.end

tree "M4IRAM"
base e:0x2100000
width 80.
tree.end

tree "DDRRAM1"
base e:0x10000000
width 80.
tree.end

tree "M85DTCM"
base e:0x20000000
width 80.
tree.end

tree "SRAM1"
base e:0x20100000
width 80.
tree.end

tree "SRAM2"
base e:0x20200000
width 80.
tree.end

tree "SRAM3"
base e:0x20300000
width 80.
tree.end

tree "SRAM4"
base e:0x20400000
width 80.
tree.end

tree "M4DRAM"
base e:0x20500000
width 80.
tree.end

tree "DDRRAM1_ALIAS"
base e:0x30000000
width 80.
tree.end

tree "RBB"
base e:0x40000000
width 80.
group.long  0x0++0x3
    line.long 0x00 "RBB_CTRL_ARM_M4_CLKRST, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x3"
         bitfld.long 0x00 0. " RBB_CTRL_ARM_M4_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x1"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_ARM_M4_CLKRST_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_ARM_M4_CLKRST_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "RBB_CTRL_ARM_M85_CLKRST, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_ARM_M85_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_ARM_M85_CLKRST_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_ARM_M85_CLKRST_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_EMMC, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_EMMC_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_EMMC_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_EMMC_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_EMMC_TX, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_EMMC_TX_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_EMMC_TX_DIV ,Divider value of clk. freq = source_freq/div. FPGA: min val of 2 applied. RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_EMMC_TX_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_QSPI_DISP_M, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_QSPI_DISP_M_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_QSPI_DISP_M_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_QSPI_DISP_M_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_I2S_M, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_I2S_M_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_I2S_M_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_I2S_M_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_BTSPI_M, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_BTSPI_M_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_BTSPI_M_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_BTSPI_M_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_DECTSPI_M, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_DECTSPI_M_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_DECTSPI_M_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_DECTSPI_M_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_SPI_M, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_SPI_M_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_SPI_M_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_SPI_M_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_GPU, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_GPU_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_GPU_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_GPU_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_DCU, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_DCU_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_DCU_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_DCU_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_LPDDR, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x20a"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_LPDDR_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_LPDDR_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x5"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_LPDDR_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x1"
          
group.long  0x30++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_LPDDR_CTRL, Register to control enable and division ratio on the path of this clock RESET:0x4"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_LPDDR_CTRL_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_LPDDR_CTRL_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x2"
          
group.long  0x34++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_MALI, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_MALI_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_MALI_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_MALI_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_H264, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_H264_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_H264_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_H264_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_ETHOS, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_ETHOS_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_ETHOS_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_ETHOS_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_NIC_HALF, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x3"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_NIC_HALF_EN_CLK ,Enable clock. FPGA: N/A RESET:0x1"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_NIC_HALF_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_NIC_HALF_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x44++0x3
    line.long 0x00 "RBB_CTRL_IRCAM_AXI_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_IRCAM_AXI_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "RBB_CTRL_SPI_M_AXI_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_SPI_M_AXI_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "RBB_CTRL_DECTSPI_M_AXI_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_DECTSPI_M_AXI_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "RBB_CTRL_DECTSPI_S_AXI_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_DECTSPI_S_AXI_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0x54++0x3
    line.long 0x00 "RBB_CTRL_BTSPI_M_AXI_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_BTSPI_M_AXI_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "RBB_CTRL_QSPI_DISP_AXI_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_QSPI_DISP_AXI_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0x5c++0x3
    line.long 0x00 "RBB_CTRL_I2S1_S_AXI_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_I2S1_S_AXI_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "RBB_CTRL_I2S2_S_AXI_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_I2S2_S_AXI_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_LPDDR_NIC, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_LPDDR_NIC_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_LPDDR_NIC_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_LPDDR_NIC_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x68++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_LPDDR_APB, Register to control enable and division ratio on the path of this clock RESET:0x4"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_LPDDR_APB_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_LPDDR_APB_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x2"
          
group.long  0x6c++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_ETHERNET, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_ETHERNET_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_ETHERNET_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_ETHERNET_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x70++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_IRSPI_M, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_IRSPI_M_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_IRSPI_M_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_IRSPI_M_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x74++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_DMA350, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_DMA350_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_DMA350_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_DMA350_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x78++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_CSI_PIXEL, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_CSI_PIXEL_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_CSI_PIXEL_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_CSI_PIXEL_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x7c++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_DSI_PIXEL, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_DSI_PIXEL_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_DSI_PIXEL_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_DSI_PIXEL_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x80++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_DSI_SYS, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_DSI_SYS_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_DSI_SYS_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_DSI_SYS_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x84++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_SRAM, Register to control enable, division ratio, and source mux selection on the path of this clock RESET:0x3"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_SRAM_EN_CLK ,Enable clock. FPGA: N/A RESET:0x1"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_SRAM_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_DIV_CLK_SRAM_SEL_CLK_PLL2000 ,If 1: source clk = clk_pll2000, if 0: source clk = clk_rbb. FPGA: N/A RESET:0x0"
          
group.long  0x88++0x3
    line.long 0x00 "RBB_CTRL_SRAM1_CLKRST, Register to control the enable on the path of this clock RESET:0x1"
         bitfld.long 0x00 0. " RBB_CTRL_SRAM1_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x1"
          
group.long  0x8c++0x3
    line.long 0x00 "RBB_CTRL_SRAM2_CLKRST, Register to control the enable on the path of this clock RESET:0x1"
         bitfld.long 0x00 0. " RBB_CTRL_SRAM2_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x1"
          
group.long  0x90++0x3
    line.long 0x00 "RBB_CTRL_SRAM3_CLKRST, Register to control the enable on the path of this clock RESET:0x1"
         bitfld.long 0x00 0. " RBB_CTRL_SRAM3_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x1"
          
group.long  0x94++0x3
    line.long 0x00 "RBB_CTRL_SRAM4_CLKRST, Register to control the enable on the path of this clock RESET:0x1"
         bitfld.long 0x00 0. " RBB_CTRL_SRAM4_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x1"
          
group.long  0x98++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_PERI, Register to control enable and division ratio on the path of this clock RESET:0x3"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_PERI_EN_CLK ,Enable clock. FPGA: N/A RESET:0x1"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_PERI_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
group.long  0x9c++0x3
    line.long 0x00 "RBB_CTRL_KIVI_PQC_CFG_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_KIVI_PQC_CFG_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0xa0++0x3
    line.long 0x00 "RBB_CTRL_UART_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_UART_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0xa4++0x3
    line.long 0x00 "RBB_CTRL_DUALTIMER1_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_DUALTIMER1_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0xa8++0x3
    line.long 0x00 "RBB_CTRL_DUALTIMER2_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_DUALTIMER2_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0xac++0x3
    line.long 0x00 "RBB_CTRL_WATCHDOG_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_WATCHDOG_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0xb0++0x3
    line.long 0x00 "RBB_CTRL_I2C_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_I2C_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0xb4++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_DISP_DPHY_CFG, Register to control enable and division ratio on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_DISP_DPHY_CFG_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_DISP_DPHY_CFG_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
group.long  0xb8++0x3
    line.long 0x00 "RBB_CTRL_DIV_CLK_CAM_DPHY_CFG, Register to control enable and division ratio on the path of this clock RESET:0x2"
         bitfld.long 0x00 0. " RBB_CTRL_DIV_CLK_CAM_DPHY_CFG_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " RBB_CTRL_DIV_CLK_CAM_DPHY_CFG_DIV ,Divider value of clk. freq = source_freq/div. FPGA: N/A RESET:0x1"
          
group.long  0xbc++0x3
    line.long 0x00 "RBB_CTRL_DSIPHY_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_DSIPHY_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0xc0++0x3
    line.long 0x00 "RBB_CTRL_ETHPHY_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_ETHPHY_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0xc4++0x3
    line.long 0x00 "RBB_CTRL_SGMII_CLKRST, Register to control the enable on the path of this clock RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_SGMII_CLKRST_EN_CLK ,Enable clock. FPGA: N/A RESET:0x0"
          
group.long  0xc8++0x3
    line.long 0x00 "RBB_RESET_CTRL, register to reset some peripherals RESET:0x7ff"
         bitfld.long 0x00 0. " RBB_RESET_CTRL_I2S1_S_AXI_N ,None RESET:0x1"
          
         bitfld.long 0x00 1. " RBB_RESET_CTRL_I2S2_S_AXI_N ,None RESET:0x1"
          
         bitfld.long 0x00 2. " RBB_RESET_CTRL_DECTSPI_S_AXI_N ,None RESET:0x1"
          
         bitfld.long 0x00 3. " RBB_RESET_CTRL_I2S_M_N ,None RESET:0x1"
          
         bitfld.long 0x00 4. " RBB_RESET_CTRL_DECTSPI_M_N ,None RESET:0x1"
          
         bitfld.long 0x00 5. " RBB_RESET_CTRL_SPI_M_N ,None RESET:0x1"
          
         bitfld.long 0x00 6. " RBB_RESET_CTRL_BTSPI_M_N ,None RESET:0x1"
          
         bitfld.long 0x00 7. " RBB_RESET_CTRL_IRSPI_M_N ,None RESET:0x1"
          
         bitfld.long 0x00 8. " RBB_RESET_CTRL_QSPI_DISP_M_N ,None RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_RESET_CTRL_DMA350_N ,None RESET:0x1"
          
         bitfld.long 0x00 10. " RBB_RESET_CTRL_SRAM_N ,None RESET:0x1"
          
group.long  0xcc++0x3
    line.long 0x00 "RBB_CTRL_DECT_SPI_S, dect_spi_s RESET:0x0"
         bitfld.long 0x00 0. " RBB_CTRL_DECT_SPI_S_ENABLE ,if set to 1: The block SBA2(SPI) to AXI is enabled RESET:0x0"
          
         bitfld.long 0x00 1. " RBB_CTRL_DECT_SPI_S_CPOL ,if value is 0 : The clock is low when idle RESET:0x0"
          
         bitfld.long 0x00 2. " RBB_CTRL_DECT_SPI_S_CPHA ,if value is 0 : Data is sampled on rising edge and shifted on falling edge RESET:0x0"
          
group.long  0xd0++0x3
    line.long 0x00 "RBB_ARMCM4_HALT2FREEZE_MASK, None RESET:0x0"
         bitfld.long 0x00 0. " RBB_ARMCM4_HALT2FREEZE_MASK_TIMER1 ,if set to 1: timer1 will freeze while armcm4 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
         bitfld.long 0x00 1. " RBB_ARMCM4_HALT2FREEZE_MASK_TIMER2 ,if set to 1: timer2 will freeze while armcm4 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
         bitfld.long 0x00 2. " RBB_ARMCM4_HALT2FREEZE_MASK_TIMER3 ,if set to 1: timer3 will freeze while armcm4 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
         bitfld.long 0x00 3. " RBB_ARMCM4_HALT2FREEZE_MASK_TIMER4 ,if set to 1: timer4 will freeze while armcm4 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
         bitfld.long 0x00 4. " RBB_ARMCM4_HALT2FREEZE_MASK_WATCHDOG ,if set to 1: watchdog will freeze while armcm4 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
         bitfld.long 0x00 5. " RBB_ARMCM4_HALT2FREEZE_MASK_RI_TIMER_PWM1 ,if set to 1: ri_timer_pwm1 will freeze while armcm4 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
         bitfld.long 0x00 6. " RBB_ARMCM4_HALT2FREEZE_MASK_RI_TIMER_PWM2 ,if set to 1: ri_timer_pwm2 will freeze while armcm4 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
         bitfld.long 0x00 7. " RBB_ARMCM4_HALT2FREEZE_MASK_RI_TIMER_SIMPLE_RTC ,if set to 1: ri_timer_simple_rtc will freeze while armcm4 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
group.long  0xd4++0x3
    line.long 0x00 "RBB_ARMCM85_HALT2FREEZE_MASK, None RESET:0x0"
         bitfld.long 0x00 0. " RBB_ARMCM85_HALT2FREEZE_MASK_TIMER1 ,if set to 1: timer1 will freeze while armcm85 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
         bitfld.long 0x00 1. " RBB_ARMCM85_HALT2FREEZE_MASK_TIMER2 ,if set to 1: timer2 will freeze while armcm85 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
         bitfld.long 0x00 2. " RBB_ARMCM85_HALT2FREEZE_MASK_TIMER3 ,if set to 1: timer3 will freeze while armcm85 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
         bitfld.long 0x00 3. " RBB_ARMCM85_HALT2FREEZE_MASK_TIMER4 ,if set to 1: timer4 will freeze while armcm85 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
         bitfld.long 0x00 4. " RBB_ARMCM85_HALT2FREEZE_MASK_WATCHDOG ,if set to 1: watchdog will freeze while armcm85 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
         bitfld.long 0x00 5. " RBB_ARMCM85_HALT2FREEZE_MASK_RI_TIMER_PWM1 ,if set to 1: ri_timer_pwm1 will freeze while armcm85 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
         bitfld.long 0x00 6. " RBB_ARMCM85_HALT2FREEZE_MASK_RI_TIMER_PWM2 ,if set to 1: ri_timer_pwm2 will freeze while armcm85 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
         bitfld.long 0x00 7. " RBB_ARMCM85_HALT2FREEZE_MASK_RI_TIMER_SIMPLE_RTC ,if set to 1: ri_timer_simple_rtc will freeze while armcm85 has the  HALTED signal asserted, which means the processor is in debug mode RESET:0x0"
          
group.long  0xd8++0x3
    line.long 0x00 "RBB_ARM_DMA350_P_Q_CH, Handshake signals of the P and Q channels of DMA350 RESET:0x113"
         bitfld.long 0x00 0. " RBB_ARM_DMA350_P_Q_CH_CLK_QREQN ,Clock quiescence entry or exit request RESET:0x1"
          
         bitfld.long 0x00 1. " RBB_ARM_DMA350_P_Q_CH_CLK_QACCEPTN ,Indicates quiescence request is accepted RESET:0x1"
          
         bitfld.long 0x00 2. " RBB_ARM_DMA350_P_Q_CH_CLK_QDENY ,Clock quiescence request denied RESET:0x0"
          
         bitfld.long 0x00 3. " RBB_ARM_DMA350_P_Q_CH_CLK_QACTIVE ,It indicates when the DMA is active and also when it requests to exit from clock quiescence RESET:0x0"
          
         bitfld.long 0x00 4. " RBB_ARM_DMA350_P_Q_CH_PREQ ,Power state change request RESET:0x1"
          
         hexmask.long 0x00 5.--8. 1. " RBB_ARM_DMA350_P_Q_CH_PSTATE ,Requested power state RESET:0x8"
          
         bitfld.long 0x00 9. " RBB_ARM_DMA350_P_Q_CH_PACCEPT ,Power state change request accepted RESET:0x0"
          
         bitfld.long 0x00 10. " RBB_ARM_DMA350_P_Q_CH_PDENY ,Power state change request denied RESET:0x0"
          
         hexmask.long 0x00 11.--20. 1. " RBB_ARM_DMA350_P_Q_CH_PACTIVE ,Active power states RESET:0x0"
          
group.long  0xdc++0x3
    line.long 0x00 "RBB_ARM_DMA350_CTRL, Handshake signals of the P and Q channels of DMA350 RESET:0x6"
         bitfld.long 0x00 0. " RBB_ARM_DMA350_CTRL_PDEBUG ,APB interface extra signal. When high, it disables the security violation error (used when debugger accesses in non-secure mode) RESET:0x0"
          
         bitfld.long 0x00 1. " RBB_ARM_DMA350_CTRL_ACLKEN_M0 ,Enable AXI clk on M0 interface RESET:0x1"
          
         bitfld.long 0x00 2. " RBB_ARM_DMA350_CTRL_PCLKEN ,Enable APB clock RESET:0x1"
          
         bitfld.long 0x00 3. " RBB_ARM_DMA350_CTRL_ALLCH_STOP_REQ_NONSEC ,All channel stop request for Non-secure channels RESET:0x0"
          
         bitfld.long 0x00 4. " RBB_ARM_DMA350_CTRL_ALLCH_STOP_ACK_NONSEC ,All channel stopped acknowledge for Non-secure channels RESET:0x0"
          
         bitfld.long 0x00 5. " RBB_ARM_DMA350_CTRL_ALLCH_PAUSE_REQ_NONSEC ,All channel pause request for Non-secure channels RESET:0x0"
          
         bitfld.long 0x00 6. " RBB_ARM_DMA350_CTRL_ALLCH_PAUSE_ACK_NONSEC ,All channel pause acknowledge for Non-secure channels RESET:0x0"
          
         bitfld.long 0x00 7. " RBB_ARM_DMA350_CTRL_HALT_REQ ,Level input to pause all operations and go into a halted state for both Secure and Non-secure channels. RESET:0x0"
          
         bitfld.long 0x00 8. " RBB_ARM_DMA350_CTRL_HALTED ,Pulse indication that the DMAC reached the halted state. RESET:0x0"
          
         bitfld.long 0x00 9. " RBB_ARM_DMA350_CTRL_RESTART_REQ ,Pulse input to resume the operation from the halted state RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " RBB_ARM_DMA350_CTRL_CH_ENABLED ,Channel is active. RESET:0x0"
          
         hexmask.long 0x00 12.--13. 1. " RBB_ARM_DMA350_CTRL_CH_ERR ,Channel has error. RESET:0x0"
          
         hexmask.long 0x00 14.--15. 1. " RBB_ARM_DMA350_CTRL_CH_STOPPED ,Channel is stopped. RESET:0x0"
          
         hexmask.long 0x00 16.--17. 1. " RBB_ARM_DMA350_CTRL_CH_PAUSED ,Channel is paused. RESET:0x0"
          
         hexmask.long 0x00 18.--19. 1. " RBB_ARM_DMA350_CTRL_CH_PRIV ,Privilege settings of the channel. RESET:0x0"
          
group.long  0xe0++0x3
    line.long 0x00 "RBB_SRAM1_Q_CH, Handshake signals of the P channel of SRAM1 RESET:0x33"
         bitfld.long 0x00 0. " RBB_SRAM1_Q_CH_CLK_QREQN ,Clock quiescence entry or exit request RESET:0x1"
          
         bitfld.long 0x00 1. " RBB_SRAM1_Q_CH_CLK_QACCEPTN ,Indicates quiescence request is accepted RESET:0x1"
          
         bitfld.long 0x00 2. " RBB_SRAM1_Q_CH_CLK_QDENY ,Clock quiescence request denied RESET:0x0"
          
         bitfld.long 0x00 3. " RBB_SRAM1_Q_CH_CLK_QACTIVE ,It indicates when the component is active and also when it requests to exit from quiescence RESET:0x0"
          
         bitfld.long 0x00 4. " RBB_SRAM1_Q_CH_PWR_QREQN ,Power quiescence entry or exit request RESET:0x1"
          
         bitfld.long 0x00 5. " RBB_SRAM1_Q_CH_PWR_QACCEPTN ,Indicates quiescence request is accepted RESET:0x1"
          
         bitfld.long 0x00 6. " RBB_SRAM1_Q_CH_PWR_QDENY ,Clock quiescence request denied RESET:0x0"
          
         bitfld.long 0x00 7. " RBB_SRAM1_Q_CH_PWR_QACTIVE ,It indicates when the component is active and also when it requests to exit from quiescence RESET:0x0"
          
group.long  0xe4++0x3
    line.long 0x00 "RBB_SRAM2_Q_CH, Handshake signals of the P channel of SRAM2 RESET:0x33"
         bitfld.long 0x00 0. " RBB_SRAM2_Q_CH_CLK_QREQN ,Clock quiescence entry or exit request RESET:0x1"
          
         bitfld.long 0x00 1. " RBB_SRAM2_Q_CH_CLK_QACCEPTN ,Indicates quiescence request is accepted RESET:0x1"
          
         bitfld.long 0x00 2. " RBB_SRAM2_Q_CH_CLK_QDENY ,Clock quiescence request denied RESET:0x0"
          
         bitfld.long 0x00 3. " RBB_SRAM2_Q_CH_CLK_QACTIVE ,It indicates when the component is active and also when it requests to exit from quiescence RESET:0x0"
          
         bitfld.long 0x00 4. " RBB_SRAM2_Q_CH_PWR_QREQN ,Power quiescence entry or exit request RESET:0x1"
          
         bitfld.long 0x00 5. " RBB_SRAM2_Q_CH_PWR_QACCEPTN ,Indicates quiescence request is accepted RESET:0x1"
          
         bitfld.long 0x00 6. " RBB_SRAM2_Q_CH_PWR_QDENY ,Clock quiescence request denied RESET:0x0"
          
         bitfld.long 0x00 7. " RBB_SRAM2_Q_CH_PWR_QACTIVE ,It indicates when the component is active and also when it requests to exit from quiescence RESET:0x0"
          
group.long  0xe8++0x3
    line.long 0x00 "RBB_SRAM3_Q_CH, Handshake signals of the P channel of SRAM3 RESET:0x33"
         bitfld.long 0x00 0. " RBB_SRAM3_Q_CH_CLK_QREQN ,Clock quiescence entry or exit request RESET:0x1"
          
         bitfld.long 0x00 1. " RBB_SRAM3_Q_CH_CLK_QACCEPTN ,Indicates quiescence request is accepted RESET:0x1"
          
         bitfld.long 0x00 2. " RBB_SRAM3_Q_CH_CLK_QDENY ,Clock quiescence request denied RESET:0x0"
          
         bitfld.long 0x00 3. " RBB_SRAM3_Q_CH_CLK_QACTIVE ,It indicates when the component is active and also when it requests to exit from quiescence RESET:0x0"
          
         bitfld.long 0x00 4. " RBB_SRAM3_Q_CH_PWR_QREQN ,Power quiescence entry or exit request RESET:0x1"
          
         bitfld.long 0x00 5. " RBB_SRAM3_Q_CH_PWR_QACCEPTN ,Indicates quiescence request is accepted RESET:0x1"
          
         bitfld.long 0x00 6. " RBB_SRAM3_Q_CH_PWR_QDENY ,Clock quiescence request denied RESET:0x0"
          
         bitfld.long 0x00 7. " RBB_SRAM3_Q_CH_PWR_QACTIVE ,It indicates when the component is active and also when it requests to exit from quiescence RESET:0x0"
          
group.long  0xec++0x3
    line.long 0x00 "RBB_SRAM4_Q_CH, Handshake signals of the P channel of SRAM4 RESET:0x33"
         bitfld.long 0x00 0. " RBB_SRAM4_Q_CH_CLK_QREQN ,Clock quiescence entry or exit request RESET:0x1"
          
         bitfld.long 0x00 1. " RBB_SRAM4_Q_CH_CLK_QACCEPTN ,Indicates quiescence request is accepted RESET:0x1"
          
         bitfld.long 0x00 2. " RBB_SRAM4_Q_CH_CLK_QDENY ,Clock quiescence request denied RESET:0x0"
          
         bitfld.long 0x00 3. " RBB_SRAM4_Q_CH_CLK_QACTIVE ,It indicates when the component is active and also when it requests to exit from quiescence RESET:0x0"
          
         bitfld.long 0x00 4. " RBB_SRAM4_Q_CH_PWR_QREQN ,Power quiescence entry or exit request RESET:0x1"
          
         bitfld.long 0x00 5. " RBB_SRAM4_Q_CH_PWR_QACCEPTN ,Indicates quiescence request is accepted RESET:0x1"
          
         bitfld.long 0x00 6. " RBB_SRAM4_Q_CH_PWR_QDENY ,Clock quiescence request denied RESET:0x0"
          
         bitfld.long 0x00 7. " RBB_SRAM4_Q_CH_PWR_QACTIVE ,It indicates when the component is active and also when it requests to exit from quiescence RESET:0x0"
          
group.long  0xf0++0x3
    line.long 0x00 "RBB_LPDDR4_PHY_CFG, Config signals of LPDDR4 PUB/phy RESET:0x3"
         hexmask.long 0x00 0.--2. 1. " RBB_LPDDR4_PHY_CFG_PPROT_PIN ,Static value provided by SoC to check against pprot_apb. 011 = instruction access/non-secure/normal access RESET:0x3"
          
         bitfld.long 0x00 3. " RBB_LPDDR4_PHY_CFG_DFI0_ERROR ,DFI error RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " RBB_LPDDR4_PHY_CFG_DFI0_ERROR_INFO ,DFI error info RESET:0x0"
          
group.long  0xf4++0x3
    line.long 0x00 "RBB_CTRL_LPDDR4, LPDDR4 extra control signals RESET:0x7e0"
         bitfld.long 0x00 0. " RBB_CTRL_LPDDR4_RESET_LPDDR_N ,SW trigger for reset_lpddr_n RESET:0x0"
          
         bitfld.long 0x00 1. " RBB_CTRL_LPDDR4_RESET_LPDDR_NIC_N ,SW trigger for reset_lpddr_nic_n RESET:0x0"
          
         bitfld.long 0x00 2. " RBB_CTRL_LPDDR4_RESET_LPDDR_APB_N ,SW trigger for reset_lpddr_apb_n RESET:0x0"
          
         bitfld.long 0x00 3. " RBB_CTRL_LPDDR4_RESET_LPDDR_CTRL_N ,SW trigger for reset_lpddr_ctrl_n RESET:0x0"
          
         bitfld.long 0x00 4. " RBB_CTRL_LPDDR4_PWROKIN ,Used to indicate coldreset as well as Retention mode (s3) entry RESET:0x0"
          
         bitfld.long 0x00 5. " RBB_CTRL_LPDDR4_CSYSREQ ,AXI Low-Power Request, active low RESET:0x1"
          
         bitfld.long 0x00 6. " RBB_CTRL_LPDDR4_CSYSACK ,AXI Low-Power Request Acknowledge, active low RESET:0x1"
          
         bitfld.long 0x00 7. " RBB_CTRL_LPDDR4_CACTIVE ,AXI Clock Active, active low RESET:0x1"
          
         bitfld.long 0x00 8. " RBB_CTRL_LPDDR4_CSYSREQ_DDRC ,DDRC hardware Low-Power Request, active low RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_CTRL_LPDDR4_CSYSACK_DDRC ,DDRC hardware Low-Power Request Acknowledge, active low RESET:0x1"
          
         bitfld.long 0x00 10. " RBB_CTRL_LPDDR4_CACTIVE_DDRC ,DDRC hardware Clock Active, active low RESET:0x1"
          
         hexmask.long 0x00 11.--13. 1. " RBB_CTRL_LPDDR4_RAQ_WCOUNT ,Number of used positions in the Read address FIFO RESET:0x0"
          
         bitfld.long 0x00 14. " RBB_CTRL_LPDDR4_RAQ_POP ,Transaction read from the Read address FIFO RESET:0x0"
          
         bitfld.long 0x00 15. " RBB_CTRL_LPDDR4_RAQ_PUSH ,Transaction written to the Read address FIFO RESET:0x0"
          
         bitfld.long 0x00 16. " RBB_CTRL_LPDDR4_RAQ_SPLIT ,First portion of a wrap burst going to the Read address FIFO RESET:0x0"
          
         hexmask.long 0x00 17.--19. 1. " RBB_CTRL_LPDDR4_WAQ_WCOUNT ,Number of used positions in the Write address FIFO RESET:0x0"
          
         bitfld.long 0x00 20. " RBB_CTRL_LPDDR4_WAQ_POP ,Transaction read from the Write address FIFO RESET:0x0"
          
         bitfld.long 0x00 21. " RBB_CTRL_LPDDR4_WAQ_PUSH ,Transaction written to the Write address FIFO RESET:0x0"
          
         bitfld.long 0x00 22. " RBB_CTRL_LPDDR4_WAQ_SPLIT ,First portion of a wrap burst going to the Write address FIFO RESET:0x0"
          
         bitfld.long 0x00 23. " RBB_CTRL_LPDDR4_CTL_IDLE ,Signal to be used in conjunction with certain Synopsys PHYs only - to trigger the PHY's Anti-Aging feature RESET:0x0"
          
rgroup.long 0xf8++0x3
    line.long 0x00 "RBB_LPDDR4_CAM_STATUS, LPDDR4 signals to monitor the CAM RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " RBB_LPDDR4_CAM_STATUS_LPR_CREDIT_CNT ,Number of available Low priority read CAM (content-addressable memory) slots RESET:0x0"
          
         hexmask.long 0x00 7.--13. 1. " RBB_LPDDR4_CAM_STATUS_HPR_CREDIT_CNT ,Number of available High priority read CAM (content-addressable memory) slots RESET:0x0"
          
         hexmask.long 0x00 14.--20. 1. " RBB_LPDDR4_CAM_STATUS_WR_CREDIT_CNT ,Number of available write CAM (content-addressable memory) slots RESET:0x0"
          
group.long  0xfc++0x3
    line.long 0x00 "RBB_SYS_M4_CSR, Control and Status bits of sys_m4 RESET:0x4f"
         bitfld.long 0x00 0. " RBB_SYS_M4_CSR_DBGEN ,debug feature enable RESET:0x1"
          
         bitfld.long 0x00 1. " RBB_SYS_M4_CSR_LOCKUP ,Indicates core is locked up RESET:0x1"
          
         bitfld.long 0x00 2. " RBB_SYS_M4_CSR_FIXHMASTERTYPE ,If asserted, HMASTER of AHB-AP is always 1. AHB-AP always issues AHB transaction as DAP and cannot pretend it is the core RESET:0x1"
          
         bitfld.long 0x00 3. " RBB_SYS_M4_CSR_SLEEPHOLDREQN ,Request to extend sleep. Can only be asserted when SLEEPING is HIGH RESET:0x1"
          
         bitfld.long 0x00 4. " RBB_SYS_M4_CSR_SLEEPHOLDACKN ,Acknowledge signal for SLEEPHOLDREQn RESET:0x0"
          
         bitfld.long 0x00 5. " RBB_SYS_M4_CSR_DBGRESTARTED ,handshake for exit from halt mode (live). RESET:0x0"
          
         bitfld.long 0x00 6. " RBB_SYS_M4_CSR_ETMPWRUP ,This bit enables PC monitoring via m4_pc register RESET:0x1"
          
rgroup.long 0x100++0x3
    line.long 0x00 "RBB_SYS_M85_CSR, None RESET:0x0"
         bitfld.long 0x00 0. " RBB_SYS_M85_CSR_DBGRESTARTED ,handshake for exit from halt mode (live). RESET:0x0"
          
group.long  0x104++0x3
    line.long 0x00 "RBB_FPGA_TOP_OUT_0, FPGA top output reg 0, writeable, for additional top level outs RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " RBB_FPGA_TOP_OUT_0_OUTS ,None RESET:0x0"
          
rgroup.long 0x108++0x3
    line.long 0x00 "RBB_FPGA_TOP_INP_0, FPGA top input reg 0, read only, for additional top level inputs RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " RBB_FPGA_TOP_INP_0_INPS ,None RESET:0x0"
          
group.long  0x10c++0x3
    line.long 0x00 "RBB_FPGA_INT_CTRL, FPGA internal control reg RESET:0x0"
         bitfld.long 0x00 0. " RBB_FPGA_INT_CTRL_DPHY_CAM_SELECT ,None RESET:0x0"
          
rgroup.long 0x110++0x3
    line.long 0x00 "RBB_FPGA_INT_STATUS, FPGA internal status reg RESET:0x0"
         bitfld.long 0x00 0. " RBB_FPGA_INT_STATUS_DDR4_INIT_CALIB_COMPLETE ,Indicates when DDR4 PHY calibration is finished RESET:0x0"
          
         hexmask.long 0x00 1.--9. 1. " RBB_FPGA_INT_STATUS_OTHER_INPS ,Other status bits RESET:0x0"
          
group.long  0x114++0x3
    line.long 0x00 "RBB_NIC400_CLKEN, Clock enable signals for NIC400 domains RESET:0xffff"
         bitfld.long 0x00 0. " RBB_NIC400_CLKEN_CAMERA ,Enable clk_nic_camera clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 1. " RBB_NIC400_CLKEN_DCU ,Enable clk_nic_dcu clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 2. " RBB_NIC400_CLKEN_DMA ,Enable clk_nic_dma clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 3. " RBB_NIC400_CLKEN_EMMC ,Enable clk_nic_emmc clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 4. " RBB_NIC400_CLKEN_ETHERNET ,Enable clk_nic_ethernet clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 5. " RBB_NIC400_CLKEN_GPU ,Enable clk_nic_gpu clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 6. " RBB_NIC400_CLKEN_HALF ,Enable clk_nic_half clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 7. " RBB_NIC400_CLKEN_M85 ,Enable clk_nic_m85 clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 8. " RBB_NIC400_CLKEN_ZBB ,Enable clk_nic_zbb clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 9. " RBB_NIC400_CLKEN_CFG ,Enable clk_nic_cfg clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 10. " RBB_NIC400_CLKEN_ETHOS ,Enable clk_nic_ethos clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 11. " RBB_NIC400_CLKEN_LPDDR ,Enable clk_nic_lpddr clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 12. " RBB_NIC400_CLKEN_H264 ,Enable clk_nic_h264 clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 13. " RBB_NIC400_CLKEN_I2S_M ,Enable clk_nic_i2s_m clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 14. " RBB_NIC400_CLKEN_LPDDR_CFG ,Enable clk_nic_lpddr_cfg clock domain on NIC RESET:0x1"
          
         bitfld.long 0x00 15. " RBB_NIC400_CLKEN_QSPI_DISP ,Enable clk_nic_qspi_disp clock domain on NIC RESET:0x1"
          
rgroup.long 0x118++0x3
    line.long 0x00 "RBB_M4_PC, Program Counter of ARM CM4. Note: this value is not guaranteed to be cycle accurate. Only available on ASIC RESET:0x0"
         bitfld.long 0x00 0. " RBB_M4_PC_BIT_0 ,None RESET:0x0"
          
         hexmask.long 0x00 1.--31. 1. " RBB_M4_PC_BIT_31_1 ,None RESET:0x0"
          
group.long  0x11c++0x3
    line.long 0x00 "RBB_ARMCM_DBG_CT, Enable/disable cross-trigger for processors debug mode RESET:0x0"
         bitfld.long 0x00 0. " RBB_ARMCM_DBG_CT_DISABLE_CM4_CT ,0: M85 debug mode entry/exit also triggers M4 debug mode entry/exit. 1: independed debug modes of processors RESET:0x0"
          
         bitfld.long 0x00 1. " RBB_ARMCM_DBG_CT_DISABLE_CM85_CT ,0: M4 debug mode entry/exit also triggers M85 debug mode entry/exit. 1: independed debug modes of processors RESET:0x0"
          
group.long  0x120++0x3
    line.long 0x00 "RBB_NIC400_FORCE_ERROR_RESP, Enable/disable NIC400 error reponse on peripherals in shut-off domain. Setting the bit to 1 will enable the error response; Else, default response from slave is forwarded. Note: The bits can be toggled only when there is no active transaction to the interfaces that are under isolation. Else, there is a risk of undefined behavior (E.g.: metastability) RESET:0x0"
         bitfld.long 0x00 0. " RBB_NIC400_FORCE_ERROR_RESP_SYS_DISPLAY ,See register description RESET:0x0"
          
         bitfld.long 0x00 1. " RBB_NIC400_FORCE_ERROR_RESP_SYS_GPU ,See register description RESET:0x0"
          
         bitfld.long 0x00 2. " RBB_NIC400_FORCE_ERROR_RESP_SYS_ETHOS ,See register description RESET:0x0"
          
         bitfld.long 0x00 3. " RBB_NIC400_FORCE_ERROR_RESP_SYS_LPDDR4 ,See register description RESET:0x0"
          
         bitfld.long 0x00 4. " RBB_NIC400_FORCE_ERROR_RESP_SYS_M85 ,See register description RESET:0x0"
          
         bitfld.long 0x00 5. " RBB_NIC400_FORCE_ERROR_RESP_SYS_CAMERA ,See register description RESET:0x0"
          
         bitfld.long 0x00 6. " RBB_NIC400_FORCE_ERROR_RESP_SYS_ETHERNET ,See register description RESET:0x0"
          
         bitfld.long 0x00 7. " RBB_NIC400_FORCE_ERROR_RESP_SYS_EMMC ,See register description RESET:0x0"
          
         bitfld.long 0x00 8. " RBB_NIC400_FORCE_ERROR_RESP_SYS_H264 ,See register description RESET:0x0"
          
group.long  0x124++0x3
    line.long 0x00 "RBB_SRAM_1P_CONFIG, RI_SRAM one-port configuration register RESET:0xf"
         bitfld.long 0x00 0. " RBB_SRAM_1P_CONFIG_AE ,Assist enable RESET:0x1"
          
         bitfld.long 0x00 1. " RBB_SRAM_1P_CONFIG_DLV ,Additional delay setting RESET:0x1"
          
         hexmask.long 0x00 2.--4. 1. " RBB_SRAM_1P_CONFIG_DLY ,Delay setting RESET:0x3"
          
group.long  0x128++0x3
    line.long 0x00 "RBB_SRAM_2P_CONFIG, RI_SRAM two-port configuration register RESET:0x24"
         hexmask.long 0x00 0.--2. 1. " RBB_SRAM_2P_CONFIG_DLY_W ,Write delay setting RESET:0x4"
          
         hexmask.long 0x00 3.--5. 1. " RBB_SRAM_2P_CONFIG_DLY_R ,Read delay setting RESET:0x4"
          
         bitfld.long 0x00 6. " RBB_SRAM_2P_CONFIG_WAE ,Write Assist Enable. Recommended value depends on operating corner; please see Racyics SRAM datasheet. RESET:0x0"
          
         bitfld.long 0x00 7. " RBB_SRAM_2P_CONFIG_RAE ,Read Assist Enable. Recommended value depends on operating corner; please see Racyics SRAM datasheet. RESET:0x0"
          
group.long  0x12c++0x3
    line.long 0x00 "RBB_ROM_CONFIG, RI_ROM configuration register RESET:0x2"
         bitfld.long 0x00 0. " RBB_ROM_CONFIG_DLY_V ,Delay setting v RESET:0x0"
          
         hexmask.long 0x00 1.--2. 1. " RBB_ROM_CONFIG_DLY_R ,Delay setting r RESET:0x1"
          
tree.end

tree "M85"
base e:0x40001000
width 80.
group.long  0x0++0x3
    line.long 0x00 "M85_CONTROL_INITSVTOR, M85 secure vector start address RESET:0x20000"
         hexmask.long 0x00 0.--24. 1. " M85_CONTROL_INITSVTOR_INITSVTOR ,upper 25 bits of the M85 32-bit secure vector start address RESET:0x20000"
          
group.long  0x4++0x3
    line.long 0x00 "M85_CONTROL_INITNSVTOR, M85 non-secure vector start address RESET:0x20000"
         hexmask.long 0x00 0.--24. 1. " M85_CONTROL_INITNSVTOR_INITNSVTOR ,upper 25 bits of the M85 32-bit non-secure vector start address RESET:0x20000"
          
rgroup.long 0x8++0x3
    line.long 0x00 "M85_STATUS_CURRPC, M85 instruction debug RESET:0x0"
         bitfld.long 0x00 0. " M85_STATUS_CURRPC_CURRNS ,M85 security state indicator RESET:0x0"
          
         hexmask.long 0x00 1.--31. 1. " M85_STATUS_CURRPC_CURRPC ,M85 program counter RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "M85_STATUS_FAULTSTAT, M85 fault status 32 LSB RESET:0x0"
         bitfld.long 0x00 0. " M85_STATUS_FAULTSTAT_FAULTSTAT ,M85 fault status LSB RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "M85_STATUS_FAULTSTAT2, M85 fault status 11 MSB RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " M85_STATUS_FAULTSTAT2_FAULTSTAT ,M85 fault status MSB RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "M85_STATUS_CPUWAIT, M85 instruction execution control signals RESET:0x1"
         bitfld.long 0x00 0. " M85_STATUS_CPUWAIT_CPUWAIT ,Stall M85 out of reset RESET:0x1"
          
group.long  0x18++0x3
    line.long 0x00 "M85_CONTROL_DEBUG, M85 debug control RESET:0xf"
         bitfld.long 0x00 0. " M85_CONTROL_DEBUG_DBGEN ,invasive debug enable RESET:0x1"
          
         bitfld.long 0x00 1. " M85_CONTROL_DEBUG_NIDEN ,non-invasive debug enable RESET:0x1"
          
         bitfld.long 0x00 2. " M85_CONTROL_DEBUG_SPIDEN ,secure invasive debug enable RESET:0x1"
          
         bitfld.long 0x00 3. " M85_CONTROL_DEBUG_SPNIDEN ,secure non-invasive debug enable RESET:0x1"
          
group.long  0x1c++0x3
    line.long 0x00 "M85_CONTROL_LOCK, M85 locks RESET:0x0"
         bitfld.long 0x00 0. " M85_CONTROL_LOCK_LOCKSVTAIRCR ,write disable to special secure registers RESET:0x0"
          
         bitfld.long 0x00 1. " M85_CONTROL_LOCK_LOCKNSVTOR ,write disable to VTOR_NS register RESET:0x0"
          
         bitfld.long 0x00 2. " M85_CONTROL_LOCK_LOCKSMPU ,write disable to secure MPU region RESET:0x0"
          
         bitfld.long 0x00 3. " M85_CONTROL_LOCK_LOCKNSMPU ,write disable to non-secure MPU region RESET:0x0"
          
         bitfld.long 0x00 4. " M85_CONTROL_LOCK_LOCKSAU ,write disable to SAU region RESET:0x0"
          
         bitfld.long 0x00 5. " M85_CONTROL_LOCK_LOCKTCM ,write disable to TCM region RESET:0x0"
          
         bitfld.long 0x00 6. " M85_CONTROL_LOCK_LOCKITGU ,write disable to ITCM related security registers RESET:0x0"
          
         bitfld.long 0x00 7. " M85_CONTROL_LOCK_LOCKDTGU ,write disable to DTCM related security registers RESET:0x0"
          
         bitfld.long 0x00 8. " M85_CONTROL_LOCK_LOCKPAHB ,write disable to PAHBCR register RESET:0x0"
          
         bitfld.long 0x00 9. " M85_CONTROL_LOCK_LOCKDCAIC ,access disable to instrauction cache registers RESET:0x0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "M85_CONTROL_EVENT, M85 event signals RESET:0x0"
         bitfld.long 0x00 0. " M85_CONTROL_EVENT_LOCKUP ,Signals that the processor is in the architected lockup state because of an unrecoverable exception. RESET:0x0"
          
rgroup.long 0x24++0x3
    line.long 0x00 "M85_STATUS_FP_ERROR, M85 floating point exceptions RESET:0x0"
         bitfld.long 0x00 0. " M85_STATUS_FP_ERROR_FPIXC ,masked floating point inexact exception RESET:0x0"
          
         bitfld.long 0x00 1. " M85_STATUS_FP_ERROR_FPIDC ,masked floating point input denormal exception RESET:0x0"
          
         bitfld.long 0x00 2. " M85_STATUS_FP_ERROR_FPOFC ,masked floating point overflow exception RESET:0x0"
          
         bitfld.long 0x00 3. " M85_STATUS_FP_ERROR_FPUFC ,masked floating point underflow exception RESET:0x0"
          
         bitfld.long 0x00 4. " M85_STATUS_FP_ERROR_FPDZC ,masked floating point divide-by-zero exception RESET:0x0"
          
         bitfld.long 0x00 5. " M85_STATUS_FP_ERROR_FPIOC ,invalid operation RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "M85_P_CHANNEL_CORE, Handshake signals of the P and Q channels of M85 RESET:0x30"
         bitfld.long 0x00 0. " M85_P_CHANNEL_CORE_COREPREQ ,Request to transition to power mode indicated by COREPSTATE RESET:0x0"
          
         hexmask.long 0x00 1.--5. 1. " M85_P_CHANNEL_CORE_COREPSTATE ,Requested power mode RESET:0x18"
          
         bitfld.long 0x00 6. " M85_P_CHANNEL_CORE_COREPACCEPT ,Acceptance of the transition to the requested power mode RESET:0x0"
          
         bitfld.long 0x00 7. " M85_P_CHANNEL_CORE_COREPDENY ,Denial of the power mode transition request RESET:0x0"
          
         hexmask.long 0x00 8.--28. 1. " M85_P_CHANNEL_CORE_COREPACTIVE ,Request for a power mode RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "M85_Q_CHANNELS, Handshake signals of the Q channels of M85 RESET:0x3ccc3"
         bitfld.long 0x00 0. " M85_Q_CHANNELS_PWRDGBQREQN ,Debug domain power control Q-Channel quiescence request signal RESET:0x1"
          
         bitfld.long 0x00 1. " M85_Q_CHANNELS_PWRDBGQACCEPTN ,Debug domain power control Q-Channel quiescence request accepted RESET:0x1"
          
         bitfld.long 0x00 2. " M85_Q_CHANNELS_PWRDBGQDENY ,Debug domain power control Q-Channel quiescence request denied RESET:0x0"
          
         bitfld.long 0x00 3. " M85_Q_CHANNELS_PWRDBGQACTIVE ,Debug power control Q-Channel logic active or activation request RESET:0x0"
          
         bitfld.long 0x00 4. " M85_Q_CHANNELS_PWRCOREWAKEPACTIVE ,Assert when DAP requests access to an address in PDCORE RESET:0x0"
          
         bitfld.long 0x00 5. " M85_Q_CHANNELS_PWRDBGWAKEQACTIVE ,Assert when DAP requests access to an address in MCU or external EPPB RESET:0x0"
          
         bitfld.long 0x00 6. " M85_Q_CHANNELS_CLKINQREQN ,CLKIN Q-Channel quiescence request signal RESET:0x1"
          
         bitfld.long 0x00 7. " M85_Q_CHANNELS_CLKINQACCEPTN ,CLKIN Q-Channel quiescence request accepted RESET:0x1"
          
         bitfld.long 0x00 8. " M85_Q_CHANNELS_CLKINQDENY ,CLKIN Q-Channel quiescence request denied RESET:0x0"
          
         bitfld.long 0x00 9. " M85_Q_CHANNELS_CLKINQACTIVE ,CLKIN Q-Channel logic active or activation request RESET:0x0"
          
         bitfld.long 0x00 10. " M85_Q_CHANNELS_DBGCLKQREQN ,DBGCLK Q-Channel quiescence request signal RESET:0x1"
          
         bitfld.long 0x00 11. " M85_Q_CHANNELS_DBGCLKQACCEPTN ,DBGCLK Q-Channel quiescence request accepted RESET:0x1"
          
         bitfld.long 0x00 12. " M85_Q_CHANNELS_DBGCLKQDENY ,DBGCLK Q-Channel quiescence request denied RESET:0x0"
          
         bitfld.long 0x00 13. " M85_Q_CHANNELS_DBGCLKQACTIVE ,DBGCLK Q-Channel logic active or activation request RESET:0x0"
          
         hexmask.long 0x00 14.--15. 1. " M85_Q_CHANNELS_CLKQREQN ,Q-Channel quiescence request signal RESET:0x3"
          
         hexmask.long 0x00 16.--17. 1. " M85_Q_CHANNELS_CLKQACCEPTN ,Q-Channel quiescence request accepted RESET:0x3"
          
         hexmask.long 0x00 18.--19. 1. " M85_Q_CHANNELS_CLKQDENY ,Q-Channel quiescence request denied RESET:0x0"
          
         hexmask.long 0x00 20.--21. 1. " M85_Q_CHANNELS_CLKQACTIVE ,Q-Channel logic active or activation request RESET:0x0"
          
rgroup.long 0x30++0x3
    line.long 0x00 "M85_PC, Program Counter of ARM CM85. Note: this value is not guaranteed to be cycle accurate. Only available on ASIC RESET:0x0"
         bitfld.long 0x00 0. " M85_PC_BIT_0 ,None RESET:0x0"
          
         hexmask.long 0x00 1.--31. 1. " M85_PC_BIT_31_1 ,None RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "M85_RST_CTRL, SW reset control RESET:0x0"
         bitfld.long 0x00 0. " M85_RST_CTRL_SW_RESET_M85_N ,SW trigger for reset_m85_n, active low. Tied-off to 1 in FPGA. RESET:0x0"
          
tree.end

tree "ETHOS_U85"
base e:0x40002000
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "ETHOS_U85_ID, ID register RESET:0xdddddddd"
         hexmask.long 0x00 0.--3. 1. " ETHOS_U85_ID_VERSION_STATUS ,This value is the version of the product RESET:0xd"
          
         hexmask.long 0x00 4.--7. 1. " ETHOS_U85_ID_VERSION_MINOR ,This value is the n for the P part of an RnPn release number RESET:0xd"
          
         hexmask.long 0x00 8.--11. 1. " ETHOS_U85_ID_VERSION_MAJOR ,This value is the n for the R part of an RnPn release number RESET:0xd"
          
         hexmask.long 0x00 12.--15. 1. " ETHOS_U85_ID_PRODUCT_MAJOR ,Product major ID number (unique per base product) RESET:0xd"
          
         hexmask.long 0x00 16.--19. 1. " ETHOS_U85_ID_ARCH_PATCH_REV ,This value is the patch number of the architecture version a.b RESET:0xd"
          
         hexmask.long 0x00 20.--27. 1. " ETHOS_U85_ID_ARCH_MINOR_REV ,This value is the minor architecture version number, b in the architecture version a.b RESET:0xdd"
          
         hexmask.long 0x00 28.--31. 1. " ETHOS_U85_ID_ARCH_MAJOR_REV ,This value is the major architecture version number, a in the architecture version a.b RESET:0xd"
          
rgroup.long 0x4++0x3
    line.long 0x00 "ETHOS_U85_STATUS, Register describes the current operating status of the NPU RESET:0x8"
         bitfld.long 0x00 0. " ETHOS_U85_STATUS_STATE ,0 = NPU is in stopped state. 1 = NPU is in running state RESET:0x0"
          
         bitfld.long 0x00 1. " ETHOS_U85_STATUS_IRQ_RAISED ,0 = IRQ not raised. 1 = IRQ raised RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_U85_STATUS_BUS_STATUS ,0 = No bus fault. 1 = Bus abort detected and processing halted RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_U85_STATUS_RESET_STATUS ,0 = No reset in progress. 1 = Reset in progress RESET:0x1"
          
         bitfld.long 0x00 4. " ETHOS_U85_STATUS_CMD_PARSE_ERROR ,0 = No parsing error. 1 = Command stream parsing error detected RESET:0x0"
          
         bitfld.long 0x00 5. " ETHOS_U85_STATUS_CMD_END_REACHED ,0 = Command stream end is not reached. 1 = Command stream end is reached RESET:0x0"
          
         bitfld.long 0x00 6. " ETHOS_U85_STATUS_PMU_IRQ_RAISED ,0 = No PMU IRQ raised. 1 = PMU IRQ raised RESET:0x0"
          
         bitfld.long 0x00 7. " ETHOS_U85_STATUS_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 8. " ETHOS_U85_STATUS_ECC_FAULT ,0 = No ECC fault detected. 1 = ECC fault detected RESET:0x0"
          
         bitfld.long 0x00 9. " ETHOS_U85_STATUS_BRANCH_FAULT ,0 = No branch fault. 1 = Branch fault detected RESET:0x0"
          
         bitfld.long 0x00 10. " ETHOS_U85_STATUS_RES1 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 11. " ETHOS_U85_STATUS_FAULTING_INTERFACE ,The faulting interface on bus abort RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " ETHOS_U85_STATUS_FAULTING_CHANNEL ,The faulting channel on a bus abort RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETHOS_U85_STATUS_IRQ_HISTORY_MASK ,The IRQ History mask RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "ETHOS_U85_CMD, The command register. This register reads as last written command RESET:0xc"
         bitfld.long 0x00 0. " ETHOS_U85_CMD_TRANSITION_TO_RUNNING_STATE ,Write 1 to transition the NPU to running state. Writing 0 has no effect RESET:0x0"
          
         bitfld.long 0x00 1. " ETHOS_U85_CMD_CLEAR_IRQ ,Write 1 to clear the IRQ status in the STATUS register. Writing 0 has no effect RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_U85_CMD_CLOCK_Q_ENABLE ,Write 1 to this bit to enable clock off using clock q-interface and enable the requester clock gate RESET:0x1"
          
         bitfld.long 0x00 3. " ETHOS_U85_CMD_POWER_Q_ENABLE ,Write 1 to this bit to enable power off using power q-interface RESET:0x1"
          
         bitfld.long 0x00 4. " ETHOS_U85_CMD_STOP_REQUEST ,Write 1 to this bit to request STOP after completing any already-started commands RESET:0x0"
          
         hexmask.long 0x00 5.--15. 1. " ETHOS_U85_CMD_RES0 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETHOS_U85_CMD_CLEAR_IRQ_HISTORY ,Clears the IRQ history mask RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETHOS_U85_RESET, Request reset and new security mode RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_U85_RESET_PENDING_CPL ,Current privilege level. 0 = User and 1 = Privileged RESET:0x0"
          
         bitfld.long 0x00 1. " ETHOS_U85_RESET_PENDING_CSL ,Current security level. 0 = Secure and 1 = Non-secure RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " ETHOS_U85_RESET_RES0 ,Reserved field RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ETHOS_U85_QBASE, The base address of the command stream in bytes RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_QBASE_OFFSET ,Offset RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "ETHOS_U85_QBASE_HI, The base address of the command stream in bytes (higher bits) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHOS_U85_QBASE_HI_OFFSET ,Offset RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_QBASE_HI_RES0 ,Reserved field RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETHOS_U85_QREAD, The read offset in the command stream in bytes. Multiple of four in the range 0-16MB RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_QREAD_QREAD ,The read offset of the current command under execution RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "ETHOS_U85_QCONFIG, The AXI configuration for the command stream in the range 0-3. Same encoding as for REGIONCFG RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETHOS_U85_QCONFIG_CMD_REGION0 ,The command region configuration number RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " ETHOS_U85_QCONFIG_RES0 ,Reserved field RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "ETHOS_U85_QSIZE, The size of the command stream in bytes. Multiple of four in the range 0-16MB RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_QSIZE_QSIZE ,The size of the next command stream to be executed by the NPU RESET:0x0"
          
rgroup.long 0x24++0x3
    line.long 0x00 "ETHOS_U85_PROT, The protection level configured for the NPU when acting as an AXI Requester RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_U85_PROT_ACTIVE_CPL ,The current privilege level. 0 = User and 1 = Privileged RESET:0x0"
          
         bitfld.long 0x00 1. " ETHOS_U85_PROT_ACTIVE_CSL ,The current security level 0=Secure 1=Non secure RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " ETHOS_U85_PROT_RES0 ,Reserved field RESET:0x0"
          
rgroup.long 0x28++0x3
    line.long 0x00 "ETHOS_U85_CONFIG, RTL configuration RESET:0xcccccccc"
         hexmask.long 0x00 0.--3. 1. " ETHOS_U85_CONFIG_MACS_PER_CC ,The log2(macs/clock cycle) RESET:0xc"
          
         hexmask.long 0x00 4.--7. 1. " ETHOS_U85_CONFIG_CMD_STREAM_VERSION ,The command stream version accepted by this NPU RESET:0xc"
          
         hexmask.long 0x00 8.--9. 1. " ETHOS_U85_CONFIG_NUM_AXI_SRAM ,The log2 of the number of AXI SRAM interfaces RESET:0x0"
          
         bitfld.long 0x00 10. " ETHOS_U85_CONFIG_NUM_AXI_EXT ,The log2 of the number of AXI External memory interfaces RESET:0x1"
          
         bitfld.long 0x00 11. " ETHOS_U85_CONFIG_RES0 ,Reserved field RESET:0x1"
          
         hexmask.long 0x00 12.--13. 1. " ETHOS_U85_CONFIG_NUM_WD ,The log2 of the number of standard weight decoders RESET:0x0"
          
         hexmask.long 0x00 14.--26. 1. " ETHOS_U85_CONFIG_RES1 ,Reserved field RESET:0x1333"
          
         bitfld.long 0x00 27. " ETHOS_U85_CONFIG_CUSTOM_DMA ,The custom DMA configuration RESET:0x1"
          
         hexmask.long 0x00 28.--31. 1. " ETHOS_U85_CONFIG_PRODUCT ,The product configuration RESET:0xc"
          
rgroup.long 0x30++0x3
    line.long 0x00 "ETHOS_U85_COND_STATUS, Condition status of the NPU RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_U85_COND_STATUS_RESULT_FLAG ,The tensor result flag. For OFM with a single element, this is bit 0 of the value. Otherwise UNPREDICTABLE RESET:0x0"
          
         hexmask.long 0x00 1.--31. 1. " ETHOS_U85_COND_STATUS_RES0 ,Reserved field RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "ETHOS_U85_POWER_CTRL, Power control register RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " ETHOS_U85_POWER_CTRL_MAC_STEP_CYCLES ,MAC power ramping up/down control RESET:0x0"
          
         hexmask.long 0x00 6.--31. 1. " ETHOS_U85_POWER_CTRL_RES0 ,Reserved field RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "ETHOS_U85_REGIONCFG, Specify which MEM_ATTR register applies to each region RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETHOS_U85_REGIONCFG_REGION0 ,Bits for Region0 Configuration RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " ETHOS_U85_REGIONCFG_REGION1 ,Bits for Region1 Configuration RESET:0x0"
          
         hexmask.long 0x00 4.--5. 1. " ETHOS_U85_REGIONCFG_REGION2 ,Bits for Region2 Configuration RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " ETHOS_U85_REGIONCFG_REGION3 ,Bits for Region3 Configuration RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " ETHOS_U85_REGIONCFG_REGION4 ,Bits for Region4 Configuration RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " ETHOS_U85_REGIONCFG_REGION5 ,Bits for Region5 Configuration RESET:0x0"
          
         hexmask.long 0x00 12.--13. 1. " ETHOS_U85_REGIONCFG_REGION6 ,Bits for Region6 Configuration RESET:0x0"
          
         hexmask.long 0x00 14.--15. 1. " ETHOS_U85_REGIONCFG_REGION7 ,Bits for Region7 Configuration RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETHOS_U85_REGIONCFG_RES0 ,Reserved field RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "ETHOS_U85_MEM_ATTR0, Memory attributes 0 RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETHOS_U85_MEM_ATTR0_MEM_DOMAIN ,Memory domain RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_U85_MEM_ATTR0_AXI_PORT ,AXI port select RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_U85_MEM_ATTR0_RES0 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " ETHOS_U85_MEM_ATTR0_MEMTYPE ,Memtype to be used to encode AxCACHE signals RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_MEM_ATTR0_RES1 ,Reserved field RESET:0x0"
          
group.long  0x44++0x3
    line.long 0x00 "ETHOS_U85_MEM_ATTR1, Memory attributes 1 RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETHOS_U85_MEM_ATTR1_MEM_DOMAIN ,Memory domain RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_U85_MEM_ATTR1_AXI_PORT ,AXI port select RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_U85_MEM_ATTR1_RES0 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " ETHOS_U85_MEM_ATTR1_MEMTYPE ,Memtype to be used to encode AxCACHE signals RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_MEM_ATTR1_RES1 ,Reserved field RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "ETHOS_U85_MEM_ATTR2, Memory attributes 2 RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETHOS_U85_MEM_ATTR2_MEM_DOMAIN ,Memory domain RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_U85_MEM_ATTR2_AXI_PORT ,AXI port select RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_U85_MEM_ATTR2_RES0 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " ETHOS_U85_MEM_ATTR2_MEMTYPE ,Memtype to be used to encode AxCACHE signals RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_MEM_ATTR2_RES1 ,Reserved field RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "ETHOS_U85_MEM_ATTR3, Memory attributes 3 RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETHOS_U85_MEM_ATTR3_MEM_DOMAIN ,Memory domain RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_U85_MEM_ATTR3_AXI_PORT ,AXI port select RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_U85_MEM_ATTR3_RES0 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " ETHOS_U85_MEM_ATTR3_MEMTYPE ,Memtype to be used to encode AxCACHE signals RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_MEM_ATTR3_RES1 ,Reserved field RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "ETHOS_U85_AXI_SRAM, The AXI configuration for SRAM ports RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " ETHOS_U85_AXI_SRAM_MAX_OUTSTANDING_READ_M1 ,Maximum number of outstanding AXI read transactions per port - 1 RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " ETHOS_U85_AXI_SRAM_RES0 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 8.--12. 1. " ETHOS_U85_AXI_SRAM_MAX_OUTSTANDING_WRITE_M1 ,Maximum number of outstanding AXI write transactions per port - 1 RESET:0x0"
          
         hexmask.long 0x00 13.--15. 1. " ETHOS_U85_AXI_SRAM_RES1 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 16.--17. 1. " ETHOS_U85_AXI_SRAM_MAX_BEATS ,Burst split alignment RESET:0x0"
          
         hexmask.long 0x00 18.--31. 1. " ETHOS_U85_AXI_SRAM_RES2 ,Reserved field RESET:0x0"
          
group.long  0x54++0x3
    line.long 0x00 "ETHOS_U85_AXI_EXT, The AXI configuration for EXT ports RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " ETHOS_U85_AXI_EXT_MAX_OUTSTANDING_READ_M1 ,Maximum number of outstanding AXI read transactions per port - 1 RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " ETHOS_U85_AXI_EXT_RES0 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 8.--12. 1. " ETHOS_U85_AXI_EXT_MAX_OUTSTANDING_WRITE_M1 ,Maximum number of outstanding AXI write transactions per port - 1 RESET:0x0"
          
         hexmask.long 0x00 13.--15. 1. " ETHOS_U85_AXI_EXT_RES1 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 16.--17. 1. " ETHOS_U85_AXI_EXT_MAX_BEATS ,Burst split alignment RESET:0x0"
          
         hexmask.long 0x00 18.--31. 1. " ETHOS_U85_AXI_EXT_RES2 ,Reserved field RESET:0x0"
          
rgroup.long 0x60++0x3
    line.long 0x00 "ETHOS_U85_CFG_SRAM_CAP, The value of the CFGSRAMCAP pins, SRAM AXI ports cap RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " ETHOS_U85_CFG_SRAM_CAP_MAX_OUTSTANDING_READ_M1 ,Maximum number of outstanding AXI read transactions per port - 1 RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " ETHOS_U85_CFG_SRAM_CAP_RES0 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 8.--12. 1. " ETHOS_U85_CFG_SRAM_CAP_MAX_OUTSTANDING_WRITE_M1 ,Maximum number of outstanding AXI write transactions per port - 1 RESET:0x0"
          
         hexmask.long 0x00 13.--15. 1. " ETHOS_U85_CFG_SRAM_CAP_RES1 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 16.--17. 1. " ETHOS_U85_CFG_SRAM_CAP_MAX_BEATS ,Burst split alignment RESET:0x0"
          
         hexmask.long 0x00 18.--31. 1. " ETHOS_U85_CFG_SRAM_CAP_RES2 ,Reserved field RESET:0x0"
          
rgroup.long 0x64++0x3
    line.long 0x00 "ETHOS_U85_CFG_EXT_CAP, The value of the CFGEXTCAP pins, EXT AXI ports cap RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " ETHOS_U85_CFG_EXT_CAP_MAX_OUTSTANDING_READ_M1 ,Maximum number of outstanding AXI read transactions per port - 1 RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " ETHOS_U85_CFG_EXT_CAP_RES0 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 8.--12. 1. " ETHOS_U85_CFG_EXT_CAP_MAX_OUTSTANDING_WRITE_M1 ,Maximum number of outstanding AXI write transactions per port - 1 RESET:0x0"
          
         hexmask.long 0x00 13.--15. 1. " ETHOS_U85_CFG_EXT_CAP_RES1 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 16.--17. 1. " ETHOS_U85_CFG_EXT_CAP_MAX_BEATS ,Burst split alignment RESET:0x0"
          
         hexmask.long 0x00 18.--31. 1. " ETHOS_U85_CFG_EXT_CAP_RES2 ,Reserved field RESET:0x0"
          
rgroup.long 0x68++0x3
    line.long 0x00 "ETHOS_U85_CFG_SRAM_HASH0, The value of the CFGSRAMHASH0 pins, SRAM AXI port select bit 0 hash RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " ETHOS_U85_CFG_SRAM_HASH0_ZERO ,Must be zero RESET:0x0"
          
         hexmask.long 0x00 6.--31. 1. " ETHOS_U85_CFG_SRAM_HASH0_HASH ,Hash function RESET:0x0"
          
rgroup.long 0x6c++0x3
    line.long 0x00 "ETHOS_U85_CFG_SRAM_HASH0_HI, The value of the CFGSRAMHASH0 pins, SRAM AXI port select bit 0 hash (higher bits) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHOS_U85_CFG_SRAM_HASH0_HI_HASH ,Hash function RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_CFG_SRAM_HASH0_HI_RES0 ,Reserved field RESET:0x0"
          
rgroup.long 0x70++0x3
    line.long 0x00 "ETHOS_U85_CFG_SRAM_HASH1, The value of the CFGSRAMHASH1 pins, SRAM AXI port select bit 1 hash RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " ETHOS_U85_CFG_SRAM_HASH1_ZERO ,Must be zero RESET:0x0"
          
         hexmask.long 0x00 6.--31. 1. " ETHOS_U85_CFG_SRAM_HASH1_HASH ,Hash function RESET:0x0"
          
rgroup.long 0x74++0x3
    line.long 0x00 "ETHOS_U85_CFG_SRAM_HASH1_HI, The value of the CFGSRAMHASH1 pins, SRAM AXI port select bit 1 hash (higher bits) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHOS_U85_CFG_SRAM_HASH1_HI_HASH ,Hash function RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_CFG_SRAM_HASH1_HI_RES0 ,Reserved field RESET:0x0"
          
rgroup.long 0x78++0x3
    line.long 0x00 "ETHOS_U85_CFG_EXT_HASH0, The value of the CFGEXTHASH0  pins, EXT AXI port select bit 0 hash RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " ETHOS_U85_CFG_EXT_HASH0_ZERO ,Must be zero RESET:0x0"
          
         hexmask.long 0x00 6.--31. 1. " ETHOS_U85_CFG_EXT_HASH0_HASH ,Hash function RESET:0x0"
          
rgroup.long 0x7c++0x3
    line.long 0x00 "ETHOS_U85_CFG_EXT_HASH0_HI, The value of the CFGEXTHASH0  pins, EXT AXI port select bit 0 hash (higher bits) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHOS_U85_CFG_EXT_HASH0_HI_HASH ,Hash function RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_CFG_EXT_HASH0_HI_RES0 ,Reserved field RESET:0x0"
          
group.long  0x80++0x3
    line.long 0x00 "ETHOS_U85_BASEP0, AXI base address of the respective region number 0 - 7 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_BASEP0_OFFSET ,Offset RESET:0x0"
          
group.long  0x84++0x3
    line.long 0x00 "ETHOS_U85_BASEP0_HI, AXI base address of the respective region number 0 - 7 (higher bits) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHOS_U85_BASEP0_HI_OFFSET ,Offset RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_BASEP0_HI_RES0 ,Reserved field RESET:0x0"
          
group.long  0x88++0x3
    line.long 0x00 "ETHOS_U85_BASEP1, AXI base address of the respective region number 0 - 7 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_BASEP1_OFFSET ,Offset RESET:0x0"
          
group.long  0x8c++0x3
    line.long 0x00 "ETHOS_U85_BASEP1_HI, AXI base address of the respective region number 0 - 7 (higher bits) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHOS_U85_BASEP1_HI_OFFSET ,Offset RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_BASEP1_HI_RES0 ,Reserved field RESET:0x0"
          
group.long  0x90++0x3
    line.long 0x00 "ETHOS_U85_BASEP2, AXI base address of the respective region number 0 - 7 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_BASEP2_OFFSET ,Offset RESET:0x0"
          
group.long  0x94++0x3
    line.long 0x00 "ETHOS_U85_BASEP2_HI, AXI base address of the respective region number 0 - 7 (higher bits) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHOS_U85_BASEP2_HI_OFFSET ,Offset RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_BASEP2_HI_RES0 ,Reserved field RESET:0x0"
          
group.long  0x98++0x3
    line.long 0x00 "ETHOS_U85_BASEP3, AXI base address of the respective region number 0 - 7 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_BASEP3_OFFSET ,Offset RESET:0x0"
          
group.long  0x9c++0x3
    line.long 0x00 "ETHOS_U85_BASEP3_HI, AXI base address of the respective region number 0 - 7 (higher bits) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHOS_U85_BASEP3_HI_OFFSET ,Offset RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_BASEP3_HI_RES0 ,Reserved field RESET:0x0"
          
group.long  0xa0++0x3
    line.long 0x00 "ETHOS_U85_BASEP4, AXI base address of the respective region number 0 - 7 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_BASEP4_OFFSET ,Offset RESET:0x0"
          
group.long  0xa4++0x3
    line.long 0x00 "ETHOS_U85_BASEP4_HI, AXI base address of the respective region number 0 - 7 (higher bits) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHOS_U85_BASEP4_HI_OFFSET ,Offset RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_BASEP4_HI_RES0 ,Reserved field RESET:0x0"
          
group.long  0xa8++0x3
    line.long 0x00 "ETHOS_U85_BASEP5, AXI base address of the respective region number 0 - 7 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_BASEP5_OFFSET ,Offset RESET:0x0"
          
group.long  0xac++0x3
    line.long 0x00 "ETHOS_U85_BASEP5_HI, AXI base address of the respective region number 0 - 7 (higher bits) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHOS_U85_BASEP5_HI_OFFSET ,Offset RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_BASEP5_HI_RES0 ,Reserved field RESET:0x0"
          
group.long  0xb0++0x3
    line.long 0x00 "ETHOS_U85_BASEP6, AXI base address of the respective region number 0 - 7 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_BASEP6_OFFSET ,Offset RESET:0x0"
          
group.long  0xb4++0x3
    line.long 0x00 "ETHOS_U85_BASEP6_HI, AXI base address of the respective region number 0 - 7 (higher bits) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHOS_U85_BASEP6_HI_OFFSET ,Offset RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_BASEP6_HI_RES0 ,Reserved field RESET:0x0"
          
group.long  0xb8++0x3
    line.long 0x00 "ETHOS_U85_BASEP7, AXI base address of the respective region number 0 - 7 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_BASEP7_OFFSET ,Offset RESET:0x0"
          
group.long  0xbc++0x3
    line.long 0x00 "ETHOS_U85_BASEP7_HI, AXI base address of the respective region number 0 - 7 (higher bits) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHOS_U85_BASEP7_HI_OFFSET ,Offset RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " ETHOS_U85_BASEP7_HI_RES0 ,Reserved field RESET:0x0"
          
rgroup.long 0xfd0++0x3
    line.long 0x00 "ETHOS_U85_PID4, Peripheral ID byte 4 (Arm=code 4) RESET:0x4"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PID4_PID4 ,Byte 4 of Peripheral ID (Lower 8 bits valid) RESET:0x4"
          
rgroup.long 0xfd4++0x3
    line.long 0x00 "ETHOS_U85_PID5, Peripheral ID byte 5 (reserved) RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PID5_PID5 ,Byte 5 of Peripheral ID (Lower 8 bits valid) RESET:0x0"
          
rgroup.long 0xfd8++0x3
    line.long 0x00 "ETHOS_U85_PID6, Peripheral ID byte 6 (reserved) RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PID6_PID6 ,Byte 6 of Peripheral ID (Lower 8 bits valid) RESET:0x0"
          
rgroup.long 0xfdc++0x3
    line.long 0x00 "ETHOS_U85_PID7, Peripheral ID byte 7 (reserved) RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PID7_PID7 ,Byte 7 of Peripheral ID (Lower 8 bits valid) RESET:0x0"
          
rgroup.long 0xfe0++0x3
    line.long 0x00 "ETHOS_U85_PID0, Peripheral ID byte 0. This is bits[7:0] of the part number RESET:0x82"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PID0_PID0 ,Byte 0 of Peripheral ID (Lower 8 bits valid) RESET:0x82"
          
rgroup.long 0xfe4++0x3
    line.long 0x00 "ETHOS_U85_PID1, Peripheral ID byte 1. This is bits[11:8] of the part number in bits[3:0], and bits[3:0] of the Arm ID in bits[7:4] RESET:0xb5"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PID1_PID1 ,Byte 1 of Peripheral ID (Lower 8 bits valid) RESET:0xb5"
          
rgroup.long 0xfe8++0x3
    line.long 0x00 "ETHOS_U85_PID2, Peripheral ID byte 2. This is bits[6:4] of the Arm ID in bits[2:0], and bit 3 indicates format B RESET:0xb"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PID2_PID2 ,Byte 2 of Peripheral ID (Lower 8 bits valid) RESET:0xb"
          
rgroup.long 0xfec++0x3
    line.long 0x00 "ETHOS_U85_PID3, Peripheral ID byte 3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PID3_PID3 ,Byte 1 of Peripheral ID (Lower 8 bits valid) RESET:0x0"
          
rgroup.long 0xff0++0x3
    line.long 0x00 "ETHOS_U85_CID0, Component ID byte 0 RESET:0xd"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_CID0_CID0 ,Byte 0 of Component ID (Lower 8 bits valid) RESET:0xd"
          
rgroup.long 0xff4++0x3
    line.long 0x00 "ETHOS_U85_CID1, Component ID byte 1 RESET:0xf0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_CID1_CID1 ,Byte 1 of Component ID (Lower 8 bits valid) RESET:0xf0"
          
rgroup.long 0xff8++0x3
    line.long 0x00 "ETHOS_U85_CID2, Component ID byte 2 RESET:0x5"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_CID2_CID2 ,Byte 2 of Component ID (Lower 8 bits valid) RESET:0x5"
          
rgroup.long 0xffc++0x3
    line.long 0x00 "ETHOS_U85_CID3, Component ID byte 3 RESET:0xb1"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_CID3_CID3 ,Byte 3 of Component ID (Lower 8 bits valid) RESET:0xb1"
          
group.long  0x1180++0x3
    line.long 0x00 "ETHOS_U85_PMCR, PMU register control RESET:0x4000"
         bitfld.long 0x00 0. " ETHOS_U85_PMCR_CNT_EN ,Enable counter RESET:0x0"
          
         bitfld.long 0x00 1. " ETHOS_U85_PMCR_EVENT_CNT_RST ,Reset event counter RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_U85_PMCR_CYCLE_CNT_RST ,Reset cycle counter RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_U85_PMCR_MASK_EN ,PMU can be enabled/disabled by command stream operation NPU_OP_PMU_MASK RESET:0x0"
          
         hexmask.long 0x00 4.--10. 1. " ETHOS_U85_PMCR_RES0 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 11.--15. 1. " ETHOS_U85_PMCR_NUM_EVENT_CNT ,Number of event counters RESET:0x8"
          
         hexmask.long 0x00 16.--31. 1. " ETHOS_U85_PMCR_RES1 ,Reserved field RESET:0x0"
          
group.long  0x1184++0x3
    line.long 0x00 "ETHOS_U85_PMCNTENSET, Count enable set register RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_U85_PMCNTENSET_EVENT_CNT_0 ,Event counter enable bit for PMEVCNTR0 RESET:0x0"
          
         bitfld.long 0x00 1. " ETHOS_U85_PMCNTENSET_EVENT_CNT_1 ,Event counter enable bit for PMEVCNTR1 RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_U85_PMCNTENSET_EVENT_CNT_2 ,Event counter enable bit for PMEVCNTR2 RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_U85_PMCNTENSET_EVENT_CNT_3 ,Event counter enable bit for PMEVCNTR3 RESET:0x0"
          
         bitfld.long 0x00 4. " ETHOS_U85_PMCNTENSET_EVENT_CNT_4 ,Event counter enable bit for PMEVCNTR4 RESET:0x0"
          
         bitfld.long 0x00 5. " ETHOS_U85_PMCNTENSET_EVENT_CNT_5 ,Event counter enable bit for PMEVCNTR5 RESET:0x0"
          
         bitfld.long 0x00 6. " ETHOS_U85_PMCNTENSET_EVENT_CNT_6 ,Event counter enable bit for PMEVCNTR6 RESET:0x0"
          
         bitfld.long 0x00 7. " ETHOS_U85_PMCNTENSET_EVENT_CNT_7 ,Event counter enable bit for PMEVCNTR7 RESET:0x0"
          
         hexmask.long 0x00 8.--30. 1. " ETHOS_U85_PMCNTENSET_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 31. " ETHOS_U85_PMCNTENSET_CYCLE_CNT ,PMCCNTR enable bit RESET:0x0"
          
group.long  0x1188++0x3
    line.long 0x00 "ETHOS_U85_PMCNTENCLR, Count enable clear register RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_U85_PMCNTENCLR_EVENT_CNT_0 ,Event counter disable bit for PMEVCNTR0 RESET:0x0"
          
         bitfld.long 0x00 1. " ETHOS_U85_PMCNTENCLR_EVENT_CNT_1 ,Event counter disable bit for PMEVCNTR1 RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_U85_PMCNTENCLR_EVENT_CNT_2 ,Event counter disable bit for PMEVCNTR2 RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_U85_PMCNTENCLR_EVENT_CNT_3 ,Event counter disable bit for PMEVCNTR3 RESET:0x0"
          
         bitfld.long 0x00 4. " ETHOS_U85_PMCNTENCLR_EVENT_CNT_4 ,Event counter disable bit for PMEVCNTR4 RESET:0x0"
          
         bitfld.long 0x00 5. " ETHOS_U85_PMCNTENCLR_EVENT_CNT_5 ,Event counter disable bit for PMEVCNTR5 RESET:0x0"
          
         bitfld.long 0x00 6. " ETHOS_U85_PMCNTENCLR_EVENT_CNT_6 ,Event counter disable bit for PMEVCNTR6 RESET:0x0"
          
         bitfld.long 0x00 7. " ETHOS_U85_PMCNTENCLR_EVENT_CNT_7 ,Event counter disable bit for PMEVCNTR7 RESET:0x0"
          
         hexmask.long 0x00 8.--30. 1. " ETHOS_U85_PMCNTENCLR_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 31. " ETHOS_U85_PMCNTENCLR_CYCLE_CNT ,PMCCNTR disable bit RESET:0x0"
          
group.long  0x118c++0x3
    line.long 0x00 "ETHOS_U85_PMOVSSET, Overflow flag status set register RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_U85_PMOVSSET_EVENT_CNT_0_OVF ,Event counter overflow set bit for PMEVCNTR0 RESET:0x0"
          
         bitfld.long 0x00 1. " ETHOS_U85_PMOVSSET_EVENT_CNT_1_OVF ,Event counter overflow set bit for PMEVCNTR1 RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_U85_PMOVSSET_EVENT_CNT_2_OVF ,Event counter overflow set bit for PMEVCNTR2 RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_U85_PMOVSSET_EVENT_CNT_3_OVF ,Event counter overflow set bit for PMEVCNTR3 RESET:0x0"
          
         bitfld.long 0x00 4. " ETHOS_U85_PMOVSSET_EVENT_CNT_4_OVF ,Event counter overflow set bit for PMEVCNTR4 RESET:0x0"
          
         bitfld.long 0x00 5. " ETHOS_U85_PMOVSSET_EVENT_CNT_5_OVF ,Event counter overflow set bit for PMEVCNTR5 RESET:0x0"
          
         bitfld.long 0x00 6. " ETHOS_U85_PMOVSSET_EVENT_CNT_6_OVF ,Event counter overflow set bit for PMEVCNTR6 RESET:0x0"
          
         bitfld.long 0x00 7. " ETHOS_U85_PMOVSSET_EVENT_CNT_7_OVF ,Event counter overflow set bit for PMEVCNTR7 RESET:0x0"
          
         hexmask.long 0x00 8.--30. 1. " ETHOS_U85_PMOVSSET_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 31. " ETHOS_U85_PMOVSSET_CYCLE_CNT_OVF ,PMCCNTR overflow set bit RESET:0x0"
          
group.long  0x1190++0x3
    line.long 0x00 "ETHOS_U85_PMOVSCLR, Overflow flag status clear register RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_U85_PMOVSCLR_EVENT_CNT_0_OVF ,Event counter overflow clear bit for PMEVCNTR0 RESET:0x0"
          
         bitfld.long 0x00 1. " ETHOS_U85_PMOVSCLR_EVENT_CNT_1_OVF ,Event counter overflow clear bit for PMEVCNTR1 RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_U85_PMOVSCLR_EVENT_CNT_2_OVF ,Event counter overflow clear bit for PMEVCNTR2 RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_U85_PMOVSCLR_EVENT_CNT_3_OVF ,Event counter overflow clear bit for PMEVCNTR3 RESET:0x0"
          
         bitfld.long 0x00 4. " ETHOS_U85_PMOVSCLR_EVENT_CNT_4_OVF ,Event counter overflow clear bit for PMEVCNTR4 RESET:0x0"
          
         bitfld.long 0x00 5. " ETHOS_U85_PMOVSCLR_EVENT_CNT_5_OVF ,Event counter overflow clear bit for PMEVCNTR5 RESET:0x0"
          
         bitfld.long 0x00 6. " ETHOS_U85_PMOVSCLR_EVENT_CNT_6_OVF ,Event counter overflow clear bit for PMEVCNTR6 RESET:0x0"
          
         bitfld.long 0x00 7. " ETHOS_U85_PMOVSCLR_EVENT_CNT_7_OVF ,Event counter overflow clear bit for PMEVCNTR7 RESET:0x0"
          
         hexmask.long 0x00 8.--30. 1. " ETHOS_U85_PMOVSCLR_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 31. " ETHOS_U85_PMOVSCLR_CYCLE_CNT_OVF ,PMCCNTR overflow clear bit RESET:0x0"
          
group.long  0x1194++0x3
    line.long 0x00 "ETHOS_U85_PMINTSET, Interrupt enable set register RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_U85_PMINTSET_EVENT_CNT_0_INT ,Event counter overflow interrupt request enable bit for PMEVCNTR0 RESET:0x0"
          
         bitfld.long 0x00 1. " ETHOS_U85_PMINTSET_EVENT_CNT_1_INT ,Event counter overflow interrupt request enable bit for PMEVCNTR1 RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_U85_PMINTSET_EVENT_CNT_2_INT ,Event counter overflow interrupt request enable bit for PMEVCNTR2 RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_U85_PMINTSET_EVENT_CNT_3_INT ,Event counter overflow interrupt request enable bit for PMEVCNTR3 RESET:0x0"
          
         bitfld.long 0x00 4. " ETHOS_U85_PMINTSET_EVENT_CNT_4_INT ,Event counter overflow interrupt request enable bit for PMEVCNTR4 RESET:0x0"
          
         bitfld.long 0x00 5. " ETHOS_U85_PMINTSET_EVENT_CNT_5_INT ,Event counter overflow interrupt request enable bit for PMEVCNTR5 RESET:0x0"
          
         bitfld.long 0x00 6. " ETHOS_U85_PMINTSET_EVENT_CNT_6_INT ,Event counter overflow interrupt request enable bit for PMEVCNTR6 RESET:0x0"
          
         bitfld.long 0x00 7. " ETHOS_U85_PMINTSET_EVENT_CNT_7_INT ,Event counter overflow interrupt request enable bit for PMEVCNTR7 RESET:0x0"
          
         hexmask.long 0x00 8.--30. 1. " ETHOS_U85_PMINTSET_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 31. " ETHOS_U85_PMINTSET_CYCLE_CNT_INT ,PMCCNTR overflow interrupt request enable bit RESET:0x0"
          
group.long  0x1198++0x3
    line.long 0x00 "ETHOS_U85_PMINTCLR, Interrupt enable clear register RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_U85_PMINTCLR_EVENT_CNT_0_INT ,Event counter overflow interrupt request disable bit for PMEVCNTR0 RESET:0x0"
          
         bitfld.long 0x00 1. " ETHOS_U85_PMINTCLR_EVENT_CNT_1_INT ,Event counter overflow interrupt request disable bit for PMEVCNTR1 RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_U85_PMINTCLR_EVENT_CNT_2_INT ,Event counter overflow interrupt request disable bit for PMEVCNTR2 RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_U85_PMINTCLR_EVENT_CNT_3_INT ,Event counter overflow interrupt request disable bit for PMEVCNTR3 RESET:0x0"
          
         bitfld.long 0x00 4. " ETHOS_U85_PMINTCLR_EVENT_CNT_4_INT ,Event counter overflow interrupt request disable bit for PMEVCNTR4 RESET:0x0"
          
         bitfld.long 0x00 5. " ETHOS_U85_PMINTCLR_EVENT_CNT_5_INT ,Event counter overflow interrupt request disable bit for PMEVCNTR5 RESET:0x0"
          
         bitfld.long 0x00 6. " ETHOS_U85_PMINTCLR_EVENT_CNT_6_INT ,Event counter overflow interrupt request disable bit for PMEVCNTR6 RESET:0x0"
          
         bitfld.long 0x00 7. " ETHOS_U85_PMINTCLR_EVENT_CNT_7_INT ,Event counter overflow interrupt request disable bit for PMEVCNTR7 RESET:0x0"
          
         hexmask.long 0x00 8.--30. 1. " ETHOS_U85_PMINTCLR_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 31. " ETHOS_U85_PMINTCLR_CYCLE_CNT_INT ,PMCCNTR overflow interrupt request disable bit RESET:0x0"
          
group.long  0x11a0++0x3
    line.long 0x00 "ETHOS_U85_PMCCNTR, Performance monitor cycle count register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PMCCNTR_CYCLE_CNT ,Cycle count RESET:0x0"
          
group.long  0x11a4++0x3
    line.long 0x00 "ETHOS_U85_PMCCNTR_HI, Performance monitor cycle count register (higher bits) RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETHOS_U85_PMCCNTR_HI_CYCLE_CNT ,Cycle count RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETHOS_U85_PMCCNTR_HI_RES0 ,Reserved field RESET:0x0"
          
group.long  0x11ac++0x3
    line.long 0x00 "ETHOS_U85_PMCAXI_CHAN, Set which AXI channel to monitor for latency measurements in PMU RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETHOS_U85_PMCAXI_CHAN_CH_SEL ,Channel select for latency measurements RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " ETHOS_U85_PMCAXI_CHAN_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 8. " ETHOS_U85_PMCAXI_CHAN_AXI_SEL ,AXI port select for latency measurements RESET:0x0"
          
         bitfld.long 0x00 9. " ETHOS_U85_PMCAXI_CHAN_RES1 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 10. " ETHOS_U85_PMCAXI_CHAN_BW_CH_SEL_EN ,Bandwidth channel selector RESET:0x0"
          
         hexmask.long 0x00 11.--31. 1. " ETHOS_U85_PMCAXI_CHAN_RES2 ,Reserved field RESET:0x0"
          
group.long  0x11b0++0x3
    line.long 0x00 "ETHOS_U85_PMCLUT, Performance monitor control for lookup table RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_U85_PMCLUT_PCM_LUT_EN_0 ,PMU lookup table enable for event counter 0 RESET:0x0"
          
         hexmask.long 0x00 1.--15. 1. " ETHOS_U85_PMCLUT_RES0 ,Reserved field RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETHOS_U85_PMCLUT_PMC_LUT_0 ,PMU lookup table for event counter 0 RESET:0x0"
          
group.long  0x1300++0x3
    line.long 0x00 "ETHOS_U85_PMEVCNTR0, Performance monitor event 0 count register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PMEVCNTR0_COUNT ,Count word RESET:0x0"
          
group.long  0x1304++0x3
    line.long 0x00 "ETHOS_U85_PMEVCNTR1, Performance monitor event 1 count register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PMEVCNTR1_COUNT ,Count word RESET:0x0"
          
group.long  0x1308++0x3
    line.long 0x00 "ETHOS_U85_PMEVCNTR2, Performance monitor event 2 count register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PMEVCNTR2_COUNT ,Count word RESET:0x0"
          
group.long  0x130c++0x3
    line.long 0x00 "ETHOS_U85_PMEVCNTR3, Performance monitor event 3 count register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PMEVCNTR3_COUNT ,Count word RESET:0x0"
          
group.long  0x1310++0x3
    line.long 0x00 "ETHOS_U85_PMEVCNTR4, Performance monitor event 4 count register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PMEVCNTR4_COUNT ,Count word RESET:0x0"
          
group.long  0x1314++0x3
    line.long 0x00 "ETHOS_U85_PMEVCNTR5, Performance monitor event 5 count register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PMEVCNTR5_COUNT ,Count word RESET:0x0"
          
group.long  0x1318++0x3
    line.long 0x00 "ETHOS_U85_PMEVCNTR6, Performance monitor event 6 count register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PMEVCNTR6_COUNT ,Count word RESET:0x0"
          
group.long  0x131c++0x3
    line.long 0x00 "ETHOS_U85_PMEVCNTR7, Performance monitor event 7 count register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_U85_PMEVCNTR7_COUNT ,Count word RESET:0x0"
          
group.long  0x1380++0x3
    line.long 0x00 "ETHOS_U85_PMEVTYPER0, Performance monitor event type register 0 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " ETHOS_U85_PMEVTYPER0_EV_TYPE ,Event Type RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " ETHOS_U85_PMEVTYPER0_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 12. " ETHOS_U85_PMEVTYPER0_D0 ,Counting disabled for AXI port 0 RESET:0x0"
          
         bitfld.long 0x00 13. " ETHOS_U85_PMEVTYPER0_D1 ,Counting disabled for AXI port 1 RESET:0x0"
          
         bitfld.long 0x00 14. " ETHOS_U85_PMEVTYPER0_D2 ,Counting disabled for AXI port 2 RESET:0x0"
          
         bitfld.long 0x00 15. " ETHOS_U85_PMEVTYPER0_D3 ,Counting disabled for AXI port 3 RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETHOS_U85_PMEVTYPER0_RES1 ,Reserved field RESET:0x0"
          
group.long  0x1384++0x3
    line.long 0x00 "ETHOS_U85_PMEVTYPER1, Performance monitor event type register 1 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " ETHOS_U85_PMEVTYPER1_EV_TYPE ,Event Type RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " ETHOS_U85_PMEVTYPER1_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 12. " ETHOS_U85_PMEVTYPER1_D0 ,Counting disabled for AXI port 0 RESET:0x0"
          
         bitfld.long 0x00 13. " ETHOS_U85_PMEVTYPER1_D1 ,Counting disabled for AXI port 1 RESET:0x0"
          
         bitfld.long 0x00 14. " ETHOS_U85_PMEVTYPER1_D2 ,Counting disabled for AXI port 2 RESET:0x0"
          
         bitfld.long 0x00 15. " ETHOS_U85_PMEVTYPER1_D3 ,Counting disabled for AXI port 3 RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETHOS_U85_PMEVTYPER1_RES1 ,Reserved field RESET:0x0"
          
group.long  0x1388++0x3
    line.long 0x00 "ETHOS_U85_PMEVTYPER2, Performance monitor event type register 2 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " ETHOS_U85_PMEVTYPER2_EV_TYPE ,Event Type RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " ETHOS_U85_PMEVTYPER2_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 12. " ETHOS_U85_PMEVTYPER2_D0 ,Counting disabled for AXI port 0 RESET:0x0"
          
         bitfld.long 0x00 13. " ETHOS_U85_PMEVTYPER2_D1 ,Counting disabled for AXI port 1 RESET:0x0"
          
         bitfld.long 0x00 14. " ETHOS_U85_PMEVTYPER2_D2 ,Counting disabled for AXI port 2 RESET:0x0"
          
         bitfld.long 0x00 15. " ETHOS_U85_PMEVTYPER2_D3 ,Counting disabled for AXI port 3 RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETHOS_U85_PMEVTYPER2_RES1 ,Reserved field RESET:0x0"
          
group.long  0x138c++0x3
    line.long 0x00 "ETHOS_U85_PMEVTYPER3, Performance monitor event type register 3 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " ETHOS_U85_PMEVTYPER3_EV_TYPE ,Event Type RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " ETHOS_U85_PMEVTYPER3_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 12. " ETHOS_U85_PMEVTYPER3_D0 ,Counting disabled for AXI port 0 RESET:0x0"
          
         bitfld.long 0x00 13. " ETHOS_U85_PMEVTYPER3_D1 ,Counting disabled for AXI port 1 RESET:0x0"
          
         bitfld.long 0x00 14. " ETHOS_U85_PMEVTYPER3_D2 ,Counting disabled for AXI port 2 RESET:0x0"
          
         bitfld.long 0x00 15. " ETHOS_U85_PMEVTYPER3_D3 ,Counting disabled for AXI port 3 RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETHOS_U85_PMEVTYPER3_RES1 ,Reserved field RESET:0x0"
          
group.long  0x1390++0x3
    line.long 0x00 "ETHOS_U85_PMEVTYPER4, Performance monitor event type register 4 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " ETHOS_U85_PMEVTYPER4_EV_TYPE ,Event Type RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " ETHOS_U85_PMEVTYPER4_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 12. " ETHOS_U85_PMEVTYPER4_D0 ,Counting disabled for AXI port 0 RESET:0x0"
          
         bitfld.long 0x00 13. " ETHOS_U85_PMEVTYPER4_D1 ,Counting disabled for AXI port 1 RESET:0x0"
          
         bitfld.long 0x00 14. " ETHOS_U85_PMEVTYPER4_D2 ,Counting disabled for AXI port 2 RESET:0x0"
          
         bitfld.long 0x00 15. " ETHOS_U85_PMEVTYPER4_D3 ,Counting disabled for AXI port 3 RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETHOS_U85_PMEVTYPER4_RES1 ,Reserved field RESET:0x0"
          
group.long  0x1394++0x3
    line.long 0x00 "ETHOS_U85_PMEVTYPER5, Performance monitor event type register 5 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " ETHOS_U85_PMEVTYPER5_EV_TYPE ,Event Type RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " ETHOS_U85_PMEVTYPER5_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 12. " ETHOS_U85_PMEVTYPER5_D0 ,Counting disabled for AXI port 0 RESET:0x0"
          
         bitfld.long 0x00 13. " ETHOS_U85_PMEVTYPER5_D1 ,Counting disabled for AXI port 1 RESET:0x0"
          
         bitfld.long 0x00 14. " ETHOS_U85_PMEVTYPER5_D2 ,Counting disabled for AXI port 2 RESET:0x0"
          
         bitfld.long 0x00 15. " ETHOS_U85_PMEVTYPER5_D3 ,Counting disabled for AXI port 3 RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETHOS_U85_PMEVTYPER5_RES1 ,Reserved field RESET:0x0"
          
group.long  0x1398++0x3
    line.long 0x00 "ETHOS_U85_PMEVTYPER6, Performance monitor event type register 6 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " ETHOS_U85_PMEVTYPER6_EV_TYPE ,Event Type RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " ETHOS_U85_PMEVTYPER6_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 12. " ETHOS_U85_PMEVTYPER6_D0 ,Counting disabled for AXI port 0 RESET:0x0"
          
         bitfld.long 0x00 13. " ETHOS_U85_PMEVTYPER6_D1 ,Counting disabled for AXI port 1 RESET:0x0"
          
         bitfld.long 0x00 14. " ETHOS_U85_PMEVTYPER6_D2 ,Counting disabled for AXI port 2 RESET:0x0"
          
         bitfld.long 0x00 15. " ETHOS_U85_PMEVTYPER6_D3 ,Counting disabled for AXI port 3 RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETHOS_U85_PMEVTYPER6_RES1 ,Reserved field RESET:0x0"
          
group.long  0x139c++0x3
    line.long 0x00 "ETHOS_U85_PMEVTYPER7, Performance monitor event type register 7 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " ETHOS_U85_PMEVTYPER7_EV_TYPE ,Event Type RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " ETHOS_U85_PMEVTYPER7_RES0 ,Reserved field RESET:0x0"
          
         bitfld.long 0x00 12. " ETHOS_U85_PMEVTYPER7_D0 ,Counting disabled for AXI port 0 RESET:0x0"
          
         bitfld.long 0x00 13. " ETHOS_U85_PMEVTYPER7_D1 ,Counting disabled for AXI port 1 RESET:0x0"
          
         bitfld.long 0x00 14. " ETHOS_U85_PMEVTYPER7_D2 ,Counting disabled for AXI port 2 RESET:0x0"
          
         bitfld.long 0x00 15. " ETHOS_U85_PMEVTYPER7_D3 ,Counting disabled for AXI port 3 RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETHOS_U85_PMEVTYPER7_RES1 ,Reserved field RESET:0x0"
          
tree.end

tree "DCU"
base e:0x40010000
width 80.
tree.end
    

tree "DCU__GLOBAL"
base e:0x40010000
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "DCU_GLOBAL_HW_VERSION, HW Version Register RESET:0x404"
         hexmask.long 0x00 0.--7. 1. " DCU_GLOBAL_HW_VERSION_MINOR_VERSION ,Minor version RESET:0x4"
          
         hexmask.long 0x00 8.--15. 1. " DCU_GLOBAL_HW_VERSION_MAJOR_VERSION ,Major version RESET:0x4"
          
         hexmask.long 0x00 16.--23. 1. " DCU_GLOBAL_HW_VERSION_IDENTIFICATION ,Identification RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "DCU_GLOBAL_LAYER_COUNT, Layer Count Register RESET:0x3"
         hexmask.long 0x00 0.--7. 1. " DCU_GLOBAL_LAYER_COUNT_LAYER_NUM ,Number of layers RESET:0x3"
          
rgroup.long 0x8++0x3
    line.long 0x00 "DCU_GLOBAL_SYNC_SIZE, Sync Size Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_GLOBAL_SYNC_SIZE_VSYNC_SIZE ,VSync Height in Lines - 1 RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DCU_GLOBAL_SYNC_SIZE_HSYNC_SIZE ,HSync Width in Pixels - 1 RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "DCU_GLOBAL_BACK_PORCH__ACCUMULATED_, Back Porch Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_GLOBAL_BACK_PORCH__ACCUMULATED__ACCUMULATED_HEIGHT ,Accumulated Height including sync and back porch in Lines - 1 RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DCU_GLOBAL_BACK_PORCH__ACCUMULATED__ACCUMULATED_WIDTH ,Accumulated Width including sync and back porch in Pixels - 1 RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "DCU_GLOBAL_ACTIVE_WIDTH, Active Width Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_GLOBAL_ACTIVE_WIDTH_ACCUMULATED_HEIGHT ,Accumulated Height including sync, back porch and active height in Lines - 1 RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DCU_GLOBAL_ACTIVE_WIDTH_ACCUMULATED_WIDTH ,Accumulated Width including sync, back porch and active width in Pixels - 1 RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "DCU_GLOBAL_TOTAL_WIDTH, Total Width Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_GLOBAL_TOTAL_WIDTH_TOTAL_HEIGHT_LINES ,Total height, including sync, back porch, active height and front porch in lines - 1 RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DCU_GLOBAL_TOTAL_WIDTH_TOTAL_WIDTH_PIXELS ,Total width, including sync, back porch, active width and front porch in pixels - 1 RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "DCU_GLOBAL_GLOBAL_CONTROL, Global Control Register RESET:0x2220"
         bitfld.long 0x00 0. " DCU_GLOBAL_GLOBAL_CONTROL_GLOBAL_ENABLE ,Global enable (mirrored to pin “de_o”) RESET:0x0"
          
         bitfld.long 0x00 1. " DCU_GLOBAL_GLOBAL_CONTROL_GAMMA_CORRECTION_EN ,Gamma correction enable RESET:0x0"
          
         bitfld.long 0x00 2. " DCU_GLOBAL_GLOBAL_CONTROL_ROTATION_EN ,Rotation enable RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " DCU_GLOBAL_GLOBAL_CONTROL_DITHER_BITS_BLUE ,Dither bits blue (0-4) RESET:0x2"
          
         hexmask.long 0x00 8.--10. 1. " DCU_GLOBAL_GLOBAL_CONTROL_DITHER_BITS_GREEN ,Dither bits green (0-4) RESET:0x2"
          
         hexmask.long 0x00 12.--14. 1. " DCU_GLOBAL_GLOBAL_CONTROL_DITHER_BITS_RED ,Dither bits red (0-4) RESET:0x2"
          
         bitfld.long 0x00 16. " DCU_GLOBAL_GLOBAL_CONTROL_DITHERING_EN ,Dithering Enable RESET:0x0"
          
         bitfld.long 0x00 17. " DCU_GLOBAL_GLOBAL_CONTROL_BACKGROUND_LAYER_ON ,Background layer on RESET:0x0"
          
         bitfld.long 0x00 18. " DCU_GLOBAL_GLOBAL_CONTROL_SLAVE_TIMING_ON ,Slave timing mode on RESET:0x0"
          
         bitfld.long 0x00 19. " DCU_GLOBAL_GLOBAL_CONTROL_CRC_EN ,CRC enable RESET:0x0"
          
         bitfld.long 0x00 20. " DCU_GLOBAL_GLOBAL_CONTROL_PERFORMANCE_MONITOR_EN ,Performance Monitor Enable RESET:0x0"
          
         bitfld.long 0x00 21. " DCU_GLOBAL_GLOBAL_CONTROL_COMPOSITION_CAPTURE_EN ,Composition Capture Enable RESET:0x0"
          
         bitfld.long 0x00 24. " DCU_GLOBAL_GLOBAL_CONTROL_SINGLE_FRAME_MODE_EN ,Single Frame mode enable RESET:0x0"
          
         bitfld.long 0x00 25. " DCU_GLOBAL_GLOBAL_CONTROL_SINGLE_FRAME_MODE_TRIG ,Single Frame mode software trigger RESET:0x0"
          
         bitfld.long 0x00 26. " DCU_GLOBAL_GLOBAL_CONTROL_SINGLE_FRAME_MODE_EXT ,Single Frame mode ext. trigger enable RESET:0x0"
          
         bitfld.long 0x00 27. " DCU_GLOBAL_GLOBAL_CONTROL_STREAM_EN ,Stream Enable (Layer 1) RESET:0x0"
          
         bitfld.long 0x00 28. " DCU_GLOBAL_GLOBAL_CONTROL_PIXEL_CLOCK_OUTPUT_POLARITY ,Pixel clock output polarity RESET:0x0"
          
         bitfld.long 0x00 29. " DCU_GLOBAL_GLOBAL_CONTROL_BLANK_POLARITY ,Blank polarity RESET:0x0"
          
         bitfld.long 0x00 30. " DCU_GLOBAL_GLOBAL_CONTROL_VSYNC_POLARITY ,VSync polarity RESET:0x0"
          
         bitfld.long 0x00 31. " DCU_GLOBAL_GLOBAL_CONTROL_HSYNC_POLARITY ,HSync polarity RESET:0x0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "DCU_GLOBAL_GLOBAL_CONFIGURATION_1, Global Configuration 1 Register RESET:0x6fe4d888"
         hexmask.long 0x00 0.--3. 1. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_BLUE_CHAN_OUTPUT_WIDTH ,Width of blue channel output RESET:0x8"
          
         hexmask.long 0x00 4.--7. 1. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_GREEN_CHAN_OUTPUT_WIDTH ,Width of green channel output RESET:0x8"
          
         hexmask.long 0x00 8.--11. 1. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_RED_CHAN_OUTPUT_WIDTH ,Width of red channel output RESET:0x8"
          
         bitfld.long 0x00 12. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_BLENDING_ENA ,Precise blending enabled RESET:0x1"
          
         hexmask.long 0x00 14.--15. 1. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_DITHERING_TECHNIQUE ,Dithering technique RESET:0x3"
          
         hexmask.long 0x00 17.--19. 1. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_GAMMA_CORRECTION_TECHNIQUE ,Gamma correction technique RESET:0x2"
          
         bitfld.long 0x00 21. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_SHADOW_REGISTERS_ENA ,Shadow registers enabled RESET:0x1"
          
         bitfld.long 0x00 22. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_BACKGROUND_COLOR_PRG ,Background color programmable RESET:0x1"
          
         bitfld.long 0x00 23. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_BACKGROUND_BLENDING_ENA ,Background blending enabled RESET:0x1"
          
         bitfld.long 0x00 24. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_LINE_IRQ_POSITION_PRG ,Line IRQ position programmable RESET:0x1"
          
         bitfld.long 0x00 25. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_TIMING_PRG ,Timing programmable RESET:0x1"
          
         bitfld.long 0x00 26. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_EXTENDED_ADDR_RANGE ,Extended Address Range RESET:0x1"
          
         bitfld.long 0x00 27. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_SYNC_POLARITY_PROG ,Sync polarity programmable RESET:0x1"
          
         bitfld.long 0x00 28. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_DITHER_WIDTH_PROG ,Dither width programmable RESET:0x0"
          
         bitfld.long 0x00 29. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_STATUS_REGISTERS_ENA ,Status registers enabled RESET:0x1"
          
         bitfld.long 0x00 30. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_CONFIG_READING_MODE_ENA ,Configuration Reading Mode Enabled RESET:0x1"
          
         bitfld.long 0x00 31. " DCU_GLOBAL_GLOBAL_CONFIGURATION_1_BLIND_MODE_ENA ,Blind Mode enabled RESET:0x0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "DCU_GLOBAL_GLOBAL_CONFIGURATION_2, Global Configuration 2 Register RESET:0x3f34"
         bitfld.long 0x00 0. " DCU_GLOBAL_GLOBAL_CONFIGURATION_2_BACKGROUND_LAYER_ENA ,Background layer ability enabled RESET:0x0"
          
         bitfld.long 0x00 1. " DCU_GLOBAL_GLOBAL_CONFIGURATION_2_SLAVE_TIMING_SYNCH_ENA ,Slave timing synchronization ability enabled RESET:0x0"
          
         bitfld.long 0x00 2. " DCU_GLOBAL_GLOBAL_CONFIGURATION_2_DUAL_VIEW_ENA ,Dual-view ability enabled RESET:0x1"
          
         bitfld.long 0x00 3. " DCU_GLOBAL_GLOBAL_CONFIGURATION_2_SECONDARY_RGB_OUTPUT_ENA ,Secondary RGB output port enabled RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " DCU_GLOBAL_GLOBAL_CONFIGURATION_2_BUS_WIDTH ,Bus width (log2 of number of bytes) RESET:0x3"
          
         bitfld.long 0x00 7. " DCU_GLOBAL_GLOBAL_CONFIGURATION_2_EXTERNAL_DISPLAY_CONTROL_ENA ,External display control ability enabled RESET:0x0"
          
         bitfld.long 0x00 8. " DCU_GLOBAL_GLOBAL_CONFIGURATION_2_YCBCR_OUTPUT_CONVERSION_ENA ,YCbCr output color conversion ability enabled RESET:0x1"
          
         bitfld.long 0x00 9. " DCU_GLOBAL_GLOBAL_CONFIGURATION_2_AXI_ID_ENA ,AXI Interface ID support enabled RESET:0x1"
          
         bitfld.long 0x00 10. " DCU_GLOBAL_GLOBAL_CONFIGURATION_2_ROTATION_ENA ,Rotation support enabled RESET:0x1"
          
         bitfld.long 0x00 11. " DCU_GLOBAL_GLOBAL_CONFIGURATION_2_SECONDARY_INTERRUPT_ENA ,Secondary interrupt support enabled RESET:0x1"
          
         bitfld.long 0x00 12. " DCU_GLOBAL_GLOBAL_CONFIGURATION_2_SINGLE_FRAME_ENA ,Single frame ability enable RESET:0x1"
          
         bitfld.long 0x00 13. " DCU_GLOBAL_GLOBAL_CONFIGURATION_2_CRC_MODE_AVAILABLE ,CRC mode available RESET:0x1"
          
         bitfld.long 0x00 15. " DCU_GLOBAL_GLOBAL_CONFIGURATION_2_BLENDING_ORDER_ENA ,Blending order enabled RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "DCU_GLOBAL_SHADOW_RELOAD_CONTROL, Shadow Reload Control Register RESET:0x0"
         bitfld.long 0x00 0. " DCU_GLOBAL_SHADOW_RELOAD_CONTROL_IMMEDIATE_RELOAD ,Immediate reload RESET:0x0"
          
         bitfld.long 0x00 1. " DCU_GLOBAL_SHADOW_RELOAD_CONTROL_VERTICAL_BLANKING_RELOAD ,Vertical blanking reload RESET:0x0"
          
wgroup.long 0x28++0x3
    line.long 0x00 "DCU_GLOBAL_GAMMA_CORRECTION, Gamma Correction Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DCU_GLOBAL_GAMMA_CORRECTION_ADDRESSED_COLOR ,Addressed color RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " DCU_GLOBAL_GAMMA_CORRECTION_MAPPED_COLOR ,Mapped color (RGB) RESET:0x0"
          
         bitfld.long 0x00 16. " DCU_GLOBAL_GAMMA_CORRECTION_SELECT_BLUE_CLUT ,Select blue CLUT RESET:0x0"
          
         bitfld.long 0x00 17. " DCU_GLOBAL_GAMMA_CORRECTION_SELECT_GREEN_CLUT ,Select green CLUT RESET:0x0"
          
         bitfld.long 0x00 18. " DCU_GLOBAL_GAMMA_CORRECTION_SELECT_RED_CLUT ,Select red CLUT RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "DCU_GLOBAL_BACKGROUND_COLOR, Background Color Register RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " DCU_GLOBAL_BACKGROUND_COLOR_BACKGROUND_COLOR_RGB ,Background color (RGB) RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "DCU_GLOBAL_IRQ_ENABLE, IRQ Enable Register RESET:0x0"
         bitfld.long 0x00 0. " DCU_GLOBAL_IRQ_ENABLE_LINE_IRQ_ENA ,Line IRQ on RESET:0x0"
          
         bitfld.long 0x00 1. " DCU_GLOBAL_IRQ_ENABLE_FIFO_RUN_WARNING_ENA ,FIFO Underrun Warning IRQ on RESET:0x0"
          
         bitfld.long 0x00 2. " DCU_GLOBAL_IRQ_ENABLE_BUS_ERROR_ENA ,Bus error IRQ on RESET:0x0"
          
         bitfld.long 0x00 3. " DCU_GLOBAL_IRQ_ENABLE_REGISTER_RELOAD_ENA ,Register reload IRQ on RESET:0x0"
          
         bitfld.long 0x00 4. " DCU_GLOBAL_IRQ_ENABLE_SLAVE_TIMING_NO_SIGNAL_ENA ,Slave timing no signal IRQ on RESET:0x0"
          
         bitfld.long 0x00 5. " DCU_GLOBAL_IRQ_ENABLE_SLAVE_TIMING_NO_SYNC_ENA ,Slave timing not in sync IRQ on RESET:0x0"
          
         bitfld.long 0x00 6. " DCU_GLOBAL_IRQ_ENABLE_FIFO_RUN_KILLING_ENA ,FIFO underrun killing IRQ on RESET:0x0"
          
         bitfld.long 0x00 7. " DCU_GLOBAL_IRQ_ENABLE_CRC_IRQ_ENA ,CRC IRQ on RESET:0x0"
          
         bitfld.long 0x00 8. " DCU_GLOBAL_IRQ_ENABLE_ROTATION_FIFO_ERROR_INTERRUPT_ENA ,Rotation FIFO error interrupt on RESET:0x0"
          
         bitfld.long 0x00 9. " DCU_GLOBAL_IRQ_ENABLE_BUS_STATUS_IRQ_ENA ,Bus Status IRQ on RESET:0x0"
          
         bitfld.long 0x00 10. " DCU_GLOBAL_IRQ_ENABLE_CAPTURE_COMPLETE_IRQ_ENA ,Capture Complete IRQ on RESET:0x0"
          
         bitfld.long 0x00 16. " DCU_GLOBAL_IRQ_ENABLE_LAYER_1_RELOAD_IRQ_ENA ,Layer 1 Reload IRQ on RESET:0x0"
          
         bitfld.long 0x00 17. " DCU_GLOBAL_IRQ_ENABLE_LAYER_2_RELOAD_IRQ_ENA ,Layer 2 Reload IRQ on RESET:0x0"
          
         bitfld.long 0x00 18. " DCU_GLOBAL_IRQ_ENABLE_LAYER_3_RELOAD_IRQ_ENA ,Layer 3 Reload IRQ on RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "DCU_GLOBAL_IRQ_STATUS, IRQ Status Register RESET:0x0"
         bitfld.long 0x00 0. " DCU_GLOBAL_IRQ_STATUS_LINE_IRQ_STATUS ,Line IRQ status RESET:0x0"
          
         bitfld.long 0x00 1. " DCU_GLOBAL_IRQ_STATUS_FIFO_WARNING_IRQ_STATUS ,FIFO Underrun Warning IRQ status RESET:0x0"
          
         bitfld.long 0x00 2. " DCU_GLOBAL_IRQ_STATUS_BUS_ERROR_IRQ_STATUS ,Bus error IRQ status RESET:0x0"
          
         bitfld.long 0x00 3. " DCU_GLOBAL_IRQ_STATUS_REGISTER_RELOAD_IRQ_STATUS ,Register reload IRQ status RESET:0x0"
          
         bitfld.long 0x00 4. " DCU_GLOBAL_IRQ_STATUS_SLAVE_SIGNAL_IRQ_STATUS ,Slave timing no signal IRQ status RESET:0x0"
          
         bitfld.long 0x00 5. " DCU_GLOBAL_IRQ_STATUS_SLAVE_SYNC_IRQ_STATUS ,Slave timing not in sync IRQ status RESET:0x0"
          
         bitfld.long 0x00 6. " DCU_GLOBAL_IRQ_STATUS_FIFO_RUN_KILLING_IRQ_STATUS ,FIFO underrun killing IRQ status RESET:0x0"
          
         bitfld.long 0x00 7. " DCU_GLOBAL_IRQ_STATUS_CRC_IRQ_STATUS ,CRC IRQ status RESET:0x0"
          
         bitfld.long 0x00 8. " DCU_GLOBAL_IRQ_STATUS_ROTATION_FIFO_ERROR_INTERRUPT_STATUS ,Rotation FIFO error interrupt status RESET:0x0"
          
         bitfld.long 0x00 9. " DCU_GLOBAL_IRQ_STATUS_BUS_STATUS_INTERRUPT_STATUS ,Bus Status IRQ Status RESET:0x0"
          
         bitfld.long 0x00 10. " DCU_GLOBAL_IRQ_STATUS_CAPTURE_COMPLETE_INTERRUPT_STATUS ,Capture Complete IRQ Status RESET:0x0"
          
         bitfld.long 0x00 16. " DCU_GLOBAL_IRQ_STATUS_LAYER_1_RELOAD_INTERRUPT_STATUS ,Layer 1 Reload IRQ Status RESET:0x0"
          
         bitfld.long 0x00 17. " DCU_GLOBAL_IRQ_STATUS_LAYER_2_RELOAD_INTERRUPT_STATUS ,Layer 2 Reload IRQ Status RESET:0x0"
          
         bitfld.long 0x00 18. " DCU_GLOBAL_IRQ_STATUS_LAYER_3_RELOAD_INTERRUPT_STATUS ,Layer 3 Reload IRQ Status RESET:0x0"
          
wgroup.long 0x3c++0x3
    line.long 0x00 "DCU_GLOBAL_IRQ_CLEAR, IRQ Clear Register RESET:0x0"
         bitfld.long 0x00 0. " DCU_GLOBAL_IRQ_CLEAR_CLEAR_LINE_IRQ ,Clear line IRQ RESET:0x0"
          
         bitfld.long 0x00 1. " DCU_GLOBAL_IRQ_CLEAR_CLEAR_FIFO_RUN_WARNING_IRQ ,Clear FIFO Underrun Warning IRQ RESET:0x0"
          
         bitfld.long 0x00 2. " DCU_GLOBAL_IRQ_CLEAR_CLEAR_BUS_ERROR_IRQ ,Clear bus error IRQ RESET:0x0"
          
         bitfld.long 0x00 3. " DCU_GLOBAL_IRQ_CLEAR_CLEAR_REGISTER_RELOAD_IRQ ,Clear register reload IRQ RESET:0x0"
          
         bitfld.long 0x00 4. " DCU_GLOBAL_IRQ_CLEAR_CLEAR_SLAVE_SIGNAL_IRQ ,Clear slave timing no signal IRQ RESET:0x0"
          
         bitfld.long 0x00 5. " DCU_GLOBAL_IRQ_CLEAR_CLEAR_SLAVE_SYNC_IRQ ,Clear slave timing not in sync IRQ RESET:0x0"
          
         bitfld.long 0x00 6. " DCU_GLOBAL_IRQ_CLEAR_CLEAR_FIFO_RUN_KILLING_IRQ ,Clear FIFO underrun killing IRQ RESET:0x0"
          
         bitfld.long 0x00 7. " DCU_GLOBAL_IRQ_CLEAR_CLEAR_CRC_IRQ ,Clear CRC IRQ RESET:0x0"
          
         bitfld.long 0x00 8. " DCU_GLOBAL_IRQ_CLEAR_CLEAR_ROTATION_FIFO_ERROR_IRQ ,Clear rotation FIFO error IRQ RESET:0x0"
          
         bitfld.long 0x00 9. " DCU_GLOBAL_IRQ_CLEAR_CLEAR_BUS_STATUS_IRQ ,Clear Bus Status IRQ RESET:0x0"
          
         bitfld.long 0x00 10. " DCU_GLOBAL_IRQ_CLEAR_CLEAR_CAPTURE_COMPLETE_IRQ ,Clear Capture Complete IRQ RESET:0x0"
          
         bitfld.long 0x00 16. " DCU_GLOBAL_IRQ_CLEAR_CLEAR_LAYER_1_RELOAD_IRQ ,Clear Layer 1 Reload IRQ RESET:0x0"
          
         bitfld.long 0x00 17. " DCU_GLOBAL_IRQ_CLEAR_CLEAR_LAYER_2_RELOAD_IRQ ,Clear Layer 2 Reload IRQ RESET:0x0"
          
         bitfld.long 0x00 18. " DCU_GLOBAL_IRQ_CLEAR_CLEAR_LAYER_3_RELOAD_IRQ ,Clear Layer 3 Reload IRQ RESET:0x0"
          
rgroup.long 0x40++0x3
    line.long 0x00 "DCU_GLOBAL_LINE_IRQ_POSITION_CONTROL, Line number IRQ Control Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_GLOBAL_LINE_IRQ_POSITION_CONTROL_LINE_IRQ_POSITION ,Line IRQ position RESET:0x0"
          
rgroup.long 0x44++0x3
    line.long 0x00 "DCU_GLOBAL_POSITION_STATUS, Position Status Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_GLOBAL_POSITION_STATUS_CURRENT_Y_POSITION ,Current Y position RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DCU_GLOBAL_POSITION_STATUS_CURRENT_X_POSITION ,Current X position RESET:0x0"
          
rgroup.long 0x48++0x3
    line.long 0x00 "DCU_GLOBAL_SYNC_BLANK_STATUS, Sync/Blank Status Register RESET:0xc"
         bitfld.long 0x00 0. " DCU_GLOBAL_SYNC_BLANK_STATUS_HSYNC_STATUS ,HSync Status (active high) RESET:0x0"
          
         bitfld.long 0x00 1. " DCU_GLOBAL_SYNC_BLANK_STATUS_VSYNC_STATUS ,VSync Status (active high) RESET:0x0"
          
         bitfld.long 0x00 2. " DCU_GLOBAL_SYNC_BLANK_STATUS_HBLANK_STATUS ,HBlank Status (active high) RESET:0x1"
          
         bitfld.long 0x00 3. " DCU_GLOBAL_SYNC_BLANK_STATUS_VBLANK_STATUS ,VBlank Status (active high) RESET:0x1"
          
rgroup.long 0x4c++0x3
    line.long 0x00 "DCU_GLOBAL_BACKGROUND_LAYER_BASE, Background Layer Base Register RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DCU_GLOBAL_BACKGROUND_LAYER_BASE_BACKGROUND_LAYER_FRACTIONAL_PART ,Background layer base_reg fractional part RESET:0x0"
          
         hexmask.long 0x00 4.--12. 1. " DCU_GLOBAL_BACKGROUND_LAYER_BASE_BACKGROUND_LAYER_INTEGER_PART ,Background layer base_reg integer part RESET:0x0"
          
         hexmask.long 0x00 24.--25. 1. " DCU_GLOBAL_BACKGROUND_LAYER_BASE_BACKGROUND_LAYER_MASK_MODE ,Background layer mask mode (0 to 2) RESET:0x0"
          
rgroup.long 0x50++0x3
    line.long 0x00 "DCU_GLOBAL_BACKGROUND_LAYER_INCREMENTS, Background Layer Increments Register RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DCU_GLOBAL_BACKGROUND_LAYER_INCREMENTS_BACKGROUND_LAYER_Y_INC_FRACTIONAL_PART ,Background layer y_inc_reg fractional part RESET:0x0"
          
         hexmask.long 0x00 4.--9. 1. " DCU_GLOBAL_BACKGROUND_LAYER_INCREMENTS_BACKGROUND_LAYER_Y_INC_SIGNED_INTEGER_PART ,Background layer y_inc_reg signed integer part RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " DCU_GLOBAL_BACKGROUND_LAYER_INCREMENTS_BACKGROUND_LAYER_X_INC_FRACTIONAL_PART ,Background layer x_inc_reg fractional part RESET:0x0"
          
         hexmask.long 0x00 20.--25. 1. " DCU_GLOBAL_BACKGROUND_LAYER_INCREMENTS_BACKGROUND_LAYER_X_INC_SIGNED_INTEGER_PART ,Background layer x_inc_reg signed integer part RESET:0x0"
          
rgroup.long 0x54++0x3
    line.long 0x00 "DCU_GLOBAL_BACKGROUND_LAYER_RAM_ADDRESS, Background Layer RAM Address Register RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " DCU_GLOBAL_BACKGROUND_LAYER_RAM_ADDRESS_ADDRESS_WRITE_DATA_BACKGROUND_RAM ,Address for next data write to background layer RAM (self-incrementing) RESET:0x0"
          
wgroup.long 0x58++0x3
    line.long 0x00 "DCU_GLOBAL_BACKGROUND_LAYER_DATA, Background Layer Data Register RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " DCU_GLOBAL_BACKGROUND_LAYER_DATA_DATA_BACKGROUND_RAM ,Data to be written to background layer RAM (RGB) RESET:0x0"
          
rgroup.long 0x5c++0x3
    line.long 0x00 "DCU_GLOBAL_SLAVE_TIMING_MODE_STATUS, Slave Timing Mode Status Register RESET:0xffff"
         hexmask.long 0x00 0.--15. 1. " DCU_GLOBAL_SLAVE_TIMING_MODE_STATUS_EXTERNAL_VSYNC_LINE ,External vsync event line RESET:0xffff"
          
         bitfld.long 0x00 16. " DCU_GLOBAL_SLAVE_TIMING_MODE_STATUS_LOW_FREQUENCY_MODE ,Low frequency mode active RESET:0x0"
          
rgroup.long 0x60++0x3
    line.long 0x00 "DCU_GLOBAL_EXTERNAL_DISPLAY_CONTROL, External Display Control Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DCU_GLOBAL_EXTERNAL_DISPLAY_CONTROL_BRIGHTNESS_PWM_LOW_COUNT ,Brightness PWM low count RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " DCU_GLOBAL_EXTERNAL_DISPLAY_CONTROL_BRIGHTNESS_PWM_HIGH_COUNT ,Brightness PWM high count RESET:0x0"
          
         bitfld.long 0x00 16. " DCU_GLOBAL_EXTERNAL_DISPLAY_CONTROL_DISPLAY_ON_OFF ,Display on/off RESET:0x0"
          
         bitfld.long 0x00 20. " DCU_GLOBAL_EXTERNAL_DISPLAY_CONTROL_DUAL_VIEW_ENABLE ,Dual-view enable RESET:0x0"
          
         bitfld.long 0x00 21. " DCU_GLOBAL_EXTERNAL_DISPLAY_CONTROL_SUB_PIXEL_MIXING_ENABLE ,Sub-pixel mixing enable RESET:0x0"
          
         bitfld.long 0x00 22. " DCU_GLOBAL_EXTERNAL_DISPLAY_CONTROL_PIXEL_CLOCK_HALF_EVEN_ENABLE ,Pixel clock half even enable RESET:0x0"
          
         bitfld.long 0x00 23. " DCU_GLOBAL_EXTERNAL_DISPLAY_CONTROL_PIXEL_CLOCK_HALF_ODD_ENABLE ,Pixel clock half odd enable RESET:0x0"
          
         bitfld.long 0x00 24. " DCU_GLOBAL_EXTERNAL_DISPLAY_CONTROL_PIXEL_CLOCK_HALF_ODD_EVEN_ACTIVE_EDGE_SHIFT ,Pixel clock half odd/even active edge shift (0=no shift, 1=shift to pixel clock falling edge) RESET:0x0"
          
         bitfld.long 0x00 25. " DCU_GLOBAL_EXTERNAL_DISPLAY_CONTROL_YCBCR_OUTPUT_ENABLE ,YCbCr output enable RESET:0x0"
          
         bitfld.long 0x00 26. " DCU_GLOBAL_EXTERNAL_DISPLAY_CONTROL_YCBCR_OUTPUT_COEFF ,YCbCr output coeff. set (601/709) RESET:0x0"
          
         bitfld.long 0x00 27. " DCU_GLOBAL_EXTERNAL_DISPLAY_CONTROL_YCBCR_OUTPUT_CB_CR ,YCbCr output Cb/Cr order RESET:0x0"
          
         hexmask.long 0x00 28.--29. 1. " DCU_GLOBAL_EXTERNAL_DISPLAY_CONTROL_SECONDARY_RGB_OUTPUT_MODE ,Secondary RGB output port mode:(0:Off, 1:Cloned, 2:Dual-port/half-rate RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "DCU_GLOBAL_SECONDARY_IRQ_ENABLE, Secondary IRQ Enable Register RESET:0x0"
         bitfld.long 0x00 0. " DCU_GLOBAL_SECONDARY_IRQ_ENABLE_LINE_IRQ_ON ,Line IRQ on RESET:0x0"
          
         bitfld.long 0x00 1. " DCU_GLOBAL_SECONDARY_IRQ_ENABLE_FIFO_RUN_WARNING_IRQ_ON ,FIFO Underrun Warning IRQ on RESET:0x0"
          
         bitfld.long 0x00 2. " DCU_GLOBAL_SECONDARY_IRQ_ENABLE_BUS_ERROR_IRQ_ON ,Bus error IRQ on RESET:0x0"
          
         bitfld.long 0x00 3. " DCU_GLOBAL_SECONDARY_IRQ_ENABLE_REGISTER_RELOAD_IRQ_ON ,Register reload IRQ on RESET:0x0"
          
         bitfld.long 0x00 4. " DCU_GLOBAL_SECONDARY_IRQ_ENABLE_SLAVE_SIGNAL_IRQ_ON ,Slave timing no signal IRQ on RESET:0x0"
          
         bitfld.long 0x00 5. " DCU_GLOBAL_SECONDARY_IRQ_ENABLE_SLAVE_SYNC_IRQ_ON ,Slave timing not in sync IRQ on RESET:0x0"
          
         bitfld.long 0x00 6. " DCU_GLOBAL_SECONDARY_IRQ_ENABLE_FIFO_RUN_KILLING_IRQ_ON ,FIFO Underrun Killing IRQ on RESET:0x0"
          
         bitfld.long 0x00 7. " DCU_GLOBAL_SECONDARY_IRQ_ENABLE_CRC_IRQ_ON ,CRC IRQ on RESET:0x0"
          
         bitfld.long 0x00 8. " DCU_GLOBAL_SECONDARY_IRQ_ENABLE_ROTATION_FIFO_ERROR_IRQ_ON ,Rotation FIFO Error Interrupt On RESET:0x0"
          
         bitfld.long 0x00 9. " DCU_GLOBAL_SECONDARY_IRQ_ENABLE_BUS_STATUS_IRQ_ON ,Bus Status IRQ On RESET:0x0"
          
         bitfld.long 0x00 10. " DCU_GLOBAL_SECONDARY_IRQ_ENABLE_CAPTURE_COMPLETE_IRQ_ON ,Capture Complete IRQ on RESET:0x0"
          
         bitfld.long 0x00 16. " DCU_GLOBAL_SECONDARY_IRQ_ENABLE_LAYER_1_RELOAD_IRQ_ON ,Layer 1 Reload IRQ on RESET:0x0"
          
         bitfld.long 0x00 17. " DCU_GLOBAL_SECONDARY_IRQ_ENABLE_LAYER_2_RELOAD_IRQ_ON ,Layer 2 Reload IRQ on RESET:0x0"
          
         bitfld.long 0x00 18. " DCU_GLOBAL_SECONDARY_IRQ_ENABLE_LAYER_3_RELOAD_IRQ_ON ,Layer 3 Reload IRQ on RESET:0x0"
          
rgroup.long 0x68++0x3
    line.long 0x00 "DCU_GLOBAL_SECONDARY_IRQ_STATUS, Secondary IRQ Status Register RESET:0x0"
         bitfld.long 0x00 0. " DCU_GLOBAL_SECONDARY_IRQ_STATUS_LINE_IRQ_STATUS ,Line IRQ status RESET:0x0"
          
         bitfld.long 0x00 1. " DCU_GLOBAL_SECONDARY_IRQ_STATUS_FIFO_RUN_WARNING_IRQ_STATUS ,FIFO Underrun Warning IRQ status RESET:0x0"
          
         bitfld.long 0x00 2. " DCU_GLOBAL_SECONDARY_IRQ_STATUS_BUS_ERROR_IRQ_STATUS ,Bus error IRQ status RESET:0x0"
          
         bitfld.long 0x00 3. " DCU_GLOBAL_SECONDARY_IRQ_STATUS_REGISTER_RELOAD_IRQ_STATUS ,Register reload IRQ status RESET:0x0"
          
         bitfld.long 0x00 4. " DCU_GLOBAL_SECONDARY_IRQ_STATUS_SLAVE_SIGNAL_IRQ_STATUS ,Slave timing no signal IRQ status RESET:0x0"
          
         bitfld.long 0x00 5. " DCU_GLOBAL_SECONDARY_IRQ_STATUS_SLAVE_SYNC_IRQ_STATUS ,Slave timing not in sync IRQ status RESET:0x0"
          
         bitfld.long 0x00 6. " DCU_GLOBAL_SECONDARY_IRQ_STATUS_FIFO_RUN_KILLING_IRQ_STATUS ,FIFO Underrun Killing IRQ status RESET:0x0"
          
         bitfld.long 0x00 7. " DCU_GLOBAL_SECONDARY_IRQ_STATUS_CRC_IRQ_STATUS ,CRC IRQ status RESET:0x0"
          
         bitfld.long 0x00 8. " DCU_GLOBAL_SECONDARY_IRQ_STATUS_ROTATION_FIFO_ERROR_IRQ_STATUS ,Rotation FIFO Error Interrupt status RESET:0x0"
          
         bitfld.long 0x00 9. " DCU_GLOBAL_SECONDARY_IRQ_STATUS_BUS_STATUS_IRQ_STATUS ,Bus Status IRQ status RESET:0x0"
          
         bitfld.long 0x00 10. " DCU_GLOBAL_SECONDARY_IRQ_STATUS_CAPTURE_COMPLETE_IRQ_STATUS ,Capture Complete IRQ status RESET:0x0"
          
         bitfld.long 0x00 16. " DCU_GLOBAL_SECONDARY_IRQ_STATUS_LAYER_1_RELOAD_IRQ_STATUS ,Layer 1 Reload IRQ status RESET:0x0"
          
         bitfld.long 0x00 17. " DCU_GLOBAL_SECONDARY_IRQ_STATUS_LAYER_2_RELOAD_IRQ_STATUS ,Layer 2 Reload IRQ status RESET:0x0"
          
         bitfld.long 0x00 18. " DCU_GLOBAL_SECONDARY_IRQ_STATUS_LAYER_3_RELOAD_IRQ_STATUS ,Layer 3 Reload IRQ status RESET:0x0"
          
wgroup.long 0x6c++0x3
    line.long 0x00 "DCU_GLOBAL_SECONDARY_IRQ_CLEAR, Secondary IRQ Clear Register RESET:0x0"
         bitfld.long 0x00 0. " DCU_GLOBAL_SECONDARY_IRQ_CLEAR_CLEAR_LINE_IRQ ,Clear line IRQ RESET:0x0"
          
         bitfld.long 0x00 1. " DCU_GLOBAL_SECONDARY_IRQ_CLEAR_CLEAR_FIFO_RUN_WARNING_IRQ ,Clear FIFO Underrun Warning IRQ RESET:0x0"
          
         bitfld.long 0x00 2. " DCU_GLOBAL_SECONDARY_IRQ_CLEAR_CLEAR_BUS_ERROR_IRQ ,Clear bus error IRQ RESET:0x0"
          
         bitfld.long 0x00 3. " DCU_GLOBAL_SECONDARY_IRQ_CLEAR_CLEAR_REGISTER_RELOAD_IRQ ,Clear register reload IRQ RESET:0x0"
          
         bitfld.long 0x00 4. " DCU_GLOBAL_SECONDARY_IRQ_CLEAR_CLEAR_SLAVE_SIGNAL_IRQ ,Clear slave timing no signal IRQ RESET:0x0"
          
         bitfld.long 0x00 5. " DCU_GLOBAL_SECONDARY_IRQ_CLEAR_CLEAR_SLAVE_SYNC_IRQ ,Clear slave timing not in sync IRQ RESET:0x0"
          
         bitfld.long 0x00 6. " DCU_GLOBAL_SECONDARY_IRQ_CLEAR_CLEAR_FIFO_RUN_KILLING_IRQ ,Clear FIFO Underrun Killing IRQ RESET:0x0"
          
         bitfld.long 0x00 7. " DCU_GLOBAL_SECONDARY_IRQ_CLEAR_CLEAR_CRC_IRQ ,Clear CRC IRQ RESET:0x0"
          
         bitfld.long 0x00 8. " DCU_GLOBAL_SECONDARY_IRQ_CLEAR_CLEAR_ROTATION_FIFO_ERROR_IRQ ,Clear Rotation FIFO Error Interrupt RESET:0x0"
          
         bitfld.long 0x00 9. " DCU_GLOBAL_SECONDARY_IRQ_CLEAR_CLEAR_BUS_STATUS_IRQ ,Clear Bus Status IRQ RESET:0x0"
          
         bitfld.long 0x00 10. " DCU_GLOBAL_SECONDARY_IRQ_CLEAR_CLEAR_CAPTURE_COMPLETE_IRQ ,Clear Capture Complete IRQ RESET:0x0"
          
         bitfld.long 0x00 16. " DCU_GLOBAL_SECONDARY_IRQ_CLEAR_CLEAR_LAYER_1_RELOAD_IRQ ,Clear Layer 1 Reload IRQ RESET:0x0"
          
         bitfld.long 0x00 17. " DCU_GLOBAL_SECONDARY_IRQ_CLEAR_CLEAR_LAYER_2_RELOAD_IRQ ,Clear Layer 2 Reload IRQ RESET:0x0"
          
         bitfld.long 0x00 18. " DCU_GLOBAL_SECONDARY_IRQ_CLEAR_CLEAR_LAYER_3_RELOAD_IRQ ,Clear Layer 3 Reload IRQ RESET:0x0"
          
rgroup.long 0x70++0x3
    line.long 0x00 "DCU_GLOBAL_SECURE_LINE_IRQ_POSITION_CONTROL, Secure Line IRQ Position Control Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_GLOBAL_SECURE_LINE_IRQ_POSITION_CONTROL_LINE_IRQ_POSITION ,Line IRQ position RESET:0x0"
          
group.long  0x78++0x3
    line.long 0x00 "DCU_GLOBAL_CRC_REFERENCE, CRC Reference Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_GLOBAL_CRC_REFERENCE_EXPECTED_CRC_FRAME ,Expected CRC of frame RESET:0x0"
          
rgroup.long 0x7c++0x3
    line.long 0x00 "DCU_GLOBAL_CRC_RESULT, CRC Result Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_GLOBAL_CRC_RESULT_ACTUAL_CRC_FRAME ,Actual CRC of (last) frame RESET:0x0"
          
group.long  0x80++0x3
    line.long 0x00 "DCU_GLOBAL_ROTATION_BUFFER_0_ADDRESS, Rotation Buffer 0 Address Register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_GLOBAL_ROTATION_BUFFER_0_ADDRESS_ROTATION_BUFFER_0_START_ADDRESS ,Rotation buffer 0 start address RESET:0x0"
          
group.long  0x84++0x3
    line.long 0x00 "DCU_GLOBAL_ROTATION_BUFFER_1_ADDRESS, Rotation Buffer 1 Address Register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_GLOBAL_ROTATION_BUFFER_1_ADDRESS_ROTATION_BUFFER_1_START_ADDRESS ,Rotation buffer 1 start address RESET:0x0"
          
group.long  0x88++0x3
    line.long 0x00 "DCU_GLOBAL_ROTATION_BUFFER_PITCH, Rotation Buffer Pitch Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_GLOBAL_ROTATION_BUFFER_PITCH_PITCH_ROTATION_BUFFERS_0_AND_1 ,Pitch for rotation buffers 0 and 1 RESET:0x0"
          
group.long  0x8c++0x3
    line.long 0x00 "DCU_GLOBAL_ROTATION_BLEND_COLOR, Rotation Blend Color Register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_GLOBAL_ROTATION_BLEND_COLOR_ROTATION_BLEND_COLOR ,Frame color used when switching from normal to rotation mode. Format: ARGB RESET:0x0"
          
group.long  0x90++0x3
    line.long 0x00 "DCU_GLOBAL_UNDERRUN_THRESHOLD, Underrun Threshold Register RESET:0x10"
         hexmask.long 0x00 0.--15. 1. " DCU_GLOBAL_UNDERRUN_THRESHOLD_THRESHOLD_RUN_KILLING_INTERRUPT ,Threshold for underrun killing interrupt RESET:0x10"
          
group.long  0x94++0x3
    line.long 0x00 "DCU_GLOBAL_ROTATION_FIFO_THRESHOLD, Rotation FIFO threshold register (RFTR) RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " DCU_GLOBAL_ROTATION_FIFO_THRESHOLD_READ_FIFO_LOW_THRESHOLD ,Read FIFO low Threshold RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " DCU_GLOBAL_ROTATION_FIFO_THRESHOLD_READ_FIFO_HIGH_THRESHOLD ,Read FIFO high Threshold RESET:0x0"
          
         hexmask.long 0x00 8.--10. 1. " DCU_GLOBAL_ROTATION_FIFO_THRESHOLD_WRITE_FIFO_LOW_THRESHOLD ,Write FIFO low Threshold RESET:0x0"
          
         hexmask.long 0x00 12.--14. 1. " DCU_GLOBAL_ROTATION_FIFO_THRESHOLD_WRITE_FIFO_HIGH_THRESHOLD ,Write FIFO high Threshold RESET:0x0"
          
rgroup.long 0x98++0x3
    line.long 0x00 "DCU_GLOBAL_PERFORMANCE_MONITOR, Performance Monitor Register (PMR) RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_GLOBAL_PERFORMANCE_MONITOR_PERFORMANCE_MONITOR ,Performance Monitor Register (PMR) RESET:0x0"
          
group.long  0xa4++0x3
    line.long 0x00 "DCU_GLOBAL_ROTATION_BUFFER_0_ADDR_MSB, Rotation Buffer 0 Address MSB RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_GLOBAL_ROTATION_BUFFER_0_ADDR_MSB_ROTATION_BUFFER_0_START_ADDR_MSB ,Rotation buffer 0 start address MSB bits RESET:0x0"
          
group.long  0xa8++0x3
    line.long 0x00 "DCU_GLOBAL_ROTATION_BUFFER_1_ADDR_MSB, Rotation Buffer 1 Address MSB RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_GLOBAL_ROTATION_BUFFER_1_ADDR_MSB_ROTATION_BUFFER_1_START_ADDR_MSB ,Rotation buffer 1 start address MSB bits RESET:0x0"
          
tree.end
    

tree "DCU__LAYER"
base e:0x40010100
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "DCU_LAYER_LAYER_CONFIGURATION_1, Layer Configuration 1 Register RESET:0xff50a075"
         bitfld.long 0x00 0. " DCU_LAYER_LAYER_CONFIGURATION_1_COLOR_KEY_ABILITY_ENA ,Color key ability enabled RESET:0x1"
          
         bitfld.long 0x00 1. " DCU_LAYER_LAYER_CONFIGURATION_1_COLOR_FB_DUPLICATION_ENA ,Color FB duplication ability enabled RESET:0x0"
          
         bitfld.long 0x00 2. " DCU_LAYER_LAYER_CONFIGURATION_1_COLOR_FB_PITCH_ENA ,Color FB pitch ability enabled RESET:0x1"
          
         bitfld.long 0x00 3. " DCU_LAYER_LAYER_CONFIGURATION_1_ALPHA_PLANE_ENA ,Alpha plane ability enabled RESET:0x0"
          
         bitfld.long 0x00 4. " DCU_LAYER_LAYER_CONFIGURATION_1_DEFAULT_COLOR_PROGRAMMABLE ,Default Color programmable RESET:0x1"
          
         bitfld.long 0x00 5. " DCU_LAYER_LAYER_CONFIGURATION_1_WINDOWING_ABILITY_ENA ,Windowing ability enabled RESET:0x1"
          
         bitfld.long 0x00 6. " DCU_LAYER_LAYER_CONFIGURATION_1_CLUT_ABILITY_ENA ,CLUT ability enabled RESET:0x1"
          
         bitfld.long 0x00 7. " DCU_LAYER_LAYER_CONFIGURATION_1_COLOR_KEY_REPLACE_ENA ,Color key replace ability enabled RESET:0x0"
          
         bitfld.long 0x00 8. " DCU_LAYER_LAYER_CONFIGURATION_1_ONE_VALUE_BLENDING_FACTORS_F2 ,1.0 (255) RESET:0x0"
          
         bitfld.long 0x00 9. " DCU_LAYER_LAYER_CONFIGURATION_1_ZERO_VALUE_BLENDING_FACTORS_F2 ,0.0 RESET:0x0"
          
         bitfld.long 0x00 10. " DCU_LAYER_LAYER_CONFIGURATION_1_PIXEL_ALPHA_BLENDING_FACTORS_F2 ,Pixel alpha RESET:0x0"
          
         bitfld.long 0x00 11. " DCU_LAYER_LAYER_CONFIGURATION_1_ONE_MINUS_PIXEL_ALPHA_BLENDING_FACTORS_F2 ,1.0 - pixel alpha RESET:0x0"
          
         bitfld.long 0x00 12. " DCU_LAYER_LAYER_CONFIGURATION_1_CONSTANT_ALPHA_BLENDING_FACTORS_F2 ,Constant alpha RESET:0x0"
          
         bitfld.long 0x00 13. " DCU_LAYER_LAYER_CONFIGURATION_1_ONE_MINUS_CONSTANT_ALPHA_BLENDING_FACTORS_F2 ,1.0 - constant alpha RESET:0x1"
          
         bitfld.long 0x00 14. " DCU_LAYER_LAYER_CONFIGURATION_1_PIXEL_ALPHA_MULT_CONSTANT_ALPHA_BLENDING_FACTORS_F2 ,pixel alpha * constant alpha RESET:0x0"
          
         bitfld.long 0x00 15. " DCU_LAYER_LAYER_CONFIGURATION_1_ONE_MINUS_PIXEL_ALPHA_MULT_CONSTANT_ALPHA_BLENDING_FACTORS_F2 ,1.0 - (pixel alpha * constant alpha) RESET:0x1"
          
         bitfld.long 0x00 16. " DCU_LAYER_LAYER_CONFIGURATION_1_ONE_BLENDING_FACTORS_F1 ,1.0 (255) RESET:0x0"
          
         bitfld.long 0x00 17. " DCU_LAYER_LAYER_CONFIGURATION_1_ZERO_BLENDING_FACTORS_F1 ,0.0 RESET:0x0"
          
         bitfld.long 0x00 18. " DCU_LAYER_LAYER_CONFIGURATION_1_PIXEL_ALPHA_BLENDING_FACTORS_F1 ,Pixel alpha RESET:0x0"
          
         bitfld.long 0x00 19. " DCU_LAYER_LAYER_CONFIGURATION_1_ONE_MINUS_PIXEL_ALPHA_BLENDING_FACTORS_F1 ,1.0 - pixel alpha RESET:0x0"
          
         bitfld.long 0x00 20. " DCU_LAYER_LAYER_CONFIGURATION_1_CONSTANT_ALPHA_BLENDING_FACTORS_F1 ,Constant alpha RESET:0x1"
          
         bitfld.long 0x00 21. " DCU_LAYER_LAYER_CONFIGURATION_1_ONE_MINUS_CONSTANT_ALPHA_BLENDING_FACTORS_F1 ,1.0 - constant alpha RESET:0x0"
          
         bitfld.long 0x00 22. " DCU_LAYER_LAYER_CONFIGURATION_1_PIXEL_ALPHA_MULT_CONSTANT_ALPHA_BLENDING_FACTORS_F1 ,pixel alpha * constant alpha RESET:0x1"
          
         bitfld.long 0x00 23. " DCU_LAYER_LAYER_CONFIGURATION_1_ONE_MINUS_PIXEL_ALPHA_MULT_CONSTANT_ALPHA_BLENDING_FACTORS_F1 ,1.0 - (pixel alpha * constant alpha) RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " DCU_LAYER_LAYER_CONFIGURATION_1_SUPPORTED_PIXEL_FORMATS ,Supported pixel formats (bit mask, custom) RESET:0xff"
          
rgroup.long 0x4++0x3
    line.long 0x00 "DCU_LAYER_LAYER_CONFIGURATION_2, Layer Configuration 2 Register RESET:0x80000007"
         bitfld.long 0x00 0. " DCU_LAYER_LAYER_CONFIGURATION_2_YCBCR_4_2_2_INTERLEAVED_ENA ,YCbCr 4:2:2 interleaved enabled RESET:0x1"
          
         bitfld.long 0x00 1. " DCU_LAYER_LAYER_CONFIGURATION_2_YCBCR_4_2_0_SEMI_PLANAR_ENA ,YCbCr 4:2:0 semi-planar enabled RESET:0x1"
          
         bitfld.long 0x00 2. " DCU_LAYER_LAYER_CONFIGURATION_2_YCBCR_4_2_0_FULLY_PLANAR_ENA ,YCbCr 4:2:0 fully planar enabled RESET:0x1"
          
         bitfld.long 0x00 31. " DCU_LAYER_LAYER_CONFIGURATION_2_SCALING_ABILITY_ENA ,Scaling ability enabled RESET:0x1"
          
group.long  0x8++0x3
    line.long 0x00 "DCU_LAYER_LAYER_RELOAD_CONTROL, Layer Reload Control Register RESET:0x0"
         bitfld.long 0x00 0. " DCU_LAYER_LAYER_RELOAD_CONTROL_SHADOW_RELOAD_IMMEDIATE ,Shadow reload control immediate RESET:0x0"
          
         bitfld.long 0x00 1. " DCU_LAYER_LAYER_RELOAD_CONTROL_SHADOW_RELOAD_VERTICAL_BLANKING ,Shadow reload control vertical blanking RESET:0x0"
          
         bitfld.long 0x00 2. " DCU_LAYER_LAYER_RELOAD_CONTROL_SHADOW_RELOAD_MASK_GLOBAL_RELOADING ,Shadow reload control mask global reloading RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "DCU_LAYER_LAYER_CONTROL, Layer Control RESET:0x0"
         bitfld.long 0x00 0. " DCU_LAYER_LAYER_CONTROL_LAYER_ON ,Layer on RESET:0x0"
          
         bitfld.long 0x00 1. " DCU_LAYER_LAYER_CONTROL_COLOR_FEATURE_ON ,Color key feature on RESET:0x0"
          
         bitfld.long 0x00 2. " DCU_LAYER_LAYER_CONTROL_VERTICAL_DUPLICATION_ON ,Vertical duplication on RESET:0x0"
          
         bitfld.long 0x00 3. " DCU_LAYER_LAYER_CONTROL_HORIZONTAL_DUPLICATION_ON ,Horizontal duplication on RESET:0x0"
          
         bitfld.long 0x00 4. " DCU_LAYER_LAYER_CONTROL_CLUT_LOOKUP_ON ,CLUT lookup on RESET:0x0"
          
         bitfld.long 0x00 5. " DCU_LAYER_LAYER_CONTROL_COLOR_REPLACE_ON ,Color key replace on RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " DCU_LAYER_LAYER_CONTROL_DUAL_VIEW_MODE ,Dual-view insertion mode RESET:0x0"
          
         bitfld.long 0x00 8. " DCU_LAYER_LAYER_CONTROL_HORIZONTAL_MIRRORING_ENA ,Horizontal mirroring enable RESET:0x0"
          
         bitfld.long 0x00 9. " DCU_LAYER_LAYER_CONTROL_DEFAULT_COLOR_BLENDING_ENA ,Default color blending enable RESET:0x0"
          
         bitfld.long 0x00 10. " DCU_LAYER_LAYER_CONTROL_SCALER_ENABLE ,Scaler enable RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "DCU_LAYER_WINDOW_HORIZONTAL_POSITION, Window Horizontal Position Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_LAYER_WINDOW_HORIZONTAL_POSITION_HORIZONTAL_START_POSITION ,Horizontal Start Position RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DCU_LAYER_WINDOW_HORIZONTAL_POSITION_HORIZONTAL_STOP_POSITION ,Horizontal Stop Position RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "DCU_LAYER_WINDOW_VERTICAL_POSITION, Window Vertical Position Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_LAYER_WINDOW_VERTICAL_POSITION_VERTICAL_START_POSITION ,Vertical Start Position RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DCU_LAYER_WINDOW_VERTICAL_POSITION_VERTICAL_STOP_POSITION ,Vertical Stop Position RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "DCU_LAYER_COLOR_KEY, Color Key Register RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " DCU_LAYER_COLOR_KEY_TRANSPARENCY_COLOR ,Transparency color RESET:0x0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "DCU_LAYER_PIXEL_FORMAT, Pixel Format Register RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " DCU_LAYER_PIXEL_FORMAT_PIX_FORMAT ,Pixel format RESET:0x0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "DCU_LAYER_CONSTANT_ALPHA, Constant Alpha Register RESET:0xff"
         hexmask.long 0x00 0.--7. 1. " DCU_LAYER_CONSTANT_ALPHA_CONST_ALPHA ,Constant Alpha RESET:0xff"
          
rgroup.long 0x24++0x3
    line.long 0x00 "DCU_LAYER_DEFAULT_COLOR, Default Color Register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_LAYER_DEFAULT_COLOR_DEFAULT_COLOR_ARGB ,Default color (ARGB) RESET:0x0"
          
rgroup.long 0x28++0x3
    line.long 0x00 "DCU_LAYER_BLENDING_CONFIGURATION, Blending Configuration Register RESET:0x607"
         hexmask.long 0x00 0.--2. 1. " DCU_LAYER_BLENDING_CONFIGURATION_SELECTION__FACTOR_F2 ,Selection of factor f2 RESET:0x7"
          
         hexmask.long 0x00 8.--10. 1. " DCU_LAYER_BLENDING_CONFIGURATION_SELECTION__FACTOR_F1 ,Selection of factor f1 RESET:0x6"
          
         hexmask.long 0x00 16.--18. 1. " DCU_LAYER_BLENDING_CONFIGURATION_BLENDING_ORDER_POSITION ,Layer blending order position (lower 3 bits used) RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "DCU_LAYER_FB_BUS_CONTROL, FB Bus Control Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DCU_LAYER_FB_BUS_CONTROL_WORDS_PER_BURST_NUMBER ,Number of words per burst when reading the frame buffers RESET:0x0"
          
rgroup.long 0x30++0x3
    line.long 0x00 "DCU_LAYER_AUXILIARY_FB_CONTROL, Auxiliary FB Control Register RESET:0x0"
         bitfld.long 0x00 0. " DCU_LAYER_AUXILIARY_FB_CONTROL_ALPHA_PLANE_ON ,Alpha plane on RESET:0x0"
          
         bitfld.long 0x00 1. " DCU_LAYER_AUXILIARY_FB_CONTROL_VERTICAL_DUPLICATION_ON ,Vertical duplication on RESET:0x0"
          
         bitfld.long 0x00 2. " DCU_LAYER_AUXILIARY_FB_CONTROL_HORIZONTAL_DUPLICATION_ON ,Horizontal duplication on RESET:0x0"
          
         bitfld.long 0x00 3. " DCU_LAYER_AUXILIARY_FB_CONTROL_YCBCR_CONVERSION_ENABLE_3_3 ,YCbCr conversion enable RESET:0x0"
          
         hexmask.long 0x00 4.--5. 1. " DCU_LAYER_AUXILIARY_FB_CONTROL_YCBCR_CONVERSION_ENABLE_5_4 ,YCbCr conversion enable RESET:0x0"
          
         bitfld.long 0x00 6. " DCU_LAYER_AUXILIARY_FB_CONTROL_Y_FIRST ,Y first RESET:0x0"
          
         bitfld.long 0x00 7. " DCU_LAYER_AUXILIARY_FB_CONTROL_CB_FIRST ,Cb first RESET:0x0"
          
         bitfld.long 0x00 8. " DCU_LAYER_AUXILIARY_FB_CONTROL_ODD_FIRST ,Odd first RESET:0x0"
          
         bitfld.long 0x00 9. " DCU_LAYER_AUXILIARY_FB_CONTROL_Y_HEADROOM_ENA ,Y headroom enable RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "DCU_LAYER_COLOR_FB_ADDRESS, Color FB Address Register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_LAYER_COLOR_FB_ADDRESS_COLOR_FB_START_ADDRESS ,Color FB start address RESET:0x0"
          
rgroup.long 0x38++0x3
    line.long 0x00 "DCU_LAYER_COLOR_FB_LENGTH, Color FB Pitch and Length Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_LAYER_COLOR_FB_LENGTH_COLOR_FB_PLUS_BUS_WIDTH ,Line length of color FB in bytes – 1 + (width of bus in bytes) RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DCU_LAYER_COLOR_FB_LENGTH_COLOR_FB_PITCH ,Pitch of color FB in bytes (signed) RESET:0x0"
          
rgroup.long 0x3c++0x3
    line.long 0x00 "DCU_LAYER_COLOR_FB_LINES, Color FB Lines Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_LAYER_COLOR_FB_LINES_NUMBER_OF_LINES_COLOR_FB ,Number of lines in the color FB RESET:0x0"
          
rgroup.long 0x40++0x3
    line.long 0x00 "DCU_LAYER_AUXILIARY_0_FB_ADDRESS, Auxiliary 0 FB Address Register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_LAYER_AUXILIARY_0_FB_ADDRESS_AUXILIARY_0_FB_START_ADDRESS ,Auxiliary 0 FB start address RESET:0x0"
          
rgroup.long 0x44++0x3
    line.long 0x00 "DCU_LAYER_AUXILIARY_1_FB_ADDRESS, Auxiliary 1 FB Address Register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_LAYER_AUXILIARY_1_FB_ADDRESS_AUXILIARY_1_FB_START_ADDRESS ,Auxiliary 1 FB start address (YCbCr planar mode only) RESET:0x0"
          
rgroup.long 0x48++0x3
    line.long 0x00 "DCU_LAYER_AUXILIARY_FB_LENGTH, Auxiliary FB Length Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_LAYER_AUXILIARY_FB_LENGTH_AUXILIARY_LENGTH_PLUS_BUS_WIDTH ,Line length of auxiliary FB in bytes-1 + (width of bus in bytes) RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DCU_LAYER_AUXILIARY_FB_LENGTH_PITCH_OF_AUXILIARY_FB ,Pitch of auxiliary 0/1 FB in bytes RESET:0x0"
          
rgroup.long 0x4c++0x3
    line.long 0x00 "DCU_LAYER_AUXILIARY_FB_LINES, Auxiliary FB Lines Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_LAYER_AUXILIARY_FB_LINES_NUMBER_OF_LINES_IN_AUXILIARY_FB ,Number of lines in the auxiliary 0/1 frame buffer RESET:0x0"
          
wgroup.long 0x50++0x3
    line.long 0x00 "DCU_LAYER_CLUT_WRITE_ACCESS, CLUT Write Access Register RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " DCU_LAYER_CLUT_WRITE_ACCESS_RGB888_VALUE ,RGB888 value to be written RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " DCU_LAYER_CLUT_WRITE_ACCESS_CLUT_ENTRY_ADDRESS ,Address of CLUT entry RESET:0x0"
          
group.long  0x54++0x3
    line.long 0x00 "DCU_LAYER_SCALER_INPUT_SIZE, Scaler Input Size Register RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " DCU_LAYER_SCALER_INPUT_SIZE_SCALER_INPUT_WIDTH ,Scaler input width RESET:0x0"
          
         hexmask.long 0x00 16.--27. 1. " DCU_LAYER_SCALER_INPUT_SIZE_SCALER_INPUT_HEIGHT ,Scaler input height RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "DCU_LAYER_SCALER_OUTPUT_SIZE, Scaler Output Size Register RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " DCU_LAYER_SCALER_OUTPUT_SIZE_SCALER_OUTPUT_WIDTH ,Scaler Output width RESET:0x0"
          
         hexmask.long 0x00 16.--27. 1. " DCU_LAYER_SCALER_OUTPUT_SIZE_SCALER_OUTPUT_HEIGHT ,Scaler Output height RESET:0x0"
          
group.long  0x5c++0x3
    line.long 0x00 "DCU_LAYER_VERTICAL_SCALING_FACTOR, Vertical Scaling Factor Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_LAYER_VERTICAL_SCALING_FACTOR_VERTICAL_SCALING_FACTOR ,Vertical scaling factor RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "DCU_LAYER_VERTICAL_SCALING_PHASE, Vertical Scaling Phase Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_LAYER_VERTICAL_SCALING_PHASE_VERTICAL_SCALING_PHASE ,Vertical scaling phase RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "DCU_LAYER_HORIZONTAL_SCALING_FACTOR, Horizontal Scaling Factor Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_LAYER_HORIZONTAL_SCALING_FACTOR_HORIZONTAL_SCALING_FACTOR ,Horizontal scaling factor RESET:0x0"
          
group.long  0x68++0x3
    line.long 0x00 "DCU_LAYER_HORIZONTAL_SCALING_PHASE, Horizontal Scaling Phase Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_LAYER_HORIZONTAL_SCALING_PHASE_HORIZONTAL_SCALING_PHASE ,Horizontal scaling phase RESET:0x0"
          
group.long  0x6c++0x3
    line.long 0x00 "DCU_LAYER_YCBCR_SCALE_1, YCbCr Scale 1 Register RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " DCU_LAYER_YCBCR_SCALE_1_RED_CR_SCALE ,Red Cr scale RESET:0x0"
          
         hexmask.long 0x00 16.--25. 1. " DCU_LAYER_YCBCR_SCALE_1_BLUE_CB_SCALE ,Blue Cb scale RESET:0x0"
          
group.long  0x70++0x3
    line.long 0x00 "DCU_LAYER_YCBCR_SCALE_2, YCbCr Scale 2 Register RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " DCU_LAYER_YCBCR_SCALE_2_GREEN_CR_SCALE ,Green Cr scale RESET:0x0"
          
         hexmask.long 0x00 16.--25. 1. " DCU_LAYER_YCBCR_SCALE_2_GREEN_CB_SCALE ,Green Cb scale RESET:0x0"
          
group.long  0x74++0x3
    line.long 0x00 "DCU_LAYER_FLEXIBLE_COLOR_FORMAT_1, Flexible color format 1 RESET:0x21100"
         hexmask.long 0x00 0.--4. 1. " DCU_LAYER_FLEXIBLE_COLOR_FORMAT_1_ALPHA_START_BIT ,Alpha Start Bit RESET:0x0"
          
         hexmask.long 0x00 5.--8. 1. " DCU_LAYER_FLEXIBLE_COLOR_FORMAT_1_ALPHA_LENGTH_BITS ,Alpha Length Bits RESET:0x8"
          
         hexmask.long 0x00 9.--13. 1. " DCU_LAYER_FLEXIBLE_COLOR_FORMAT_1_RED_START_BIT ,Red Start Bit RESET:0x8"
          
         hexmask.long 0x00 14.--18. 1. " DCU_LAYER_FLEXIBLE_COLOR_FORMAT_1_RED_LENGTH_BITS ,Red Length Bits RESET:0x8"
          
group.long  0x78++0x3
    line.long 0x00 "DCU_LAYER_FLEXIBLE_COLOR_FORMAT_2, Flexible color format 2 RESET:0x123110"
         hexmask.long 0x00 0.--4. 1. " DCU_LAYER_FLEXIBLE_COLOR_FORMAT_2_GREEN_START_BIT ,Green Start Bit RESET:0x10"
          
         hexmask.long 0x00 5.--8. 1. " DCU_LAYER_FLEXIBLE_COLOR_FORMAT_2_GREEN_LENGTH_BITS ,Green Length Bits RESET:0x8"
          
         hexmask.long 0x00 9.--13. 1. " DCU_LAYER_FLEXIBLE_COLOR_FORMAT_2_BLUE_START_BIT ,Blue Start Bit RESET:0x18"
          
         hexmask.long 0x00 14.--17. 1. " DCU_LAYER_FLEXIBLE_COLOR_FORMAT_2_BLUE_LENGTH_BITS ,Blue Length Bits RESET:0x8"
          
         hexmask.long 0x00 18.--20. 1. " DCU_LAYER_FLEXIBLE_COLOR_FORMAT_2_BYTES_PER_PIXEL ,Bytes per Pixel RESET:0x4"
          
group.long  0x7c++0x3
    line.long 0x00 "DCU_LAYER_LAYER_FIFO_THRESHOLDS, Layer FIFO Thresholds RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " DCU_LAYER_LAYER_FIFO_THRESHOLDS_COLOR_FIFO_LOW_THRESHOLD ,Color FIFO low Threshold RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " DCU_LAYER_LAYER_FIFO_THRESHOLDS_COLOR_FIFO_HIGH_THRESHOLD ,Color FIFO high Threshold RESET:0x0"
          
         hexmask.long 0x00 8.--10. 1. " DCU_LAYER_LAYER_FIFO_THRESHOLDS_AUXILIARY_0_FIFO_LOW_THRESHOLD ,Auxiliary 0 FIFO low Threshold RESET:0x0"
          
         hexmask.long 0x00 12.--14. 1. " DCU_LAYER_LAYER_FIFO_THRESHOLDS_AUXILIARY_0_FIFO_HIGH_THRESHOLD ,Auxiliary 0 FIFO high Threshold RESET:0x0"
          
         hexmask.long 0x00 16.--18. 1. " DCU_LAYER_LAYER_FIFO_THRESHOLDS_AUXILIARY_1_FIFO_LOW_THRESHOLD ,Auxiliary 1 FIFO low Threshold RESET:0x0"
          
         hexmask.long 0x00 20.--22. 1. " DCU_LAYER_LAYER_FIFO_THRESHOLDS_AUXILIARY_1_FIFO_HIGH_THRESHOLD ,Auxiliary 1 FIFO high Threshold RESET:0x0"
          
group.long  0x80++0x3
    line.long 0x00 "DCU_LAYER_COLOR_FB_ADDRESS_MSB, Color FB Address MSB RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DCU_LAYER_COLOR_FB_ADDRESS_MSB_COLOR_FB_ADDRESS_MSB ,Color FB start Address MSB RESET:0x0"
          
group.long  0x84++0x3
    line.long 0x00 "DCU_LAYER_AUXILIARY_0_FB_ADDRESS_MSB, Auxiliary 0 FB Address MSB RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DCU_LAYER_AUXILIARY_0_FB_ADDRESS_MSB_AUXILIARY_0_FB_ADDRESS_MSB ,Auxiliary 0 FB start Address MSB RESET:0x0"
          
group.long  0x88++0x3
    line.long 0x00 "DCU_LAYER_AUXILIARY_1_FB_ADDRESS_MSB, Auxiliary 1 FB Address MSB RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DCU_LAYER_AUXILIARY_1_FB_ADDRESS_MSB_AUXILIARY_1_FB_ADDRESS_MSB ,Auxiliary 1 FB start Address MSB RESET:0x0"
          
tree.end

tree "GPU"
base e:0x40018000
width 80.
tree.end
    

tree "GPU__CONTROL"
base e:0x40018000
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "GPU_CONTROL_VERSION, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_VERSION_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "GPU_CONTROL_CONFIG_1, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_CONFIG_1_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "GPU_CONTROL_CONFIG_2, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_CONFIG_2_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "GPU_CONTROL_CONFIG_3, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_CONFIG_3_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "GPU_CONTROL_CONFIG_4, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_CONFIG_4_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "GPU_CONTROL_CONFIG_5, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_CONFIG_5_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "GPU_CONTROL_BUSY, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_BUSY_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "GPU_CONTROL_IRQ_MASK, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_IRQ_MASK_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "GPU_CONTROL_IRQ_STATE, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_IRQ_STATE_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "GPU_CONTROL_PGM_BASE_ADDR, Program base address. Always write before program data registers. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_PGM_BASE_ADDR_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "GPU_CONTROL_STREAM_ADDR, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_STREAM_ADDR_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "GPU_CONTROL_STREAM_POS, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_STREAM_POS_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "GPU_CONTROL_SYNC_0, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_SYNC_0_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "GPU_CONTROL_SYNC_1, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_SYNC_1_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "GPU_CONTROL_SYNC_2, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_SYNC_2_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
rgroup.long 0x3c++0x3
    line.long 0x00 "GPU_CONTROL_RETURN_ADDRESS, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_RETURN_ADDRESS_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "GPU_CONTROL_PRIM_COUNT, TODO RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " GPU_CONTROL_PRIM_COUNT_DNX_U6 ,6- bit unsigned integer RESET:0x0"
          
group.long  0x44++0x3
    line.long 0x00 "GPU_CONTROL_PC_SELECT_1, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_PC_SELECT_1_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "GPU_CONTROL_PC_SELECT_2, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_PC_SELECT_2_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "GPU_CONTROL_PC_SELECT_3, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_PC_SELECT_3_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "GPU_CONTROL_PC_SELECT_4, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_PC_SELECT_4_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x54++0x3
    line.long 0x00 "GPU_CONTROL_L2_CACHE, TODO RESET:0x0"
         bitfld.long 0x00 0. " GPU_CONTROL_L2_CACHE_DISABLE ,Disable the L2 cache RESET:0x0"
          
         bitfld.long 0x00 1. " GPU_CONTROL_L2_CACHE_FLUSH ,Flush the L2 cache RESET:0x0"
          
wgroup.long 0x60++0x3
    line.long 0x00 "GPU_CONTROL_IRQ_TRIGGER, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_IRQ_TRIGGER_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
wgroup.long 0x64++0x3
    line.long 0x00 "GPU_CONTROL_SOFT_RESET, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_SOFT_RESET_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x70++0x3
    line.long 0x00 "GPU_CONTROL_OUT_OUF_BOUNDS, FB write out of bounds counter RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONTROL_OUT_OUF_BOUNDS_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x74++0x3
    line.long 0x00 "GPU_CONTROL_SWITCHES, developer debug switches RESET:0x0"
         bitfld.long 0x00 0. " GPU_CONTROL_SWITCHES_ALWAYS_STALL ,Force a stall on every instruction RESET:0x0"
          
         hexmask.long 0x00 1.--2. 1. " GPU_CONTROL_SWITCHES_ZS_ADDRESS_MODE ,Address mode of ZS buffer RESET:0x0"
          
         bitfld.long 0x00 3. " GPU_CONTROL_SWITCHES_BARY_MASK ,Mask barycentric mantissa bits in rasterizer RESET:0x0"
          
tree.end
    

tree "GPU__SNAPSHOT"
base e:0x40018080
width 80.
group.long  0x0++0x3
    line.long 0x00 "GPU_SNAPSHOT_SNAPSHOT_0, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_SNAPSHOT_SNAPSHOT_0_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "GPU_SNAPSHOT_SNAPSHOT_1, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_SNAPSHOT_SNAPSHOT_1_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "GPU_SNAPSHOT_SNAPSHOT_2, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_SNAPSHOT_SNAPSHOT_2_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "GPU_SNAPSHOT_SNAPSHOT_3, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_SNAPSHOT_SNAPSHOT_3_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "GPU_SNAPSHOT_SNAPSHOT_4, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_SNAPSHOT_SNAPSHOT_4_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "GPU_SNAPSHOT_SNAPSHOT_5, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_SNAPSHOT_SNAPSHOT_5_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "GPU_SNAPSHOT_SNAPSHOT_6, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_SNAPSHOT_SNAPSHOT_6_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "GPU_SNAPSHOT_SNAPSHOT_7, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_SNAPSHOT_SNAPSHOT_7_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
tree.end
    

tree "GPU__COUNTER"
base e:0x40018100
width 80.
group.long  0x0++0x3
    line.long 0x00 "GPU_COUNTER_PERFCOUNT_0, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_COUNTER_PERFCOUNT_0_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "GPU_COUNTER_PERFCOUNT_1, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_COUNTER_PERFCOUNT_1_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "GPU_COUNTER_PERFCOUNT_2, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_COUNTER_PERFCOUNT_2_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "GPU_COUNTER_PERFCOUNT_3, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_COUNTER_PERFCOUNT_3_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "GPU_COUNTER_PERFCOUNT_4, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_COUNTER_PERFCOUNT_4_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "GPU_COUNTER_PERFCOUNT_5, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_COUNTER_PERFCOUNT_5_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "GPU_COUNTER_PERFCOUNT_6, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_COUNTER_PERFCOUNT_6_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "GPU_COUNTER_PERFCOUNT_7, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_COUNTER_PERFCOUNT_7_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
tree.end
    

tree "GPU__RASTERIZER"
base e:0x40019000
width 80.
group.long  0x0++0x3
    line.long 0x00 "GPU_RASTERIZER_A0, A0 edge coefficient RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_RASTERIZER_A0_DNX_FLOAT32 ,float32 RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "GPU_RASTERIZER_A1, A1 edge coefficient RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_RASTERIZER_A1_DNX_FLOAT32 ,float32 RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "GPU_RASTERIZER_A2, A2 edge coefficient RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_RASTERIZER_A2_DNX_FLOAT32 ,float32 RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "GPU_RASTERIZER_A3, A3 edge coefficient RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_RASTERIZER_A3_DNX_FLOAT32 ,float32 RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "GPU_RASTERIZER_A4, A4 edge coefficient RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_RASTERIZER_A4_DNX_FLOAT32 ,float32 RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "GPU_RASTERIZER_A5, A5 edge coefficient RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_RASTERIZER_A5_DNX_FLOAT32 ,float32 RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "GPU_RASTERIZER_A6, A6 edge coefficient RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_RASTERIZER_A6_DNX_FLOAT32 ,float32 RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "GPU_RASTERIZER_A7, A7 edge coefficient RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_RASTERIZER_A7_DNX_FLOAT32 ,float32 RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "GPU_RASTERIZER_A8, A8 edge coefficient RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_RASTERIZER_A8_DNX_FLOAT32 ,float32 RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "GPU_RASTERIZER_D0, D0 depth coefficient RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_RASTERIZER_D0_DNX_FLOAT32 ,float32 RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "GPU_RASTERIZER_D1, D1 depth coefficient RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_RASTERIZER_D1_DNX_FLOAT32 ,float32 RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "GPU_RASTERIZER_D2, D2 depth coefficient RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_RASTERIZER_D2_DNX_FLOAT32 ,float32 RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "GPU_RASTERIZER_BBOX_MAX, Bounding box max x/y RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " GPU_RASTERIZER_BBOX_MAX_X ,X Maximum or Minimum RESET:0x0"
          
         hexmask.long 0x00 3.--5. 1. " GPU_RASTERIZER_BBOX_MAX_Y ,Y Maximum or Minimum RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "GPU_RASTERIZER_BBOX_MIN, Bounding box min x/y RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " GPU_RASTERIZER_BBOX_MIN_X ,X Maximum or Minimum RESET:0x0"
          
         hexmask.long 0x00 3.--5. 1. " GPU_RASTERIZER_BBOX_MIN_Y ,Y Maximum or Minimum RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "GPU_RASTERIZER_CONTROL, Orientation and triangle slot idx. Also triggers rasterizer start. RESET:0x0"
         bitfld.long 0x00 0. " GPU_RASTERIZER_CONTROL_ORIENTATION ,Triangle orientation (0=CW,1=CCW) RESET:0x0"
          
         hexmask.long 0x00 1.--14. 1. " GPU_RASTERIZER_CONTROL_CULL ,Cull triangle (short path in rasterizer) RESET:0x0"
          
         hexmask.long 0x00 15.--27. 1. " GPU_RASTERIZER_CONTROL_VARYING_SLOT_IDX ,Varying slot index RESET:0x0"
          
tree.end
    

tree "GPU__VAR_2"
base e:0x4001903c
width 80.
group.long  0x0++0x3
    line.long 0x00 "GPU_VAR_2_MS_CONTROL, TODO RESET:0x0"
         bitfld.long 0x00 0. " GPU_VAR_2_MS_CONTROL_MS_ENABLE ,Enable multisampling. RESET:0x0"
          
         bitfld.long 0x00 1. " GPU_VAR_2_MS_CONTROL_ALPHA_TO_COVERAGE ,Enable alpha to coverage. RESET:0x0"
          
         bitfld.long 0x00 2. " GPU_VAR_2_MS_CONTROL_COVERAGE_INVERT ,Use an inverse coverage mask in alpha to coverage. RESET:0x0"
          
         hexmask.long 0x00 3.--6. 1. " GPU_VAR_2_MS_CONTROL_COVERAGE_MASK ,Additional manual coverage mask (set to b1111 to disable). RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "GPU_VAR_2_MS_SAMPLE_POS, Multi sampling grid positions for a stamp. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " GPU_VAR_2_MS_SAMPLE_POS_PIXEL0 ,Sample position for pixel 0 (TL). RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " GPU_VAR_2_MS_SAMPLE_POS_PIXEL1 ,Sample position for pixel 1 (TR). RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " GPU_VAR_2_MS_SAMPLE_POS_PIXEL3 ,Sample position for pixel 3 (BR). RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " GPU_VAR_2_MS_SAMPLE_POS_PIXEL2 ,Sample position for pixel 2 (BL). RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "GPU_VAR_2_FAST_CLEAR_DRAW_MODE, TODO RESET:0x0"
         bitfld.long 0x00 0. " GPU_VAR_2_FAST_CLEAR_DRAW_MODE_DNX_FAST_CLEAR_DRAW_MODE ,fast clear draw mode RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "GPU_VAR_2_FAST_CLEAR_ENABLE, Fast clear enable bits for color buffer and depth/stencil buffer RESET:0x0"
         bitfld.long 0x00 0. " GPU_VAR_2_FAST_CLEAR_ENABLE_COLOR ,Color buffer fast clear enable bit RESET:0x0"
          
         bitfld.long 0x00 1. " GPU_VAR_2_FAST_CLEAR_ENABLE_ZS ,Depth/stencil buffer fast clear enable bit RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "GPU_VAR_2_CLEAR_COLOR, Clear color value RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_VAR_2_CLEAR_COLOR_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "GPU_VAR_2_CLEAR_DEPTH_STENCIL, Depth/stencil clear value RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_VAR_2_CLEAR_DEPTH_STENCIL_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "GPU_VAR_2_PGM_DATA_COM, Compute program data RESET:0x0"
         hexmask.long 0x00 0.--21. 1. " GPU_VAR_2_PGM_DATA_COM_START_ADDR ,Shader start address in shader memory arena (relative to PGM base address) RESET:0x0"
          
         hexmask.long 0x00 22.--31. 1. " GPU_VAR_2_PGM_DATA_COM_MEM_SIZE ,Number of addressed shader memory words for this shader. RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "GPU_VAR_2_PGM_DATA_GEO, Geometry program data RESET:0x0"
         hexmask.long 0x00 0.--21. 1. " GPU_VAR_2_PGM_DATA_GEO_START_ADDR ,Shader start address in shader memory arena (relative to PGM base address) RESET:0x0"
          
         hexmask.long 0x00 22.--31. 1. " GPU_VAR_2_PGM_DATA_GEO_MEM_SIZE ,Number of addressed shader memory words for this shader. RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "GPU_VAR_2_PGM_DATA_FRG, Fragment program data RESET:0x0"
         hexmask.long 0x00 0.--21. 1. " GPU_VAR_2_PGM_DATA_FRG_START_ADDR ,Shader start address in shader memory arena (relative to PGM base address) RESET:0x0"
          
         hexmask.long 0x00 22.--31. 1. " GPU_VAR_2_PGM_DATA_FRG_MEM_SIZE ,Number of addressed shader memory words for this shader. RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "GPU_VAR_2_PGM_DATA_VTX, Vertex program data RESET:0x0"
         hexmask.long 0x00 0.--21. 1. " GPU_VAR_2_PGM_DATA_VTX_START_ADDR ,Shader start address in shader memory arena (relative to PGM base address) RESET:0x0"
          
         hexmask.long 0x00 22.--31. 1. " GPU_VAR_2_PGM_DATA_VTX_MEM_SIZE ,Number of addressed shader memory words for this shader. RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "GPU_VAR_2_PGM_LENGTH_COM, Compute program length in cache lines. (deprecated) RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " GPU_VAR_2_PGM_LENGTH_COM_DNX_SHADER_PGM_LENGTH ,shader program length in instruction cache lines RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "GPU_VAR_2_PGM_LENGTH_GEO, Geometry program length in cache lines. (deprecated) RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " GPU_VAR_2_PGM_LENGTH_GEO_DNX_SHADER_PGM_LENGTH ,shader program length in instruction cache lines RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "GPU_VAR_2_PGM_LENGTH_FRG, Shader program length in cache lines. (deprecated) RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " GPU_VAR_2_PGM_LENGTH_FRG_DNX_SHADER_PGM_LENGTH ,shader program length in instruction cache lines RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "GPU_VAR_2_PGM_LENGTH_VTX, Vertex program length in cache lines. (deprecated) RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " GPU_VAR_2_PGM_LENGTH_VTX_DNX_SHADER_PGM_LENGTH ,shader program length in instruction cache lines RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "GPU_VAR_2_FLUSH_PIPELINE, Flush render pipeline (FB cache, ZSU cache) RESET:0x0"
         bitfld.long 0x00 0. " GPU_VAR_2_FLUSH_PIPELINE_DNX_BOOL ,boolean type RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "GPU_VAR_2_FLUSH_CACHES, Flush FB, ZSU and instruction caches. RESET:0x0"
         bitfld.long 0x00 0. " GPU_VAR_2_FLUSH_CACHES_FB ,flush FB cache RESET:0x0"
          
         bitfld.long 0x00 1. " GPU_VAR_2_FLUSH_CACHES_ZS ,flush ZS cache RESET:0x0"
          
         bitfld.long 0x00 2. " GPU_VAR_2_FLUSH_CACHES_PGM ,flush instruction cache RESET:0x0"
          
tree.end
    

tree "GPU__FB"
base e:0x4001907c
width 80.
group.long  0x0++0x3
    line.long 0x00 "GPU_FB_ADDRESS, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_FB_ADDRESS_DNX_PTR ,32-bit pointer RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "GPU_FB_BPP, TODO RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " GPU_FB_BPP_DNX_BPP ,bytes per pixel RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "GPU_FB_BYTE_PITCH, TODO RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " GPU_FB_BYTE_PITCH_DNX_FB_PITCH ,framebuffer pitch in bytes RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "GPU_FB_ADDRESS_MODE, TODO RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " GPU_FB_ADDRESS_MODE_DNX_SWIZZLE_MODE ,texture swizzling mode RESET:0x0"
          
tree.end
    

tree "GPU__VAR_3"
base e:0x4001908c
width 80.
group.long  0x0++0x3
    line.long 0x00 "GPU_VAR_3_CONST_COLOR, TODO RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " GPU_VAR_3_CONST_COLOR_B ,blue channel RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " GPU_VAR_3_CONST_COLOR_G ,green channel RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " GPU_VAR_3_CONST_COLOR_RED ,red channel RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " GPU_VAR_3_CONST_COLOR_A ,alpha channel RESET:0x0"
          
tree.end
    

tree "GPU__DRAW"
base e:0x40019090
width 80.
group.long  0x0++0x3
    line.long 0x00 "GPU_DRAW_OUT_SIZE, Size and offset of vertex and geometry shading result in scratch RAM. Offset given in 16 word (32 bit) steps. RESET:0x0"
         bitfld.long 0x00 0. " GPU_DRAW_OUT_SIZE_COUNT_VTX ,Vertex shader output count (sRAM stride) RESET:0x0"
          
         bitfld.long 0x00 1. " GPU_DRAW_OUT_SIZE_COUNT_GEO ,Geometry shader output count (sRAM stride) RESET:0x0"
          
         hexmask.long 0x00 2.--9. 1. " GPU_DRAW_OUT_SIZE_OFFSET_VTX ,Vertex shader output offset RESET:0x0"
          
         hexmask.long 0x00 10.--17. 1. " GPU_DRAW_OUT_SIZE_OFFSET_GEO ,Geometry shader output offset RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "GPU_DRAW_PRIMITIVE_MODE, Primitive mode (triangle list, triangle fan, ...) RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " GPU_DRAW_PRIMITIVE_MODE_DNX_PRIMITIVE_MODE ,primitive mode RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "GPU_DRAW_INDEX_TYPE, Type of index entries. RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " GPU_DRAW_INDEX_TYPE_DNX_INDEX_TYPE ,index type RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "GPU_DRAW_INDEX_ADDR, Index buffer address. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_DRAW_INDEX_ADDR_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "GPU_DRAW_INDEX_COUNT, Number of indices in buffer. RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " GPU_DRAW_INDEX_COUNT_DNX_INDEX_COUNT ,index count RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "GPU_DRAW_INDEX_BUFFER_WORD_COUNT, Size of index buffer in bus words. RESET:0x0"
         hexmask.long 0x00 0.--18. 1. " GPU_DRAW_INDEX_BUFFER_WORD_COUNT_DNX_INDEX_BUFFER_WORD_COUNT ,index buffer word count RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "GPU_DRAW_BATCH_SIZE, Max size of a vertex and primitive batch. Used to limit the usage of scratch RAM by vertex shading/geometry shading results. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " GPU_DRAW_BATCH_SIZE_VTX ,Max size of vertex batch (max used entries in vertex cache) RESET:0x0"
          
         bitfld.long 0x00 8. " GPU_DRAW_BATCH_SIZE_PRIM ,Max size of primitive batch (max used entries in primitive buffer) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "GPU_DRAW_TRANSFORM_BUFFER_ADDR, Address of transform buffer for transform feedback results. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_DRAW_TRANSFORM_BUFFER_ADDR_DNX_PTR ,32-bit pointer RESET:0x0"
          
tree.end
    

tree "GPU__ZSBUFFER"
base e:0x400190b0
width 80.
group.long  0x0++0x3
    line.long 0x00 "GPU_ZSBUFFER_ZS_CONTROL, TODO RESET:0x0"
         bitfld.long 0x00 0. " GPU_ZSBUFFER_ZS_CONTROL_ZS_ENABLE ,TODO RESET:0x0"
          
         bitfld.long 0x00 1. " GPU_ZSBUFFER_ZS_CONTROL_DEPTH_WRITE ,TODO RESET:0x0"
          
         hexmask.long 0x00 2.--4. 1. " GPU_ZSBUFFER_ZS_CONTROL_DEPTH_FUNC ,TODO RESET:0x0"
          
         hexmask.long 0x00 5.--7. 1. " GPU_ZSBUFFER_ZS_CONTROL_ZS_TEST_FAILED_OP_F ,TODO RESET:0x0"
          
         hexmask.long 0x00 8.--10. 1. " GPU_ZSBUFFER_ZS_CONTROL_ZS_TEST_PASSED_OP_F ,TODO RESET:0x0"
          
         hexmask.long 0x00 11.--13. 1. " GPU_ZSBUFFER_ZS_CONTROL_STENCIL_TEST_FAILED_OP_F ,TODO RESET:0x0"
          
         hexmask.long 0x00 14.--16. 1. " GPU_ZSBUFFER_ZS_CONTROL_STENCIL_FUNC_F ,TODO RESET:0x0"
          
         hexmask.long 0x00 17.--19. 1. " GPU_ZSBUFFER_ZS_CONTROL_ZS_TEST_FAILED_OP_B ,TODO RESET:0x0"
          
         hexmask.long 0x00 20.--22. 1. " GPU_ZSBUFFER_ZS_CONTROL_ZS_TEST_PASSED_OP_B ,TODO RESET:0x0"
          
         hexmask.long 0x00 23.--25. 1. " GPU_ZSBUFFER_ZS_CONTROL_STENCIL_TEST_FAILED_OP_B ,TODO RESET:0x0"
          
         hexmask.long 0x00 26.--28. 1. " GPU_ZSBUFFER_ZS_CONTROL_STENCIL_FUNC_B ,TODO RESET:0x0"
          
         bitfld.long 0x00 29. " GPU_ZSBUFFER_ZS_CONTROL_LATE_ZS_ENABLE ,Do the ZS test/writeback after fragment shading. RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "GPU_ZSBUFFER_STENCIL_REF_MASK_F, ref, mask and write mask for front faced triangles RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " GPU_ZSBUFFER_STENCIL_REF_MASK_F_STENCIL_MASK ,TODO RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " GPU_ZSBUFFER_STENCIL_REF_MASK_F_STENCIL_REF ,TODO RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " GPU_ZSBUFFER_STENCIL_REF_MASK_F_STENCIL_WRITE_MASK ,TODO RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "GPU_ZSBUFFER_STENCIL_REF_MASK_B, ref, mask and write mask for back faced triangles RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " GPU_ZSBUFFER_STENCIL_REF_MASK_B_STENCIL_MASK ,TODO RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " GPU_ZSBUFFER_STENCIL_REF_MASK_B_STENCIL_REF ,TODO RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " GPU_ZSBUFFER_STENCIL_REF_MASK_B_STENCIL_WRITE_MASK ,TODO RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "GPU_ZSBUFFER_ZSB_CONFIG, TODO RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " GPU_ZSBUFFER_ZSB_CONFIG_ZSB_BPP ,TODO RESET:0x0"
          
         hexmask.long 0x00 3.--4. 1. " GPU_ZSBUFFER_ZSB_CONFIG_ZSB_ORG ,TODO RESET:0x0"
          
         hexmask.long 0x00 5.--19. 1. " GPU_ZSBUFFER_ZSB_CONFIG_ZSB_BYTE_PITCH ,TODO RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "GPU_ZSBUFFER_ZSB_ADDRESS, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ZSBUFFER_ZSB_ADDRESS_DNX_PTR ,32-bit pointer RESET:0x0"
          
tree.end
    

tree "GPU__SDMA"
base e:0x400190c4
width 80.
group.long  0x0++0x3
    line.long 0x00 "GPU_SDMA_CRC, CRC32 register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_SDMA_CRC_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "GPU_SDMA_SRC_ADDR, Source address for SDMA RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_SDMA_SRC_ADDR_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "GPU_SDMA_DST_ADDR, Destination address for SDMA RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_SDMA_DST_ADDR_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "GPU_SDMA_PARAM, SDMA parameter RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " GPU_SDMA_PARAM_ATTRIBUTE_COUNT ,Number of elements per data set RESET:0x0"
          
         hexmask.long 0x00 6.--12. 1. " GPU_SDMA_PARAM_DATASET_COUNT ,Number of data sets RESET:0x0"
          
         hexmask.long 0x00 13.--20. 1. " GPU_SDMA_PARAM_OFFSET ,Offset in scratch RAM RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "GPU_SDMA_CONTROL, Type of SDMA transfer RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " GPU_SDMA_CONTROL_SHADER_MASK ,TODO RESET:0x0"
          
         bitfld.long 0x00 16. " GPU_SDMA_CONTROL_CRC_ENABLE ,TODO RESET:0x0"
          
         hexmask.long 0x00 17.--19. 1. " GPU_SDMA_CONTROL_TRANSFER_TYPE ,TODO RESET:0x0"
          
tree.end
    

tree "GPU__BLEND"
base e:0x400190d8
width 80.
group.long  0x0++0x3
    line.long 0x00 "GPU_BLEND_CONFIG, TODO RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " GPU_BLEND_CONFIG_SOURCE_COLOR ,source color factor RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " GPU_BLEND_CONFIG_SOURCE_ALPHA ,source alpha factor RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " GPU_BLEND_CONFIG_DEST_COLOR ,destination color factor RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " GPU_BLEND_CONFIG_DEST_ALPHA ,destination alpha factor RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " GPU_BLEND_CONFIG_PIXEL_ORG ,pixel/data format RESET:0x0"
          
         bitfld.long 0x00 20. " GPU_BLEND_CONFIG_FB_NOT_READ ,when set, no need to read framebuffer, e.g. clear shader RESET:0x0"
          
         hexmask.long 0x00 21.--24. 1. " GPU_BLEND_CONFIG_COLOR_MASK ,channel color mask RESET:0x0"
          
         hexmask.long 0x00 25.--27. 1. " GPU_BLEND_CONFIG_EQ_COLOR ,blend equation for color channels RESET:0x0"
          
         hexmask.long 0x00 28.--30. 1. " GPU_BLEND_CONFIG_EQ_ALPHA ,blend equation for alpha channel RESET:0x0"
          
tree.end
    

tree "GPU__TEXTURE"
base e:0x4001a000
width 80.
group.long  0x0++0x3
    line.long 0x00 "GPU_TEXTURE_WIDTH_0, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_WIDTH_0_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "GPU_TEXTURE_HEIGHT_0, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_HEIGHT_0_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "GPU_TEXTURE_DEPTH_0, TODO RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " GPU_TEXTURE_DEPTH_0_DNX_TEXTURE_DEPTH ,texture depth RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "GPU_TEXTURE_PITCH_0, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_PITCH_0_DNX_TEXTURE_PITCH ,texture pitch RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "GPU_TEXTURE_BYTE_PITCH_0, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_BYTE_PITCH_0_DNX_TEXTURE_BYTE_PITCH ,texture byte pitch RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "GPU_TEXTURE_FORMAT_0, Swizzle and channel format RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " GPU_TEXTURE_FORMAT_0_BASE_SWIZZLE_MODE ,Base level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 2.--5. 1. " GPU_TEXTURE_FORMAT_0_MIP_SWIZZLE_MODE ,MipMap level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 6.--9. 1. " GPU_TEXTURE_FORMAT_0_CHANNEL_FORMAT ,Channel Format RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "GPU_TEXTURE_WRAP_FILTER_0, Wrap and filter modes for U, V and W RESET:0x0"
         bitfld.long 0x00 0. " GPU_TEXTURE_WRAP_FILTER_0_FILTER_MIN_U ,filter in u direction (minify) RESET:0x0"
          
         bitfld.long 0x00 1. " GPU_TEXTURE_WRAP_FILTER_0_FILTER_MIN_V ,filter in v direction (minify) RESET:0x0"
          
         bitfld.long 0x00 2. " GPU_TEXTURE_WRAP_FILTER_0_FILTER_MIN_W ,filter in w direction (minify) RESET:0x0"
          
         bitfld.long 0x00 3. " GPU_TEXTURE_WRAP_FILTER_0_FILTER_MAG_U ,filter in u direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 4. " GPU_TEXTURE_WRAP_FILTER_0_FILTER_MAG_V ,filter in v direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 5. " GPU_TEXTURE_WRAP_FILTER_0_FILTER_MAG_W ,filter in w direction (magnify) RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " GPU_TEXTURE_WRAP_FILTER_0_FILTER_MIPMAP_MODE ,filter MipMap mode (minification only) RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " GPU_TEXTURE_WRAP_FILTER_0_FILTER_PAD ,Padding for compatibility RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPU_TEXTURE_WRAP_FILTER_0_WRAP_U ,wrap mode u RESET:0x0"
          
         hexmask.long 0x00 12.--13. 1. " GPU_TEXTURE_WRAP_FILTER_0_WRAP_V ,wrap mode v RESET:0x0"
          
         hexmask.long 0x00 14.--15. 1. " GPU_TEXTURE_WRAP_FILTER_0_WRAP_W ,wrap mode w RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "GPU_TEXTURE_MIPMAP_SETTINGS_0, Settings for the MipMap RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_0_LOD ,Level of details RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_0_MIN ,Minimum MipMap level RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_0_MAX ,Maximum MipMap level RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "GPU_TEXTURE_ADDRESS_0, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_ADDRESS_0_DNX_TEXTURE_ADDRESS ,texture address RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "GPU_TEXTURE_PADDING_0, padding to make address splitting possible RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_PADDING_0_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "GPU_TEXTURE_WIDTH_1, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_WIDTH_1_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "GPU_TEXTURE_HEIGHT_1, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_HEIGHT_1_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "GPU_TEXTURE_DEPTH_1, TODO RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " GPU_TEXTURE_DEPTH_1_DNX_TEXTURE_DEPTH ,texture depth RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "GPU_TEXTURE_PITCH_1, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_PITCH_1_DNX_TEXTURE_PITCH ,texture pitch RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "GPU_TEXTURE_BYTE_PITCH_1, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_BYTE_PITCH_1_DNX_TEXTURE_BYTE_PITCH ,texture byte pitch RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "GPU_TEXTURE_FORMAT_1, Swizzle and channel format RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " GPU_TEXTURE_FORMAT_1_BASE_SWIZZLE_MODE ,Base level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 2.--5. 1. " GPU_TEXTURE_FORMAT_1_MIP_SWIZZLE_MODE ,MipMap level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 6.--9. 1. " GPU_TEXTURE_FORMAT_1_CHANNEL_FORMAT ,Channel Format RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "GPU_TEXTURE_WRAP_FILTER_1, Wrap and filter modes for U, V and W RESET:0x0"
         bitfld.long 0x00 0. " GPU_TEXTURE_WRAP_FILTER_1_FILTER_MIN_U ,filter in u direction (minify) RESET:0x0"
          
         bitfld.long 0x00 1. " GPU_TEXTURE_WRAP_FILTER_1_FILTER_MIN_V ,filter in v direction (minify) RESET:0x0"
          
         bitfld.long 0x00 2. " GPU_TEXTURE_WRAP_FILTER_1_FILTER_MIN_W ,filter in w direction (minify) RESET:0x0"
          
         bitfld.long 0x00 3. " GPU_TEXTURE_WRAP_FILTER_1_FILTER_MAG_U ,filter in u direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 4. " GPU_TEXTURE_WRAP_FILTER_1_FILTER_MAG_V ,filter in v direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 5. " GPU_TEXTURE_WRAP_FILTER_1_FILTER_MAG_W ,filter in w direction (magnify) RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " GPU_TEXTURE_WRAP_FILTER_1_FILTER_MIPMAP_MODE ,filter MipMap mode (minification only) RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " GPU_TEXTURE_WRAP_FILTER_1_FILTER_PAD ,Padding for compatibility RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPU_TEXTURE_WRAP_FILTER_1_WRAP_U ,wrap mode u RESET:0x0"
          
         hexmask.long 0x00 12.--13. 1. " GPU_TEXTURE_WRAP_FILTER_1_WRAP_V ,wrap mode v RESET:0x0"
          
         hexmask.long 0x00 14.--15. 1. " GPU_TEXTURE_WRAP_FILTER_1_WRAP_W ,wrap mode w RESET:0x0"
          
group.long  0x44++0x3
    line.long 0x00 "GPU_TEXTURE_MIPMAP_SETTINGS_1, Settings for the MipMap RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_1_LOD ,Level of details RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_1_MIN ,Minimum MipMap level RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_1_MAX ,Maximum MipMap level RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "GPU_TEXTURE_ADDRESS_1, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_ADDRESS_1_DNX_TEXTURE_ADDRESS ,texture address RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "GPU_TEXTURE_PADDING_1, padding to make address splitting possible RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_PADDING_1_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "GPU_TEXTURE_WIDTH_2, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_WIDTH_2_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0x54++0x3
    line.long 0x00 "GPU_TEXTURE_HEIGHT_2, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_HEIGHT_2_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "GPU_TEXTURE_DEPTH_2, TODO RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " GPU_TEXTURE_DEPTH_2_DNX_TEXTURE_DEPTH ,texture depth RESET:0x0"
          
group.long  0x5c++0x3
    line.long 0x00 "GPU_TEXTURE_PITCH_2, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_PITCH_2_DNX_TEXTURE_PITCH ,texture pitch RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "GPU_TEXTURE_BYTE_PITCH_2, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_BYTE_PITCH_2_DNX_TEXTURE_BYTE_PITCH ,texture byte pitch RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "GPU_TEXTURE_FORMAT_2, Swizzle and channel format RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " GPU_TEXTURE_FORMAT_2_BASE_SWIZZLE_MODE ,Base level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 2.--5. 1. " GPU_TEXTURE_FORMAT_2_MIP_SWIZZLE_MODE ,MipMap level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 6.--9. 1. " GPU_TEXTURE_FORMAT_2_CHANNEL_FORMAT ,Channel Format RESET:0x0"
          
group.long  0x68++0x3
    line.long 0x00 "GPU_TEXTURE_WRAP_FILTER_2, Wrap and filter modes for U, V and W RESET:0x0"
         bitfld.long 0x00 0. " GPU_TEXTURE_WRAP_FILTER_2_FILTER_MIN_U ,filter in u direction (minify) RESET:0x0"
          
         bitfld.long 0x00 1. " GPU_TEXTURE_WRAP_FILTER_2_FILTER_MIN_V ,filter in v direction (minify) RESET:0x0"
          
         bitfld.long 0x00 2. " GPU_TEXTURE_WRAP_FILTER_2_FILTER_MIN_W ,filter in w direction (minify) RESET:0x0"
          
         bitfld.long 0x00 3. " GPU_TEXTURE_WRAP_FILTER_2_FILTER_MAG_U ,filter in u direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 4. " GPU_TEXTURE_WRAP_FILTER_2_FILTER_MAG_V ,filter in v direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 5. " GPU_TEXTURE_WRAP_FILTER_2_FILTER_MAG_W ,filter in w direction (magnify) RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " GPU_TEXTURE_WRAP_FILTER_2_FILTER_MIPMAP_MODE ,filter MipMap mode (minification only) RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " GPU_TEXTURE_WRAP_FILTER_2_FILTER_PAD ,Padding for compatibility RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPU_TEXTURE_WRAP_FILTER_2_WRAP_U ,wrap mode u RESET:0x0"
          
         hexmask.long 0x00 12.--13. 1. " GPU_TEXTURE_WRAP_FILTER_2_WRAP_V ,wrap mode v RESET:0x0"
          
         hexmask.long 0x00 14.--15. 1. " GPU_TEXTURE_WRAP_FILTER_2_WRAP_W ,wrap mode w RESET:0x0"
          
group.long  0x6c++0x3
    line.long 0x00 "GPU_TEXTURE_MIPMAP_SETTINGS_2, Settings for the MipMap RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_2_LOD ,Level of details RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_2_MIN ,Minimum MipMap level RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_2_MAX ,Maximum MipMap level RESET:0x0"
          
group.long  0x70++0x3
    line.long 0x00 "GPU_TEXTURE_ADDRESS_2, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_ADDRESS_2_DNX_TEXTURE_ADDRESS ,texture address RESET:0x0"
          
group.long  0x74++0x3
    line.long 0x00 "GPU_TEXTURE_PADDING_2, padding to make address splitting possible RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_PADDING_2_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x78++0x3
    line.long 0x00 "GPU_TEXTURE_WIDTH_3, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_WIDTH_3_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0x7c++0x3
    line.long 0x00 "GPU_TEXTURE_HEIGHT_3, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_HEIGHT_3_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0x80++0x3
    line.long 0x00 "GPU_TEXTURE_DEPTH_3, TODO RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " GPU_TEXTURE_DEPTH_3_DNX_TEXTURE_DEPTH ,texture depth RESET:0x0"
          
group.long  0x84++0x3
    line.long 0x00 "GPU_TEXTURE_PITCH_3, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_PITCH_3_DNX_TEXTURE_PITCH ,texture pitch RESET:0x0"
          
group.long  0x88++0x3
    line.long 0x00 "GPU_TEXTURE_BYTE_PITCH_3, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_BYTE_PITCH_3_DNX_TEXTURE_BYTE_PITCH ,texture byte pitch RESET:0x0"
          
group.long  0x8c++0x3
    line.long 0x00 "GPU_TEXTURE_FORMAT_3, Swizzle and channel format RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " GPU_TEXTURE_FORMAT_3_BASE_SWIZZLE_MODE ,Base level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 2.--5. 1. " GPU_TEXTURE_FORMAT_3_MIP_SWIZZLE_MODE ,MipMap level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 6.--9. 1. " GPU_TEXTURE_FORMAT_3_CHANNEL_FORMAT ,Channel Format RESET:0x0"
          
group.long  0x90++0x3
    line.long 0x00 "GPU_TEXTURE_WRAP_FILTER_3, Wrap and filter modes for U, V and W RESET:0x0"
         bitfld.long 0x00 0. " GPU_TEXTURE_WRAP_FILTER_3_FILTER_MIN_U ,filter in u direction (minify) RESET:0x0"
          
         bitfld.long 0x00 1. " GPU_TEXTURE_WRAP_FILTER_3_FILTER_MIN_V ,filter in v direction (minify) RESET:0x0"
          
         bitfld.long 0x00 2. " GPU_TEXTURE_WRAP_FILTER_3_FILTER_MIN_W ,filter in w direction (minify) RESET:0x0"
          
         bitfld.long 0x00 3. " GPU_TEXTURE_WRAP_FILTER_3_FILTER_MAG_U ,filter in u direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 4. " GPU_TEXTURE_WRAP_FILTER_3_FILTER_MAG_V ,filter in v direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 5. " GPU_TEXTURE_WRAP_FILTER_3_FILTER_MAG_W ,filter in w direction (magnify) RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " GPU_TEXTURE_WRAP_FILTER_3_FILTER_MIPMAP_MODE ,filter MipMap mode (minification only) RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " GPU_TEXTURE_WRAP_FILTER_3_FILTER_PAD ,Padding for compatibility RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPU_TEXTURE_WRAP_FILTER_3_WRAP_U ,wrap mode u RESET:0x0"
          
         hexmask.long 0x00 12.--13. 1. " GPU_TEXTURE_WRAP_FILTER_3_WRAP_V ,wrap mode v RESET:0x0"
          
         hexmask.long 0x00 14.--15. 1. " GPU_TEXTURE_WRAP_FILTER_3_WRAP_W ,wrap mode w RESET:0x0"
          
group.long  0x94++0x3
    line.long 0x00 "GPU_TEXTURE_MIPMAP_SETTINGS_3, Settings for the MipMap RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_3_LOD ,Level of details RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_3_MIN ,Minimum MipMap level RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_3_MAX ,Maximum MipMap level RESET:0x0"
          
group.long  0x98++0x3
    line.long 0x00 "GPU_TEXTURE_ADDRESS_3, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_ADDRESS_3_DNX_TEXTURE_ADDRESS ,texture address RESET:0x0"
          
group.long  0x9c++0x3
    line.long 0x00 "GPU_TEXTURE_PADDING_3, padding to make address splitting possible RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_PADDING_3_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0xa0++0x3
    line.long 0x00 "GPU_TEXTURE_WIDTH_4, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_WIDTH_4_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0xa4++0x3
    line.long 0x00 "GPU_TEXTURE_HEIGHT_4, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_HEIGHT_4_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0xa8++0x3
    line.long 0x00 "GPU_TEXTURE_DEPTH_4, TODO RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " GPU_TEXTURE_DEPTH_4_DNX_TEXTURE_DEPTH ,texture depth RESET:0x0"
          
group.long  0xac++0x3
    line.long 0x00 "GPU_TEXTURE_PITCH_4, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_PITCH_4_DNX_TEXTURE_PITCH ,texture pitch RESET:0x0"
          
group.long  0xb0++0x3
    line.long 0x00 "GPU_TEXTURE_BYTE_PITCH_4, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_BYTE_PITCH_4_DNX_TEXTURE_BYTE_PITCH ,texture byte pitch RESET:0x0"
          
group.long  0xb4++0x3
    line.long 0x00 "GPU_TEXTURE_FORMAT_4, Swizzle and channel format RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " GPU_TEXTURE_FORMAT_4_BASE_SWIZZLE_MODE ,Base level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 2.--5. 1. " GPU_TEXTURE_FORMAT_4_MIP_SWIZZLE_MODE ,MipMap level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 6.--9. 1. " GPU_TEXTURE_FORMAT_4_CHANNEL_FORMAT ,Channel Format RESET:0x0"
          
group.long  0xb8++0x3
    line.long 0x00 "GPU_TEXTURE_WRAP_FILTER_4, Wrap and filter modes for U, V and W RESET:0x0"
         bitfld.long 0x00 0. " GPU_TEXTURE_WRAP_FILTER_4_FILTER_MIN_U ,filter in u direction (minify) RESET:0x0"
          
         bitfld.long 0x00 1. " GPU_TEXTURE_WRAP_FILTER_4_FILTER_MIN_V ,filter in v direction (minify) RESET:0x0"
          
         bitfld.long 0x00 2. " GPU_TEXTURE_WRAP_FILTER_4_FILTER_MIN_W ,filter in w direction (minify) RESET:0x0"
          
         bitfld.long 0x00 3. " GPU_TEXTURE_WRAP_FILTER_4_FILTER_MAG_U ,filter in u direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 4. " GPU_TEXTURE_WRAP_FILTER_4_FILTER_MAG_V ,filter in v direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 5. " GPU_TEXTURE_WRAP_FILTER_4_FILTER_MAG_W ,filter in w direction (magnify) RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " GPU_TEXTURE_WRAP_FILTER_4_FILTER_MIPMAP_MODE ,filter MipMap mode (minification only) RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " GPU_TEXTURE_WRAP_FILTER_4_FILTER_PAD ,Padding for compatibility RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPU_TEXTURE_WRAP_FILTER_4_WRAP_U ,wrap mode u RESET:0x0"
          
         hexmask.long 0x00 12.--13. 1. " GPU_TEXTURE_WRAP_FILTER_4_WRAP_V ,wrap mode v RESET:0x0"
          
         hexmask.long 0x00 14.--15. 1. " GPU_TEXTURE_WRAP_FILTER_4_WRAP_W ,wrap mode w RESET:0x0"
          
group.long  0xbc++0x3
    line.long 0x00 "GPU_TEXTURE_MIPMAP_SETTINGS_4, Settings for the MipMap RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_4_LOD ,Level of details RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_4_MIN ,Minimum MipMap level RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_4_MAX ,Maximum MipMap level RESET:0x0"
          
group.long  0xc0++0x3
    line.long 0x00 "GPU_TEXTURE_ADDRESS_4, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_ADDRESS_4_DNX_TEXTURE_ADDRESS ,texture address RESET:0x0"
          
group.long  0xc4++0x3
    line.long 0x00 "GPU_TEXTURE_PADDING_4, padding to make address splitting possible RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_PADDING_4_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0xc8++0x3
    line.long 0x00 "GPU_TEXTURE_WIDTH_5, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_WIDTH_5_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0xcc++0x3
    line.long 0x00 "GPU_TEXTURE_HEIGHT_5, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_HEIGHT_5_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0xd0++0x3
    line.long 0x00 "GPU_TEXTURE_DEPTH_5, TODO RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " GPU_TEXTURE_DEPTH_5_DNX_TEXTURE_DEPTH ,texture depth RESET:0x0"
          
group.long  0xd4++0x3
    line.long 0x00 "GPU_TEXTURE_PITCH_5, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_PITCH_5_DNX_TEXTURE_PITCH ,texture pitch RESET:0x0"
          
group.long  0xd8++0x3
    line.long 0x00 "GPU_TEXTURE_BYTE_PITCH_5, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_BYTE_PITCH_5_DNX_TEXTURE_BYTE_PITCH ,texture byte pitch RESET:0x0"
          
group.long  0xdc++0x3
    line.long 0x00 "GPU_TEXTURE_FORMAT_5, Swizzle and channel format RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " GPU_TEXTURE_FORMAT_5_BASE_SWIZZLE_MODE ,Base level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 2.--5. 1. " GPU_TEXTURE_FORMAT_5_MIP_SWIZZLE_MODE ,MipMap level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 6.--9. 1. " GPU_TEXTURE_FORMAT_5_CHANNEL_FORMAT ,Channel Format RESET:0x0"
          
group.long  0xe0++0x3
    line.long 0x00 "GPU_TEXTURE_WRAP_FILTER_5, Wrap and filter modes for U, V and W RESET:0x0"
         bitfld.long 0x00 0. " GPU_TEXTURE_WRAP_FILTER_5_FILTER_MIN_U ,filter in u direction (minify) RESET:0x0"
          
         bitfld.long 0x00 1. " GPU_TEXTURE_WRAP_FILTER_5_FILTER_MIN_V ,filter in v direction (minify) RESET:0x0"
          
         bitfld.long 0x00 2. " GPU_TEXTURE_WRAP_FILTER_5_FILTER_MIN_W ,filter in w direction (minify) RESET:0x0"
          
         bitfld.long 0x00 3. " GPU_TEXTURE_WRAP_FILTER_5_FILTER_MAG_U ,filter in u direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 4. " GPU_TEXTURE_WRAP_FILTER_5_FILTER_MAG_V ,filter in v direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 5. " GPU_TEXTURE_WRAP_FILTER_5_FILTER_MAG_W ,filter in w direction (magnify) RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " GPU_TEXTURE_WRAP_FILTER_5_FILTER_MIPMAP_MODE ,filter MipMap mode (minification only) RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " GPU_TEXTURE_WRAP_FILTER_5_FILTER_PAD ,Padding for compatibility RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPU_TEXTURE_WRAP_FILTER_5_WRAP_U ,wrap mode u RESET:0x0"
          
         hexmask.long 0x00 12.--13. 1. " GPU_TEXTURE_WRAP_FILTER_5_WRAP_V ,wrap mode v RESET:0x0"
          
         hexmask.long 0x00 14.--15. 1. " GPU_TEXTURE_WRAP_FILTER_5_WRAP_W ,wrap mode w RESET:0x0"
          
group.long  0xe4++0x3
    line.long 0x00 "GPU_TEXTURE_MIPMAP_SETTINGS_5, Settings for the MipMap RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_5_LOD ,Level of details RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_5_MIN ,Minimum MipMap level RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_5_MAX ,Maximum MipMap level RESET:0x0"
          
group.long  0xe8++0x3
    line.long 0x00 "GPU_TEXTURE_ADDRESS_5, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_ADDRESS_5_DNX_TEXTURE_ADDRESS ,texture address RESET:0x0"
          
group.long  0xec++0x3
    line.long 0x00 "GPU_TEXTURE_PADDING_5, padding to make address splitting possible RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_PADDING_5_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0xf0++0x3
    line.long 0x00 "GPU_TEXTURE_WIDTH_6, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_WIDTH_6_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0xf4++0x3
    line.long 0x00 "GPU_TEXTURE_HEIGHT_6, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_HEIGHT_6_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0xf8++0x3
    line.long 0x00 "GPU_TEXTURE_DEPTH_6, TODO RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " GPU_TEXTURE_DEPTH_6_DNX_TEXTURE_DEPTH ,texture depth RESET:0x0"
          
group.long  0xfc++0x3
    line.long 0x00 "GPU_TEXTURE_PITCH_6, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_PITCH_6_DNX_TEXTURE_PITCH ,texture pitch RESET:0x0"
          
group.long  0x100++0x3
    line.long 0x00 "GPU_TEXTURE_BYTE_PITCH_6, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_BYTE_PITCH_6_DNX_TEXTURE_BYTE_PITCH ,texture byte pitch RESET:0x0"
          
group.long  0x104++0x3
    line.long 0x00 "GPU_TEXTURE_FORMAT_6, Swizzle and channel format RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " GPU_TEXTURE_FORMAT_6_BASE_SWIZZLE_MODE ,Base level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 2.--5. 1. " GPU_TEXTURE_FORMAT_6_MIP_SWIZZLE_MODE ,MipMap level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 6.--9. 1. " GPU_TEXTURE_FORMAT_6_CHANNEL_FORMAT ,Channel Format RESET:0x0"
          
group.long  0x108++0x3
    line.long 0x00 "GPU_TEXTURE_WRAP_FILTER_6, Wrap and filter modes for U, V and W RESET:0x0"
         bitfld.long 0x00 0. " GPU_TEXTURE_WRAP_FILTER_6_FILTER_MIN_U ,filter in u direction (minify) RESET:0x0"
          
         bitfld.long 0x00 1. " GPU_TEXTURE_WRAP_FILTER_6_FILTER_MIN_V ,filter in v direction (minify) RESET:0x0"
          
         bitfld.long 0x00 2. " GPU_TEXTURE_WRAP_FILTER_6_FILTER_MIN_W ,filter in w direction (minify) RESET:0x0"
          
         bitfld.long 0x00 3. " GPU_TEXTURE_WRAP_FILTER_6_FILTER_MAG_U ,filter in u direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 4. " GPU_TEXTURE_WRAP_FILTER_6_FILTER_MAG_V ,filter in v direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 5. " GPU_TEXTURE_WRAP_FILTER_6_FILTER_MAG_W ,filter in w direction (magnify) RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " GPU_TEXTURE_WRAP_FILTER_6_FILTER_MIPMAP_MODE ,filter MipMap mode (minification only) RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " GPU_TEXTURE_WRAP_FILTER_6_FILTER_PAD ,Padding for compatibility RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPU_TEXTURE_WRAP_FILTER_6_WRAP_U ,wrap mode u RESET:0x0"
          
         hexmask.long 0x00 12.--13. 1. " GPU_TEXTURE_WRAP_FILTER_6_WRAP_V ,wrap mode v RESET:0x0"
          
         hexmask.long 0x00 14.--15. 1. " GPU_TEXTURE_WRAP_FILTER_6_WRAP_W ,wrap mode w RESET:0x0"
          
group.long  0x10c++0x3
    line.long 0x00 "GPU_TEXTURE_MIPMAP_SETTINGS_6, Settings for the MipMap RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_6_LOD ,Level of details RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_6_MIN ,Minimum MipMap level RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_6_MAX ,Maximum MipMap level RESET:0x0"
          
group.long  0x110++0x3
    line.long 0x00 "GPU_TEXTURE_ADDRESS_6, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_ADDRESS_6_DNX_TEXTURE_ADDRESS ,texture address RESET:0x0"
          
group.long  0x114++0x3
    line.long 0x00 "GPU_TEXTURE_PADDING_6, padding to make address splitting possible RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_PADDING_6_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
group.long  0x118++0x3
    line.long 0x00 "GPU_TEXTURE_WIDTH_7, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_WIDTH_7_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0x11c++0x3
    line.long 0x00 "GPU_TEXTURE_HEIGHT_7, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_HEIGHT_7_DNX_TEXTURE_SIZE ,texture size (width/height) RESET:0x0"
          
group.long  0x120++0x3
    line.long 0x00 "GPU_TEXTURE_DEPTH_7, TODO RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " GPU_TEXTURE_DEPTH_7_DNX_TEXTURE_DEPTH ,texture depth RESET:0x0"
          
group.long  0x124++0x3
    line.long 0x00 "GPU_TEXTURE_PITCH_7, TODO RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " GPU_TEXTURE_PITCH_7_DNX_TEXTURE_PITCH ,texture pitch RESET:0x0"
          
group.long  0x128++0x3
    line.long 0x00 "GPU_TEXTURE_BYTE_PITCH_7, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_BYTE_PITCH_7_DNX_TEXTURE_BYTE_PITCH ,texture byte pitch RESET:0x0"
          
group.long  0x12c++0x3
    line.long 0x00 "GPU_TEXTURE_FORMAT_7, Swizzle and channel format RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " GPU_TEXTURE_FORMAT_7_BASE_SWIZZLE_MODE ,Base level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 2.--5. 1. " GPU_TEXTURE_FORMAT_7_MIP_SWIZZLE_MODE ,MipMap level swizzle mode RESET:0x0"
          
         hexmask.long 0x00 6.--9. 1. " GPU_TEXTURE_FORMAT_7_CHANNEL_FORMAT ,Channel Format RESET:0x0"
          
group.long  0x130++0x3
    line.long 0x00 "GPU_TEXTURE_WRAP_FILTER_7, Wrap and filter modes for U, V and W RESET:0x0"
         bitfld.long 0x00 0. " GPU_TEXTURE_WRAP_FILTER_7_FILTER_MIN_U ,filter in u direction (minify) RESET:0x0"
          
         bitfld.long 0x00 1. " GPU_TEXTURE_WRAP_FILTER_7_FILTER_MIN_V ,filter in v direction (minify) RESET:0x0"
          
         bitfld.long 0x00 2. " GPU_TEXTURE_WRAP_FILTER_7_FILTER_MIN_W ,filter in w direction (minify) RESET:0x0"
          
         bitfld.long 0x00 3. " GPU_TEXTURE_WRAP_FILTER_7_FILTER_MAG_U ,filter in u direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 4. " GPU_TEXTURE_WRAP_FILTER_7_FILTER_MAG_V ,filter in v direction (magnify) RESET:0x0"
          
         bitfld.long 0x00 5. " GPU_TEXTURE_WRAP_FILTER_7_FILTER_MAG_W ,filter in w direction (magnify) RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " GPU_TEXTURE_WRAP_FILTER_7_FILTER_MIPMAP_MODE ,filter MipMap mode (minification only) RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " GPU_TEXTURE_WRAP_FILTER_7_FILTER_PAD ,Padding for compatibility RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPU_TEXTURE_WRAP_FILTER_7_WRAP_U ,wrap mode u RESET:0x0"
          
         hexmask.long 0x00 12.--13. 1. " GPU_TEXTURE_WRAP_FILTER_7_WRAP_V ,wrap mode v RESET:0x0"
          
         hexmask.long 0x00 14.--15. 1. " GPU_TEXTURE_WRAP_FILTER_7_WRAP_W ,wrap mode w RESET:0x0"
          
group.long  0x134++0x3
    line.long 0x00 "GPU_TEXTURE_MIPMAP_SETTINGS_7, Settings for the MipMap RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_7_LOD ,Level of details RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_7_MIN ,Minimum MipMap level RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " GPU_TEXTURE_MIPMAP_SETTINGS_7_MAX ,Maximum MipMap level RESET:0x0"
          
group.long  0x138++0x3
    line.long 0x00 "GPU_TEXTURE_ADDRESS_7, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_ADDRESS_7_DNX_TEXTURE_ADDRESS ,texture address RESET:0x0"
          
group.long  0x13c++0x3
    line.long 0x00 "GPU_TEXTURE_PADDING_7, padding to make address splitting possible RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_TEXTURE_PADDING_7_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
tree.end
    

tree "GPU__ATTRIBUTE"
base e:0x4001ac00
width 80.
group.long  0x0++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_0, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_0_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_0_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_0_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_0_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_0_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_0_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_0, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_0_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_1, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_1_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_1_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_1_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_1_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_1_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_1_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_1, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_1_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_2, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_2_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_2_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_2_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_2_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_2_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_2_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_2, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_2_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_3, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_3_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_3_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_3_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_3_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_3_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_3_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_3, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_3_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_4, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_4_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_4_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_4_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_4_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_4_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_4_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_4, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_4_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_5, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_5_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_5_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_5_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_5_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_5_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_5_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_5, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_5_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_6, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_6_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_6_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_6_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_6_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_6_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_6_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_6, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_6_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_7, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_7_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_7_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_7_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_7_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_7_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_7_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_7, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_7_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_8, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_8_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_8_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_8_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_8_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_8_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_8_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x44++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_8, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_8_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_9, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_9_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_9_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_9_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_9_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_9_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_9_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_9, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_9_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_10, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_10_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_10_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_10_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_10_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_10_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_10_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x54++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_10, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_10_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_11, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_11_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_11_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_11_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_11_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_11_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_11_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x5c++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_11, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_11_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_12, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_12_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_12_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_12_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_12_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_12_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_12_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_12, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_12_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x68++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_13, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_13_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_13_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_13_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_13_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_13_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_13_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x6c++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_13, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_13_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x70++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_14, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_14_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_14_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_14_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_14_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_14_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_14_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x74++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_14, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_14_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
group.long  0x78++0x3
    line.long 0x00 "GPU_ATTRIBUTE_CONTROL_15, TODO RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " GPU_ATTRIBUTE_CONTROL_15_BUFFER_PITCH ,Number of bytes between two consecutive buffer elements RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " GPU_ATTRIBUTE_CONTROL_15_BUFFER_DEST_TYPE ,Destination type (register) (0=float, 1=int, 2=uint) RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " GPU_ATTRIBUTE_CONTROL_15_CACHE_ID ,Cache ID (attribute index) RESET:0x0"
          
         hexmask.long 0x00 17.--20. 1. " GPU_ATTRIBUTE_CONTROL_15_BUFFER_TYPE ,Source type (memory) RESET:0x0"
          
         hexmask.long 0x00 21.--22. 1. " GPU_ATTRIBUTE_CONTROL_15_BUFFER_NUM_COMP ,Number of components (0=x, 1=xy, 2=xyz, 3=xyzw) RESET:0x0"
          
         bitfld.long 0x00 23. " GPU_ATTRIBUTE_CONTROL_15_BUFFER_NORMALIZE ,1=normalize to 0..1 (unsigned) or -1..1 (signed) range RESET:0x0"
          
group.long  0x7c++0x3
    line.long 0x00 "GPU_ATTRIBUTE_BUFFER_ADDR_15, TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_ATTRIBUTE_BUFFER_ADDR_15_DNX_ATTRIBUTE_BUFFER_ADDRESS ,TODO RESET:0x0"
          
tree.end
    

tree "GPU__CONSTANTS"
base e:0x4001c000
width 80.
group.long  0x0++0x3
    line.long 0x00 "GPU_CONSTANTS_CONSTANT, A single shader constant RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPU_CONSTANTS_CONSTANT_DNX_U32 ,32- bit unsigned integer RESET:0x0"
          
tree.end

tree "DISP_DSI"
base e:0x40020000
width 80.
tree.end

tree "DISP_DPHY"
base e:0x40021000
width 80.
group.long  0x0++0x3
    line.long 0x00 "DISP_DPHY_DISP_DPHY_CTRL, some control signals going to the DPHY RESET:0x0"
         bitfld.long 0x00 0. " DISP_DPHY_DISP_DPHY_CTRL_BISTON ,Starts the HS bist test RESET:0x0"
          
         bitfld.long 0x00 1. " DISP_DPHY_DISP_DPHY_CTRL_BISTOK ,HS bist test OK indication RESET:0x0"
          
         bitfld.long 0x00 2. " DISP_DPHY_DISP_DPHY_CTRL_BISTDONE ,HS bist test done RESET:0x0"
          
         bitfld.long 0x00 3. " DISP_DPHY_DISP_DPHY_CTRL_CONT_EN ,Places the macro in IO continuity test mode RESET:0x0"
          
         hexmask.long 0x00 4.--14. 1. " DISP_DPHY_DISP_DPHY_CTRL_CONT_DATA ,Each pin of this output bus is used to verify the continuity from the chips pin all the way to the PHY's analog ports RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "DISP_DPHY_DISP_DPHY_INIT_CFG, Registers used during startup sequence RESET:0x20"
         hexmask.long 0x00 0.--7. 1. " DISP_DPHY_DISP_DPHY_INIT_CFG_CFGCLKFREQRANGE ,Clk freq config preset. cfgclkfreqrange = round[(cfg_clk(MHz)-17)*4] = 32 RESET:0x20"
          
         hexmask.long 0x00 8.--14. 1. " DISP_DPHY_DISP_DPHY_INIT_CFG_HSFREQRANGE ,High-speed freq range selection RESET:0x0"
          
         bitfld.long 0x00 15. " DISP_DPHY_DISP_DPHY_INIT_CFG_SHUTDOWNZ ,Used to place the PHY in shutdown RESET:0x0"
          
         bitfld.long 0x00 16. " DISP_DPHY_DISP_DPHY_INIT_CFG_SW_RSTZ ,SW trigger for rstz of DPHY, active low RESET:0x0"
          
         bitfld.long 0x00 17. " DISP_DPHY_DISP_DPHY_INIT_CFG_SW_RESET_DSI_SYS_N ,SW trigger for reset_dsi_sys_n of DPHY, active low RESET:0x0"
          
         bitfld.long 0x00 18. " DISP_DPHY_DISP_DPHY_INIT_CFG_SW_RESET_DSI_PIXEL_N ,SW trigger for reset_dsi_pixel of DPHY, active low RESET:0x0"
          
         bitfld.long 0x00 19. " DISP_DPHY_DISP_DPHY_INIT_CFG_SW_RESET_DCU_N ,SW trigger for reset_dcu of DPHY, active low RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "DISP_DPHY_DISP_DPHY_TX_TEST, DPHY TX test and control interface signals DPHY RESET:0x0"
         bitfld.long 0x00 0. " DISP_DPHY_DISP_DPHY_TX_TEST_T_CLK ,Strobe signal to clock the testdin bus contents into the PHY RESET:0x0"
          
         bitfld.long 0x00 1. " DISP_DPHY_DISP_DPHY_TX_TEST_T_EN ,Vendor-Specific Interface Operation Type Selector. 1 -> address write operation on the falling edge of testclk. 0 -> data write operation on the rising edge of testclk RESET:0x0"
          
         bitfld.long 0x00 2. " DISP_DPHY_DISP_DPHY_TX_TEST_T_CLR ,Interface clear signal that performs vendor-specific interface initialization RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " DISP_DPHY_DISP_DPHY_TX_TEST_T_DIN ,Vendor-specific input 8-bit data bus for internal register programming and test functionalities access RESET:0x0"
          
         hexmask.long 0x00 11.--18. 1. " DISP_DPHY_DISP_DPHY_TX_TEST_T_DOUT ,Vendor-Specific 8-bit data bus for read-back and internal probing functionalities RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "DISP_DPHY_DISP_DPHY_RX_TEST, DPHY RX test and control interface signals DPHY RESET:0x0"
         bitfld.long 0x00 0. " DISP_DPHY_DISP_DPHY_RX_TEST_T_CLK ,Strobe signal to clock the testdin bus contents into the PHY RESET:0x0"
          
         bitfld.long 0x00 1. " DISP_DPHY_DISP_DPHY_RX_TEST_T_EN ,Vendor-Specific Interface Operation Type Selector. 1 -> address write operation on the falling edge of testclk. 0 -> data write operation on the rising edge of testclk RESET:0x0"
          
         bitfld.long 0x00 2. " DISP_DPHY_DISP_DPHY_RX_TEST_T_CLR ,Interface clear signal that performs vendor-specific interface initialization RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " DISP_DPHY_DISP_DPHY_RX_TEST_T_DIN ,Vendor-specific input 8-bit data bus for internal register programming and test functionalities access RESET:0x0"
          
         hexmask.long 0x00 11.--18. 1. " DISP_DPHY_DISP_DPHY_RX_TEST_T_DOUT ,Vendor-Specific 8-bit data bus for read-back and internal probing functionalities RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "DISP_DPHY_DPHY_PLL_CTRL, Register for controlling the D-PHY internal PLL RESET:0x0"
         bitfld.long 0x00 0. " DISP_DPHY_DPHY_PLL_CTRL_PLL_SHADOW_CONTROL ,Selection of PLL configuration mechanism. 0: SoC control and shadow registers  1: D-PHY control RESET:0x0"
          
         bitfld.long 0x00 1. " DISP_DPHY_DPHY_PLL_CTRL_SHADOW_CLEAR ,Shadow registers clear RESET:0x0"
          
         bitfld.long 0x00 2. " DISP_DPHY_DPHY_PLL_CTRL_FORCE_LOCK ,Force lock to SoC RESET:0x0"
          
         bitfld.long 0x00 3. " DISP_DPHY_DPHY_PLL_CTRL_GP_CLK_EN ,Enable signal for clkout_gp clock RESET:0x0"
          
         hexmask.long 0x00 4.--5. 1. " DISP_DPHY_DPHY_PLL_CTRL_CLKSEL ,Control of PLL clock output selection. 00 - Clocks stopped 01 - Clock generation 10 - Buffered clkext 11 - Forbidden RESET:0x0"
          
         bitfld.long 0x00 6. " DISP_DPHY_DPHY_PLL_CTRL_UPDATEPLL ,Control for PLL operation frequency updated RESET:0x0"
          
         bitfld.long 0x00 7. " DISP_DPHY_DPHY_PLL_CTRL_LOCK ,Lock state signaling RESET:0x0"
          
         bitfld.long 0x00 8. " DISP_DPHY_DPHY_PLL_CTRL_DPHY_LOCK ,PLL lock coming from DPHY RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "DISP_DPHY_DPHY_PLL_CFG1, Register 1 for configuration of DPHY PLL. Works when pll_shadow_control = 0 RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " DISP_DPHY_DPHY_PLL_CFG1_CPBIAS_CNTRL ,Charge Pump bias control RESET:0x0"
          
         hexmask.long 0x00 7.--8. 1. " DISP_DPHY_DPHY_PLL_CFG1_GMP_CNTRL ,Controls the effective loop-filter resistance (=1/gmp) to increase/decrease MPLL bandwidth and compensate for change in divider modulus (n_cntrl) RESET:0x0"
          
         hexmask.long 0x00 9.--14. 1. " DISP_DPHY_DPHY_PLL_CFG1_INT_CNTRL ,Integral Charge Pump control RESET:0x0"
          
         hexmask.long 0x00 15.--20. 1. " DISP_DPHY_DPHY_PLL_CFG1_PROP_CNTRL ,Proportional Charge Pump control RESET:0x0"
          
         hexmask.long 0x00 21.--26. 1. " DISP_DPHY_DPHY_PLL_CFG1_VCO_CNTRL ,VCO operating range RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "DISP_DPHY_DPHY_PLL_CFG2, Register 2 for configuration of DPHY PLL. Works when pll_shadow_control = 0 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " DISP_DPHY_DPHY_PLL_CFG2_PLL_DIV_M ,Feedback multiplication ratio M (40 to 625). f(out)=f(in)*(M/2NP) RESET:0x0"
          
         hexmask.long 0x00 10.--13. 1. " DISP_DPHY_DPHY_PLL_CFG2_PLL_DIV_N ,Input frequency division ratio N (1 to 16) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "DISP_DPHY_DSI_HOST_CTRL, Register for control DSI and DCU RESET:0x0"
         bitfld.long 0x00 0. " DISP_DPHY_DSI_HOST_CTRL_FRAME_TRIG ,Triggers a single output frame (DCU) RESET:0x0"
          
         bitfld.long 0x00 1. " DISP_DPHY_DSI_HOST_CTRL_IPI_SHUTDN ,PI Shutdown command. This signal is the IPI shut down signal RESET:0x0"
          
         bitfld.long 0x00 2. " DISP_DPHY_DSI_HOST_CTRL_IPI_COLORM ,IPI Color Mode command RESET:0x0"
          
         bitfld.long 0x00 3. " DISP_DPHY_DSI_HOST_CTRL_IPI_TEAR_REQ ,IPI Tear Effect request RESET:0x0"
          
         bitfld.long 0x00 4. " DISP_DPHY_DSI_HOST_CTRL_IPI_HIBERNATE_REQ ,IPI Hibernate request RESET:0x0"
          
         bitfld.long 0x00 5. " DISP_DPHY_DSI_HOST_CTRL_IPI_FRAME_START ,IPI start of frame. This signal is asserted for one ipi_clk cycle to indicate the start of the frame RESET:0x0"
          
         bitfld.long 0x00 6. " DISP_DPHY_DSI_HOST_CTRL_IPI_FRAME_END ,IPI end of frame. This signal is asserted for one ipi_clk cycle to indicate the end of the frame RESET:0x0"
          
         bitfld.long 0x00 7. " DISP_DPHY_DSI_HOST_CTRL_IPI_TEAR_ST ,IPI Tear Effect status RESET:0x0"
          
         bitfld.long 0x00 8. " DISP_DPHY_DSI_HOST_CTRL_IPI_HALT ,IPI halt indication RESET:0x0"
          
         bitfld.long 0x00 9. " DISP_DPHY_DSI_HOST_CTRL_IPI_HIBERNATE_ST ,IPI Hibernate status RESET:0x0"
          
         bitfld.long 0x00 10. " DISP_DPHY_DSI_HOST_CTRL_CORE_BUSY ,This pin asserts when controller is receiving, processing and/or transmitting data RESET:0x0"
          
tree.end

tree "H264"
base e:0x40023000
width 80.
group.long  0x1a4++0x3
    line.long 0x00 "H264_RESET_CTRL, Control h264 reset RESET:0x0"
         bitfld.long 0x00 0. " H264_RESET_CTRL_RESET_H264_N ,SW trigger for reset_h264_n RESET:0x0"
          
tree.end

tree "H264__ENCODER"
base e:0x40023000
width 80.
tree.end

tree "H264__ENCODER__TOP"
base e:0x40023000
width 80.
group.long  0x0++0x3
    line.long 0x00 "H264_ENCODER_TOP_CONTROL_START, H264 encoder control RESET:0x0"
         bitfld.long 0x00 0. " H264_ENCODER_TOP_CONTROL_START_START ,H264 encoder start RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "H264_ENCODER_TOP_REF_ADDR, H264 encoder reference address RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_ENCODER_TOP_REF_ADDR_REF_ADDRESS ,H264 encoder reference address RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "H264_ENCODER_TOP_CONTROL_INTRA_REFRESH, H264 encoder intra refresh control RESET:0x6"
         bitfld.long 0x00 0. " H264_ENCODER_TOP_CONTROL_INTRA_REFRESH_INTRA_REFRESH_ENABLE ,H264 encoder refresh enable RESET:0x0"
          
         hexmask.long 0x00 1.--7. 1. " H264_ENCODER_TOP_CONTROL_INTRA_REFRESH_INTRA_REFRESH_WIDTH ,H264 encoder intra refresh width RESET:0x3"
          
group.long  0xc++0x3
    line.long 0x00 "H264_ENCODER_TOP_CONTROL_INTRA_PERIOD, H264 encoder intra period control RESET:0x19"
         hexmask.long 0x00 0.--15. 1. " H264_ENCODER_TOP_CONTROL_INTRA_PERIOD_INTRA_PERIOD ,H264 encoder intra period select RESET:0x19"
          
group.long  0x10++0x3
    line.long 0x00 "H264_ENCODER_TOP_CONTROL_MB_TYPE_SKIP, H264 encoder macroblock type skip control RESET:0x0"
         bitfld.long 0x00 0. " H264_ENCODER_TOP_CONTROL_MB_TYPE_SKIP_MB_TYPE_SKIP_ENABLE ,H264 encoder macroblock type skip enable RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "H264_ENCODER_TOP_CONTROL_RATE_CONTROL, H264 encoder rate control RESET:0xa8"
         bitfld.long 0x00 0. " H264_ENCODER_TOP_CONTROL_RATE_CONTROL_RC_ENABLE ,H264 encoder rate control enable RESET:0x0"
          
         hexmask.long 0x00 1.--6. 1. " H264_ENCODER_TOP_CONTROL_RATE_CONTROL_RC_INIT_QP ,H264 encoder rate control QP init RESET:0x14"
          
         hexmask.long 0x00 7.--10. 1. " H264_ENCODER_TOP_CONTROL_RATE_CONTROL_RC_INITIAL_LATENCY ,H264 encoder rate control initial latency RESET:0x1"
          
group.long  0x18++0x3
    line.long 0x00 "H264_ENCODER_TOP_CONTROL_RC_CFG1, H264 encoder rate control config 1 RESET:0x0"
         hexmask.long 0x00 0.--18. 1. " H264_ENCODER_TOP_CONTROL_RC_CFG1_RC_WORDS_PER_FRAME ,H264 encoder rate control words per frame RESET:0x0"
          
         hexmask.long 0x00 19.--28. 1. " H264_ENCODER_TOP_CONTROL_RC_CFG1_RC_BITS_PER_MB ,H264 encoder rate control bits per macroblock RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "H264_ENCODER_TOP_CONTROL_RC_CFG2, H264 encoder rate control config 2 RESET:0x1"
         hexmask.long 0x00 0.--19. 1. " H264_ENCODER_TOP_CONTROL_RC_CFG2_RC_BUFFER_SIZE ,H264 encoder rate control buffer size RESET:0x1"
          
group.long  0x20++0x3
    line.long 0x00 "H264_ENCODER_TOP_CONTROL_RC_CFG3, H264 encoder rate control config 3 RESET:0x1"
         hexmask.long 0x00 0.--15. 1. " H264_ENCODER_TOP_CONTROL_RC_CFG3_RC_WAIT_CYCLES ,H264 encoder rate control wait cycles RESET:0x1"
          
rgroup.long 0x24++0x3
    line.long 0x00 "H264_ENCODER_TOP_STATUS_RC_FLAGS, H264 encoder rate control flags RESET:0x0"
         bitfld.long 0x00 0. " H264_ENCODER_TOP_STATUS_RC_FLAGS_RC_END_OF_MB_ROW ,H264 encoder rate control end of macroblock row RESET:0x0"
          
         bitfld.long 0x00 1. " H264_ENCODER_TOP_STATUS_RC_FLAGS_RC_END_OF_FRAME ,H264 encoder rate control end of frame RESET:0x0"
          
         bitfld.long 0x00 2. " H264_ENCODER_TOP_STATUS_RC_FLAGS_RC_BUFFER_OVERFLOW ,H264 encoder rate control buffer overflow RESET:0x0"
          
         bitfld.long 0x00 3. " H264_ENCODER_TOP_STATUS_RC_FLAGS_RC_ROW_SIZE_FIFO_OVERFLOW ,H264 encoder rate control row size fifo overflow RESET:0x0"
          
         bitfld.long 0x00 4. " H264_ENCODER_TOP_STATUS_RC_FLAGS_RC_BS_HALT_ERROR ,H264 encoder rate control bitstream halt error RESET:0x0"
          
         bitfld.long 0x00 5. " H264_ENCODER_TOP_STATUS_RC_FLAGS_RC_MB_CYCLE_ERROR ,H264 encoder rate control macroblock cycle error RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "H264_ENCODER_TOP_CONTROL_IMAGE_SIZE, H264 encoder image size RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " H264_ENCODER_TOP_CONTROL_IMAGE_SIZE_VIDEO_WIDTH ,H264 encoder video image width RESET:0x0"
          
         hexmask.long 0x00 12.--23. 1. " H264_ENCODER_TOP_CONTROL_IMAGE_SIZE_VIDEO_HEIGHT ,H264 encoder video image height RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "H264_ENCODER_TOP_CONTROL_ROI_GEN, H264 encoder ROI general control RESET:0x7"
         hexmask.long 0x00 0.--5. 1. " H264_ENCODER_TOP_CONTROL_ROI_GEN_ROI_QP_DIFF ,H264 encoder ROI QP difference RESET:0x7"
          
         bitfld.long 0x00 6. " H264_ENCODER_TOP_CONTROL_ROI_GEN_ROI_BORDER_NOCHROMA ,H264 encoder ROI border nochroma flag RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "H264_ENCODER_TOP_CONTROL_ROI_0, H264 encoder ROI 0 control RESET:0x0"
         bitfld.long 0x00 0. " H264_ENCODER_TOP_CONTROL_ROI_0_ROI_0_ENA ,H264 encoder ROI 0 enable RESET:0x0"
          
         bitfld.long 0x00 1. " H264_ENCODER_TOP_CONTROL_ROI_0_ROI_0_SHOW_FRAME ,H264 encoder ROI 0 show frame flag RESET:0x0"
          
         bitfld.long 0x00 2. " H264_ENCODER_TOP_CONTROL_ROI_0_ROI_0_FRAME_NOCHROMA ,H264 encoder ROI 0 frame nochroma flag RESET:0x0"
          
         bitfld.long 0x00 3. " H264_ENCODER_TOP_CONTROL_ROI_0_ROI_0_WINDOW_NOCHROMA ,H264 encoder ROI 0 window nochroma flag RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "H264_ENCODER_TOP_CONTROL_ROI_0_WINDOW, H264 encoder ROI window control RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " H264_ENCODER_TOP_CONTROL_ROI_0_WINDOW_ROI_0_WIDTH_IN_MB ,H264 encoder ROI 0 width in macroblocks RESET:0x0"
          
         hexmask.long 0x00 7.--14. 1. " H264_ENCODER_TOP_CONTROL_ROI_0_WINDOW_ROI_0_HEIGHT_IN_MB ,H264 encoder ROI 0 height in macroblocks RESET:0x0"
          
         hexmask.long 0x00 15.--21. 1. " H264_ENCODER_TOP_CONTROL_ROI_0_WINDOW_ROI_0_OFFSET_X_IN_MB ,H264 encoder ROI 0 X offset in macroblocks RESET:0x0"
          
         hexmask.long 0x00 22.--29. 1. " H264_ENCODER_TOP_CONTROL_ROI_0_WINDOW_ROI_0_OFFSET_Y_IN_MB ,H264 encoder ROI 0 Y offset in macroblocks RESET:0x0"
          
wgroup.long 0x38++0x3
    line.long 0x00 "H264_ENCODER_TOP_DATA_PATH_CTRL, H264 encoder data path control RESET:0x0"
         bitfld.long 0x00 0. " H264_ENCODER_TOP_DATA_PATH_CTRL_CLEAR ,clear data path;     clear input buffer,     clear output buffer,     reset state of video stream generator (single pulse / self clearing) RESET:0x0"
          
tree.end

tree "H264__ENCODER__WDMA"
base e:0x40023040
width 80.
group.long  0x0++0x3
    line.long 0x00 "H264_ENCODER_WDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " H264_ENCODER_WDMA_CTRL_ENABLE ,Global enable for the WDMA RESET:0x0"
          
         bitfld.long 0x00 1. " H264_ENCODER_WDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next write will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " H264_ENCODER_WDMA_CTRL_ADDR_DECREMENT ,When = 1, address is decremented in the AXI master RESET:0x0"
          
         bitfld.long 0x00 3. " H264_ENCODER_WDMA_CTRL_CONT_MODE ,Enables continuous mode if set to 1, transmission is finalized, if HW signals last access RESET:0x0"
          
         bitfld.long 0x00 4. " H264_ENCODER_WDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 5.--12. 1. " H264_ENCODER_WDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "H264_ENCODER_WDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " H264_ENCODER_WDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " H264_ENCODER_WDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "H264_ENCODER_WDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " H264_ENCODER_WDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " H264_ENCODER_WDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "H264_ENCODER_WDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_ENCODER_WDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "H264_ENCODER_WDMA_SIZE1, SIZE1 interrupt triggers in case buffer is filled with size1 byte / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_ENCODER_WDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "H264_ENCODER_WDMA_CURR_ADDR, the current address of the DMA write pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_ENCODER_WDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "H264_ENCODER_WDMA_IRQ_STATUS, interrupt status bits / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " H264_ENCODER_WDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " H264_ENCODER_WDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " H264_ENCODER_WDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " H264_ENCODER_WDMA_IRQ_STATUS_OVFL ,Overflow: data from AXI-4S is coming too fast to be written to the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "H264_ENCODER_WDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " H264_ENCODER_WDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " H264_ENCODER_WDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " H264_ENCODER_WDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " H264_ENCODER_WDMA_IRQ_STATUS_ENABLE_OVFL ,Enable interrupt ovfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "H264_ENCODER_WDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to force an interrupt event (used for Software debugging or integration testing) RESET:0x0"
         bitfld.long 0x00 0. " H264_ENCODER_WDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize for one cycle RESET:0x0"
          
         bitfld.long 0x00 1. " H264_ENCODER_WDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 for one cycle RESET:0x0"
          
         bitfld.long 0x00 2. " H264_ENCODER_WDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr for one cycle RESET:0x0"
          
         bitfld.long 0x00 3. " H264_ENCODER_WDMA_IRQ_STATUS_SET_OVFL ,Set interrupt ovfl for one cycle RESET:0x0"
          
tree.end

tree "H264__ENCODER__RDMA"
base e:0x40023080
width 80.
group.long  0x0++0x3
    line.long 0x00 "H264_ENCODER_RDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " H264_ENCODER_RDMA_CTRL_ENABLE ,Global enable for the RDMA RESET:0x0"
          
         bitfld.long 0x00 1. " H264_ENCODER_RDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next read will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " H264_ENCODER_RDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " H264_ENCODER_RDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
         bitfld.long 0x00 11. " H264_ENCODER_RDMA_CTRL_TERMINATE ,Manual termination of stream, concludes transaction and sends tlast. Self-clearing RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "H264_ENCODER_RDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " H264_ENCODER_RDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " H264_ENCODER_RDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "H264_ENCODER_RDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " H264_ENCODER_RDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " H264_ENCODER_RDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "H264_ENCODER_RDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_ENCODER_RDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "H264_ENCODER_RDMA_SIZE1, SIZE1 interrupt triggers in case size1 byte have been read from the buffer / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_ENCODER_RDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "H264_ENCODER_RDMA_CURR_ADDR, the current address of the DMA read pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_ENCODER_RDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "H264_ENCODER_RDMA_IRQ_STATUS, interrupt status bits reflect the occurrence of an event / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " H264_ENCODER_RDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " H264_ENCODER_RDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " H264_ENCODER_RDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " H264_ENCODER_RDMA_IRQ_STATUS_UNFL ,Underflow: data towards AXI-4S is consumed faster than the DMA is able to read data from the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "H264_ENCODER_RDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " H264_ENCODER_RDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " H264_ENCODER_RDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " H264_ENCODER_RDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " H264_ENCODER_RDMA_IRQ_STATUS_ENABLE_UNFL ,Enable interrupt unfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "H264_ENCODER_RDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev) RESET:0x0"
         bitfld.long 0x00 0. " H264_ENCODER_RDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " H264_ENCODER_RDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " H264_ENCODER_RDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " H264_ENCODER_RDMA_IRQ_STATUS_SET_UNFL ,Set interrupt unfl RESET:0x0"
          
tree.end

tree "H264__DECODER"
base e:0x40023100
width 80.
tree.end

tree "H264__DECODER__TOP"
base e:0x40023100
width 80.
group.long  0x0++0x3
    line.long 0x00 "H264_DECODER_TOP_CONTROL, H264 decoder control RESET:0x0"
         bitfld.long 0x00 0. " H264_DECODER_TOP_CONTROL_START ,H264 decoder start RESET:0x0"
          
         bitfld.long 0x00 1. " H264_DECODER_TOP_CONTROL_STOP ,H264 decoder stop RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "H264_DECODER_TOP_REF_ADDR, H264 decoder reference address RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_DECODER_TOP_REF_ADDR_REF_ADDRESS ,H264 decoder reference address RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "H264_DECODER_TOP_IDR_SYNC, H264 decoder IDR sync RESET:0x0"
         bitfld.long 0x00 0. " H264_DECODER_TOP_IDR_SYNC_DISABLE_IDR_SYNC ,H264 decoder disable IDR sync RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "H264_DECODER_TOP_GEN_STATUS, H264 general status RESET:0x0"
         bitfld.long 0x00 0. " H264_DECODER_TOP_GEN_STATUS_IRQ_ERROR ,H264 Interrupt error RESET:0x0"
          
         hexmask.long 0x00 1.--5. 1. " H264_DECODER_TOP_GEN_STATUS_STATE ,H264 decoder state RESET:0x0"
          
         bitfld.long 0x00 6. " H264_DECODER_TOP_GEN_STATUS_PIC_PARAM_VALID ,H264 decoder picture parameter valid RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "H264_DECODER_TOP_HOR_STATUS, H264 decoder horizontal picture parameter status RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " H264_DECODER_TOP_HOR_STATUS_PIC_WIDTH_IN_MBS ,H264 decoder picture width in macroblocks RESET:0x0"
          
         hexmask.long 0x00 8.--19. 1. " H264_DECODER_TOP_HOR_STATUS_PIX_CROP_LEFT ,H264 decoder picture crop left RESET:0x0"
          
         hexmask.long 0x00 20.--31. 1. " H264_DECODER_TOP_HOR_STATUS_PIX_CROP_RIGHT ,H264 decoder picture crop right RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "H264_DECODER_TOP_VER_STATUS, H264 decoder vertical picture parameter status RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " H264_DECODER_TOP_VER_STATUS_PIC_HEIGHT_IN_MBS ,H264 decoder picture height in macroblocks RESET:0x0"
          
         hexmask.long 0x00 8.--19. 1. " H264_DECODER_TOP_VER_STATUS_PIX_CROP_TOP ,H264 decoder picture crop top RESET:0x0"
          
         hexmask.long 0x00 20.--31. 1. " H264_DECODER_TOP_VER_STATUS_PIX_CROP_BOTTOM ,H264 decoder picture crop bottom RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "H264_DECODER_TOP_DBG_THRESH_0, H264 decoder debug threshold 0 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_DECODER_TOP_DBG_THRESH_0_DBG_THRESHOLD_0 ,H264 debug threshold 0 value RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "H264_DECODER_TOP_DBG_THRESH_1, H264 decoder debug threshold 1 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_DECODER_TOP_DBG_THRESH_1_DBG_THRESHOLD_1 ,H264 debug threshold 1 value RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "H264_DECODER_TOP_DBG_THRESH_2, H264 decoder debug threshold 2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_DECODER_TOP_DBG_THRESH_2_DBG_THRESHOLD_2 ,H264 debug threshold 2 value RESET:0x0"
          
rgroup.long 0x24++0x3
    line.long 0x00 "H264_DECODER_TOP_DBG_THR_STATUS, H264 decoder debug threshold status RESET:0x0"
         bitfld.long 0x00 0. " H264_DECODER_TOP_DBG_THR_STATUS_DBG_GREATER_THRESHOLD_0 ,debug greater threshold 0 RESET:0x0"
          
         bitfld.long 0x00 1. " H264_DECODER_TOP_DBG_THR_STATUS_DBG_GREATER_THRESHOLD_1 ,debug greater threshold 1 RESET:0x0"
          
         bitfld.long 0x00 2. " H264_DECODER_TOP_DBG_THR_STATUS_DBG_GREATER_THRESHOLD_2 ,debug greater threshold 2 RESET:0x0"
          
wgroup.long 0x28++0x3
    line.long 0x00 "H264_DECODER_TOP_DATA_PATH_CTRL, H264 decoder data path control RESET:0x0"
         bitfld.long 0x00 0. " H264_DECODER_TOP_DATA_PATH_CTRL_CLEAR ,clear data path;     clear input buffer,     clear output buffer,     reset state of video stream regenerator (single pulse / self clearing) RESET:0x0"
          
tree.end

tree "H264__DECODER__WDMA"
base e:0x40023140
width 80.
group.long  0x0++0x3
    line.long 0x00 "H264_DECODER_WDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " H264_DECODER_WDMA_CTRL_ENABLE ,Global enable for the WDMA RESET:0x0"
          
         bitfld.long 0x00 1. " H264_DECODER_WDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next write will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " H264_DECODER_WDMA_CTRL_ADDR_DECREMENT ,When = 1, address is decremented in the AXI master RESET:0x0"
          
         bitfld.long 0x00 3. " H264_DECODER_WDMA_CTRL_CONT_MODE ,Enables continuous mode if set to 1, transmission is finalized, if HW signals last access RESET:0x0"
          
         bitfld.long 0x00 4. " H264_DECODER_WDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 5.--12. 1. " H264_DECODER_WDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "H264_DECODER_WDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " H264_DECODER_WDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " H264_DECODER_WDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "H264_DECODER_WDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " H264_DECODER_WDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " H264_DECODER_WDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "H264_DECODER_WDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_DECODER_WDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "H264_DECODER_WDMA_SIZE1, SIZE1 interrupt triggers in case buffer is filled with size1 byte / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_DECODER_WDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "H264_DECODER_WDMA_CURR_ADDR, the current address of the DMA write pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_DECODER_WDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "H264_DECODER_WDMA_IRQ_STATUS, interrupt status bits / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " H264_DECODER_WDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " H264_DECODER_WDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " H264_DECODER_WDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " H264_DECODER_WDMA_IRQ_STATUS_OVFL ,Overflow: data from AXI-4S is coming too fast to be written to the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "H264_DECODER_WDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " H264_DECODER_WDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " H264_DECODER_WDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " H264_DECODER_WDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " H264_DECODER_WDMA_IRQ_STATUS_ENABLE_OVFL ,Enable interrupt ovfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "H264_DECODER_WDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to force an interrupt event (used for Software debugging or integration testing) RESET:0x0"
         bitfld.long 0x00 0. " H264_DECODER_WDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize for one cycle RESET:0x0"
          
         bitfld.long 0x00 1. " H264_DECODER_WDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 for one cycle RESET:0x0"
          
         bitfld.long 0x00 2. " H264_DECODER_WDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr for one cycle RESET:0x0"
          
         bitfld.long 0x00 3. " H264_DECODER_WDMA_IRQ_STATUS_SET_OVFL ,Set interrupt ovfl for one cycle RESET:0x0"
          
tree.end

tree "H264__DECODER__RDMA"
base e:0x40023180
width 80.
group.long  0x0++0x3
    line.long 0x00 "H264_DECODER_RDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " H264_DECODER_RDMA_CTRL_ENABLE ,Global enable for the RDMA RESET:0x0"
          
         bitfld.long 0x00 1. " H264_DECODER_RDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next read will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " H264_DECODER_RDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " H264_DECODER_RDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
         bitfld.long 0x00 11. " H264_DECODER_RDMA_CTRL_TERMINATE ,Manual termination of stream, concludes transaction and sends tlast. Self-clearing RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "H264_DECODER_RDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " H264_DECODER_RDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " H264_DECODER_RDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "H264_DECODER_RDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " H264_DECODER_RDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " H264_DECODER_RDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "H264_DECODER_RDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_DECODER_RDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "H264_DECODER_RDMA_SIZE1, SIZE1 interrupt triggers in case size1 byte have been read from the buffer / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_DECODER_RDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "H264_DECODER_RDMA_CURR_ADDR, the current address of the DMA read pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " H264_DECODER_RDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "H264_DECODER_RDMA_IRQ_STATUS, interrupt status bits reflect the occurrence of an event / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " H264_DECODER_RDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " H264_DECODER_RDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " H264_DECODER_RDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " H264_DECODER_RDMA_IRQ_STATUS_UNFL ,Underflow: data towards AXI-4S is consumed faster than the DMA is able to read data from the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "H264_DECODER_RDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " H264_DECODER_RDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " H264_DECODER_RDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " H264_DECODER_RDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " H264_DECODER_RDMA_IRQ_STATUS_ENABLE_UNFL ,Enable interrupt unfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "H264_DECODER_RDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev) RESET:0x0"
         bitfld.long 0x00 0. " H264_DECODER_RDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " H264_DECODER_RDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " H264_DECODER_RDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " H264_DECODER_RDMA_IRQ_STATUS_SET_UNFL ,Set interrupt unfl RESET:0x0"
          
tree.end

tree "CAM_CSI"
base e:0x40028000
width 80.
tree.end

tree "CAMERA"
base e:0x40029000
width 80.
group.long  0x0++0x3
    line.long 0x00 "CAMERA_CAM_CONV_CONTROL, camera conversion control RESET:0x40"
         bitfld.long 0x00 0. " CAMERA_CAM_CONV_CONTROL_CAM_CONV_START ,sys_camera CSI to mali conversion start RESET:0x0"
          
         bitfld.long 0x00 1. " CAMERA_CAM_CONV_CONTROL_CAM_CONV_RESTART ,sys_camera CSI to MALI conversion restart RESET:0x0"
          
         hexmask.long 0x00 2.--9. 1. " CAMERA_CAM_CONV_CONTROL_CAM_CONV_VBLANK ,sys_camera CSI to MALI vertical blanking width RESET:0x10"
          
group.long  0x4++0x3
    line.long 0x00 "CAMERA_CAM_DPHY_CTRL, some control signals going to the DPHY RESET:0x0"
         bitfld.long 0x00 0. " CAMERA_CAM_DPHY_CTRL_ENABLECLK ,Enable clock lane RESET:0x0"
          
         bitfld.long 0x00 1. " CAMERA_CAM_DPHY_CTRL_BISTON ,Starts the HS bist test RESET:0x0"
          
         bitfld.long 0x00 2. " CAMERA_CAM_DPHY_CTRL_BISTOK ,HS bist test OK indication RESET:0x0"
          
         bitfld.long 0x00 3. " CAMERA_CAM_DPHY_CTRL_BISTDONE ,HS bist test done RESET:0x0"
          
         bitfld.long 0x00 4. " CAMERA_CAM_DPHY_CTRL_CONT_EN ,Places the macro in IO continuity test mode RESET:0x0"
          
         hexmask.long 0x00 5.--15. 1. " CAMERA_CAM_DPHY_CTRL_CONT_DATA ,Each pin of this output bus is used to verify the continuity from the chips pin all the way to the PHY's analog ports RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "CAMERA_CAM_DPHY_INIT, Registers used during startup sequence RESET:0x20"
         hexmask.long 0x00 0.--7. 1. " CAMERA_CAM_DPHY_INIT_CFGCLKFREQRANGE ,Clk freq config preset. cfgclkfreqrange = round[(cfg_clk(MHz)-17)*4] = 32 RESET:0x20"
          
         hexmask.long 0x00 8.--14. 1. " CAMERA_CAM_DPHY_INIT_HSFREQRANGE ,High-speed freq range selection. Needs to be set from external camera RESET:0x0"
          
         hexmask.long 0x00 15.--18. 1. " CAMERA_CAM_DPHY_INIT_FORCERXMODE ,Force Lane Module into Receive Mode/Wait for Stop State for Lanes 0-3 RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "CAMERA_CAM_DPHY_TX_TEST, DPHY TX test and control interface signals DPHY RESET:0x0"
         bitfld.long 0x00 0. " CAMERA_CAM_DPHY_TX_TEST_T_CLK ,Strobe signal to clock the testdin bus contents into the PHY RESET:0x0"
          
         bitfld.long 0x00 1. " CAMERA_CAM_DPHY_TX_TEST_T_EN ,Vendor-Specific Interface Operation Type Selector. 1 -> address write operation on the falling edge of testclk. 0 -> data write operation on the rising edge of testclk RESET:0x0"
          
         bitfld.long 0x00 2. " CAMERA_CAM_DPHY_TX_TEST_T_CLR ,Interface clear signal that performs vendor-specific interface initialization RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " CAMERA_CAM_DPHY_TX_TEST_T_DIN ,Vendor-specific input 8-bit data bus for internal register programming and test functionalities access RESET:0x0"
          
         hexmask.long 0x00 11.--18. 1. " CAMERA_CAM_DPHY_TX_TEST_T_DOUT ,Vendor-Specific 8-bit data bus for read-back and internal probing functionalities RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "CAMERA_CAM_DPHY_RX_TEST, DPHY RX test and control interface signals DPHY RESET:0x0"
         bitfld.long 0x00 0. " CAMERA_CAM_DPHY_RX_TEST_T_CLK ,Strobe signal to clock the testdin bus contents into the PHY RESET:0x0"
          
         bitfld.long 0x00 1. " CAMERA_CAM_DPHY_RX_TEST_T_EN ,Vendor-Specific Interface Operation Type Selector. 1 -> address write operation on the falling edge of testclk. 0 -> data write operation on the rising edge of testclk RESET:0x0"
          
         bitfld.long 0x00 2. " CAMERA_CAM_DPHY_RX_TEST_T_CLR ,Interface clear signal that performs vendor-specific interface initialization RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " CAMERA_CAM_DPHY_RX_TEST_T_DIN ,Vendor-specific input 8-bit data bus for internal register programming and test functionalities access RESET:0x0"
          
         hexmask.long 0x00 11.--18. 1. " CAMERA_CAM_DPHY_RX_TEST_T_DOUT ,Vendor-Specific 8-bit data bus for read-back and internal probing functionalities RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "CAMERA_CAM_DPHY_OBS, Status/error signals from MIPI DPHY RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " CAMERA_CAM_DPHY_OBS_ERRCONTENTIONLP0 ,LP0 contention error for lanes 0-3 RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " CAMERA_CAM_DPHY_OBS_ERRCONTENTIONLP1 ,LP1 contention error for lanes 0-3 RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " CAMERA_CAM_DPHY_OBS_ERRCONTROL ,Control error for incorrect line state for lanes 0-3 RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " CAMERA_CAM_DPHY_OBS_ERRSYNCESC ,Low-Power Data Transmission Synchronization Error for lanes 0-3 RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " CAMERA_CAM_DPHY_OBS_RXACTIVEHS ,High-speed reception active for lanes 0-3 RESET:0x0"
          
         hexmask.long 0x00 20.--23. 1. " CAMERA_CAM_DPHY_OBS_ULPSACTIVENOT ,Indicator ultra-low-power mode for lanes 0-3 RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "CAMERA_MALI_CTRL, Arm Mali control signals RESET:0x0"
         bitfld.long 0x00 0. " CAMERA_MALI_CTRL_VCKE ,Video clock enable for Mali core logic RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "CAMERA_RESET_CTRL, SW reset control RESET:0x0"
         bitfld.long 0x00 0. " CAMERA_RESET_CTRL_SW_RESET_MALI_N ,SW trigger for reset_mali_n of sys_camera, active low RESET:0x0"
          
         bitfld.long 0x00 1. " CAMERA_RESET_CTRL_SW_RESET_CSI_PIXEL_N ,SW trigger for sw_reset_csi_pixel_n of sys_camera, active low RESET:0x0"
          
tree.end

tree "IRCAM_SPI"
base e:0x40030000
width 80.
group.long  0x0++0x3
    line.long 0x00 "IRCAM_SPI_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " IRCAM_SPI_CTRL_EN ,Enable SPI Master RESET:0x0"
          
         bitfld.long 0x00 1. " IRCAM_SPI_CTRL_CPHA ,CPHA RESET:0x0"
          
         bitfld.long 0x00 2. " IRCAM_SPI_CTRL_CPOL ,CPOL RESET:0x0"
          
         bitfld.long 0x00 3. " IRCAM_SPI_CTRL_STOP ,End of Transfer. Must be set when last byte to be transmitted is added to the TX FIFO RESET:0x0"
          
         bitfld.long 0x00 4.--5. " IRCAM_SPI_CTRL_MODE ,SPI communication mode - 00: DMA (default) - 01: APB_WDMA - 10: APB_RDMA - 11: APB RESET:0x0" "DMA-0,APB_WDMA-1,APB_RDMA-2,APB-3"
          
rgroup.long 0x4++0x3
    line.long 0x00 "IRCAM_SPI_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " IRCAM_SPI_STATUS_RX_NOT_EMPTY ,Status: RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 1. " IRCAM_SPI_STATUS_RX_FULL ,Status: RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " IRCAM_SPI_STATUS_TX_EMPTY ,Status: TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 3. " IRCAM_SPI_STATUS_TX_NOT_FULL ,Status: TX FIFO not full RESET:0x0"
          
         bitfld.long 0x00 4. " IRCAM_SPI_STATUS_RX_TLAST ,Status: RX Path, last byte was received RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "IRCAM_SPI_IRQ_STATUS_ENABLE, None RESET:0x0"
         bitfld.long 0x00 0. " IRCAM_SPI_IRQ_STATUS_ENABLE_RX_OVFL ,Enable IRQ for RX FIFO overflow RESET:0x0"
          
         bitfld.long 0x00 1. " IRCAM_SPI_IRQ_STATUS_ENABLE_RX_FULL ,Enable IRQ for RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " IRCAM_SPI_IRQ_STATUS_ENABLE_RX_NOT_EMPTY ,Enable IRQ for RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 3. " IRCAM_SPI_IRQ_STATUS_ENABLE_TX_EMPTY ,Enable IRQ for TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 4. " IRCAM_SPI_IRQ_STATUS_ENABLE_TX_NOT_FULL ,Enable IRQ for TX FIFO not full RESET:0x0"
          
         bitfld.long 0x00 5. " IRCAM_SPI_IRQ_STATUS_ENABLE_TX_DONE ,Enable IRQ for last byte TX/RX done RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "IRCAM_SPI_IRQ_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " IRCAM_SPI_IRQ_STATUS_RX_OVFL ,IRQ Status for RX FIFO overflow RESET:0x0"
          
         bitfld.long 0x00 1. " IRCAM_SPI_IRQ_STATUS_RX_FULL ,IRQ Status for RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " IRCAM_SPI_IRQ_STATUS_RX_NOT_EMPTY ,Enable IRQ for RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 3. " IRCAM_SPI_IRQ_STATUS_TX_EMPTY ,IRQ Status for TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 4. " IRCAM_SPI_IRQ_STATUS_TX_NOT_FULL ,IRQ Status for TX FIFO not full RESET:0x0"
          
         bitfld.long 0x00 5. " IRCAM_SPI_IRQ_STATUS_TX_DONE ,IRQ Status for last byte TX/RX done RESET:0x0"
          
wgroup.long 0x10++0x3
    line.long 0x00 "IRCAM_SPI_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev) (singlepulse) RESET:0x0"
         bitfld.long 0x00 0. " IRCAM_SPI_IRQ_STATUS_SET_RX_OVFL ,Set rx_ovfl irq RESET:0x0"
          
         bitfld.long 0x00 1. " IRCAM_SPI_IRQ_STATUS_SET_RX_FULL ,Set rx_full irq RESET:0x0"
          
         bitfld.long 0x00 2. " IRCAM_SPI_IRQ_STATUS_SET_RX_NOT_EMPTY ,Set rx_not_empty irq RESET:0x0"
          
         bitfld.long 0x00 3. " IRCAM_SPI_IRQ_STATUS_SET_TX_EMPTY ,Set tx_empty irq RESET:0x0"
          
         bitfld.long 0x00 4. " IRCAM_SPI_IRQ_STATUS_SET_TX_NOT_FULL ,Set tx_not_full irq RESET:0x0"
          
         bitfld.long 0x00 5. " IRCAM_SPI_IRQ_STATUS_SET_TX_DONE ,Set tx_done irq RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "IRCAM_SPI_SCLK_FREQ, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " IRCAM_SPI_SCLK_FREQ_TICKS ,Set clock ticks for half of SCLK_PERIOD. SCLK_FREQ = SPI_MST_CLK_FREQ/(2*(ticks+1)) RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "IRCAM_SPI_TX, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " IRCAM_SPI_TX_DATA ,Data to be added on TX FIFO RESET:0x0"
          
         bitfld.long 0x00 8. " IRCAM_SPI_TX_DATA_WTRIG ,Set wtrig signal to indicate data is valid (singlepulse first check on none full tx_fifo!!!) RESET:0x0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "IRCAM_SPI_RX, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " IRCAM_SPI_RX_DATA ,Data to be read from the RX FIFO. Data is not consumed on read. Use RX_FIFO register to consume/clear RX FIFO RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "IRCAM_SPI_RX_FIFO, None RESET:0x0"
         bitfld.long 0x00 0. " IRCAM_SPI_RX_FIFO_POP ,Consume one item on RX FIFO (singlepulse) RESET:0x0"
          
         bitfld.long 0x00 1. " IRCAM_SPI_RX_FIFO_RX_FLUSH ,Flush RX FIFO (constant enable) RESET:0x0"
          
tree.end

tree "IRCAM"
base e:0x40032000
width 80.
group.long  0x24++0x3
    line.long 0x00 "IRCAM_CTRL, Control register of ircam RESET:0x0"
         bitfld.long 0x00 0. " IRCAM_CTRL_SS_POL ,0: SS active low output, 1: SS active high output. Relevant only if ss_override = 0 RESET:0x0"
          
         bitfld.long 0x00 1. " IRCAM_CTRL_SS_OVERRIDE ,0: SS controlled by ri_spi_mst, 1: SS controlled by the ss register RESET:0x0"
          
         bitfld.long 0x00 2. " IRCAM_CTRL_SS ,It can be used to control the SPI SS manually if ss_override = 1 RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "IRCAM_SENSOR, Stores the control command to be sent to the IR sensor and, if the operation is a write (e.g. for initial configuration of the sensor), the data to write RESET:0x0"
         bitfld.long 0x00 0.--7. " IRCAM_SENSOR_CMD ,Command to send to the sensor RESET:0x0" "CONFIG-1,STATUS-2,TRIM1-3,TRIM2-4,TRIM3-5,TRIM4-6,TRIM5-7,TRIM6-8,READ_DATA1-10,READ_DATA2-11"
          
         hexmask.long 0x00 8.--15. 1. " IRCAM_SENSOR_DATA ,Data to write in the sensor RESET:0x0"
          
         bitfld.long 0x00 16. " IRCAM_SENSOR_CMD_VALID ,Used to indicate that a valid command has been loaded in the register RESET:0x0"
          
         hexmask.long 0x00 17.--24. 1. " IRCAM_SENSOR_STATUS ,Value of the IR sensor status register RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "IRCAM_READ_SIZE, Specifies the amount of bytes that should be read from the sensor. It could be used in case a partial read of the frame is required RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " IRCAM_READ_SIZE_VALUE ,None RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "IRCAM_IRQ_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " IRCAM_IRQ_STATUS_OP_DONE ,Indicates the read/write operation is done RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "IRCAM_IRQ_STATUS_ENABLE, None RESET:0x0"
         bitfld.long 0x00 0. " IRCAM_IRQ_STATUS_ENABLE_OP_DONE ,Enables irq_status.op_done RESET:0x0"
          
wgroup.long 0x38++0x3
    line.long 0x00 "IRCAM_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev). RESET:0x0"
         bitfld.long 0x00 0. " IRCAM_IRQ_STATUS_SET_OP_DONE ,Set irq_status.op_done RESET:0x0"
          
tree.end

tree "IRCAM__RI_WDMA"
base e:0x40032000
width 80.
group.long  0x0++0x3
    line.long 0x00 "IRCAM_RI_WDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " IRCAM_RI_WDMA_CTRL_ENABLE ,Global enable for the WDMA RESET:0x0"
          
         bitfld.long 0x00 1. " IRCAM_RI_WDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next write will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " IRCAM_RI_WDMA_CTRL_ADDR_DECREMENT ,When = 1, address is decremented in the AXI master RESET:0x0"
          
         bitfld.long 0x00 3. " IRCAM_RI_WDMA_CTRL_CONT_MODE ,Enables continuous mode if set to 1, transmission is finalized, if HW signals last access RESET:0x0"
          
         bitfld.long 0x00 4. " IRCAM_RI_WDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 5.--12. 1. " IRCAM_RI_WDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "IRCAM_RI_WDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " IRCAM_RI_WDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " IRCAM_RI_WDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "IRCAM_RI_WDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " IRCAM_RI_WDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " IRCAM_RI_WDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "IRCAM_RI_WDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " IRCAM_RI_WDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "IRCAM_RI_WDMA_SIZE1, SIZE1 interrupt triggers in case buffer is filled with size1 byte / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " IRCAM_RI_WDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "IRCAM_RI_WDMA_CURR_ADDR, the current address of the DMA write pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " IRCAM_RI_WDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "IRCAM_RI_WDMA_IRQ_STATUS, interrupt status bits / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " IRCAM_RI_WDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " IRCAM_RI_WDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " IRCAM_RI_WDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " IRCAM_RI_WDMA_IRQ_STATUS_OVFL ,Overflow: data from AXI-4S is coming too fast to be written to the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "IRCAM_RI_WDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " IRCAM_RI_WDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " IRCAM_RI_WDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " IRCAM_RI_WDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " IRCAM_RI_WDMA_IRQ_STATUS_ENABLE_OVFL ,Enable interrupt ovfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "IRCAM_RI_WDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to force an interrupt event (used for Software debugging or integration testing) RESET:0x0"
         bitfld.long 0x00 0. " IRCAM_RI_WDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize for one cycle RESET:0x0"
          
         bitfld.long 0x00 1. " IRCAM_RI_WDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 for one cycle RESET:0x0"
          
         bitfld.long 0x00 2. " IRCAM_RI_WDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr for one cycle RESET:0x0"
          
         bitfld.long 0x00 3. " IRCAM_RI_WDMA_IRQ_STATUS_SET_OVFL ,Set interrupt ovfl for one cycle RESET:0x0"
          
tree.end

tree "I2S_SLV_1"
base e:0x40033000
width 80.
tree.end

tree "I2S_SLV_1__I2S_SLAVE"
base e:0x40033000
width 80.
group.long  0x0++0x3
    line.long 0x00 "I2S_SLV_1_I2S_SLAVE_CFG, Configuration for I2S slave RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_1_I2S_SLAVE_CFG_WS_POLARITY ,WS polarity (LRCK / FSYNC) 0: FSYNC on rising edge 1: FSYNC on falling edge RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "I2S_SLV_1_I2S_SLAVE_CTRL, Control for I2S slave RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_1_I2S_SLAVE_CTRL_RESET_DISABLE ,Interface I2S SCK domain asynchronous reset 0: reset active 1: reset inactive RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_SLV_1_I2S_SLAVE_CTRL_ENABLE ,Interface enable  0: sampler inactive, buffer clear, realign to WS  1: sampler enabled Important: reset register must be set to inactive to enable sampler RESET:0x0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "I2S_SLV_1_I2S_SLAVE_STATUS, I2S slave buffer state RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_1_I2S_SLAVE_STATUS_BUF_OVERFLOW ,buffer overflow RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "I2S_SLV_1_I2S_SLAVE_IRQ_STATUS, I2S slave IRQ status RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_1_I2S_SLAVE_IRQ_STATUS_BUFFER_OVERFLOW ,IRQ status : buffer overflow; I2S slave was writing to a full audio buffer RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "I2S_SLV_1_I2S_SLAVE_IRQ_STATUS_ENABLE, I2S slave IRQ status enable mask RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_1_I2S_SLAVE_IRQ_STATUS_ENABLE_BUFFER_OVERFLOW ,IRQ enable : buffer overflow RESET:0x0"
          
wgroup.long 0x14++0x3
    line.long 0x00 "I2S_SLV_1_I2S_SLAVE_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev). RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_1_I2S_SLAVE_IRQ_STATUS_SET_BUFFER_OVERFLOW ,Set irq_status.buffer_overflow RESET:0x0"
          
tree.end

tree "I2S_SLV_1__WDMA"
base e:0x40033040
width 80.
group.long  0x0++0x3
    line.long 0x00 "I2S_SLV_1_WDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " I2S_SLV_1_WDMA_CTRL_ENABLE ,Global enable for the WDMA RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_SLV_1_WDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next write will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " I2S_SLV_1_WDMA_CTRL_ADDR_DECREMENT ,When = 1, address is decremented in the AXI master RESET:0x0"
          
         bitfld.long 0x00 3. " I2S_SLV_1_WDMA_CTRL_CONT_MODE ,Enables continuous mode if set to 1, transmission is finalized, if HW signals last access RESET:0x0"
          
         bitfld.long 0x00 4. " I2S_SLV_1_WDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 5.--12. 1. " I2S_SLV_1_WDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "I2S_SLV_1_WDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " I2S_SLV_1_WDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " I2S_SLV_1_WDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "I2S_SLV_1_WDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " I2S_SLV_1_WDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " I2S_SLV_1_WDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "I2S_SLV_1_WDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " I2S_SLV_1_WDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "I2S_SLV_1_WDMA_SIZE1, SIZE1 interrupt triggers in case buffer is filled with size1 byte / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " I2S_SLV_1_WDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "I2S_SLV_1_WDMA_CURR_ADDR, the current address of the DMA write pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " I2S_SLV_1_WDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "I2S_SLV_1_WDMA_IRQ_STATUS, interrupt status bits / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_1_WDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_SLV_1_WDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " I2S_SLV_1_WDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " I2S_SLV_1_WDMA_IRQ_STATUS_OVFL ,Overflow: data from AXI-4S is coming too fast to be written to the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "I2S_SLV_1_WDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_1_WDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_SLV_1_WDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " I2S_SLV_1_WDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " I2S_SLV_1_WDMA_IRQ_STATUS_ENABLE_OVFL ,Enable interrupt ovfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "I2S_SLV_1_WDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to force an interrupt event (used for Software debugging or integration testing) RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_1_WDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize for one cycle RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_SLV_1_WDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 for one cycle RESET:0x0"
          
         bitfld.long 0x00 2. " I2S_SLV_1_WDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr for one cycle RESET:0x0"
          
         bitfld.long 0x00 3. " I2S_SLV_1_WDMA_IRQ_STATUS_SET_OVFL ,Set interrupt ovfl for one cycle RESET:0x0"
          
tree.end

tree "I2S_SLV_2"
base e:0x40035000
width 80.
tree.end

tree "I2S_SLV_2__I2S_SLAVE"
base e:0x40035000
width 80.
group.long  0x0++0x3
    line.long 0x00 "I2S_SLV_2_I2S_SLAVE_CFG, Configuration for I2S slave RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_2_I2S_SLAVE_CFG_WS_POLARITY ,WS polarity (LRCK / FSYNC) 0: FSYNC on rising edge 1: FSYNC on falling edge RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "I2S_SLV_2_I2S_SLAVE_CTRL, Control for I2S slave RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_2_I2S_SLAVE_CTRL_RESET_DISABLE ,Interface I2S SCK domain asynchronous reset 0: reset active 1: reset inactive RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_SLV_2_I2S_SLAVE_CTRL_ENABLE ,Interface enable  0: sampler inactive, buffer clear, realign to WS  1: sampler enabled Important: reset register must be set to inactive to enable sampler RESET:0x0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "I2S_SLV_2_I2S_SLAVE_STATUS, I2S slave buffer state RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_2_I2S_SLAVE_STATUS_BUF_OVERFLOW ,buffer overflow RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "I2S_SLV_2_I2S_SLAVE_IRQ_STATUS, I2S slave IRQ status RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_2_I2S_SLAVE_IRQ_STATUS_BUFFER_OVERFLOW ,IRQ status : buffer overflow; I2S slave was writing to a full audio buffer RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "I2S_SLV_2_I2S_SLAVE_IRQ_STATUS_ENABLE, I2S slave IRQ status enable mask RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_2_I2S_SLAVE_IRQ_STATUS_ENABLE_BUFFER_OVERFLOW ,IRQ enable : buffer overflow RESET:0x0"
          
wgroup.long 0x14++0x3
    line.long 0x00 "I2S_SLV_2_I2S_SLAVE_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev). RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_2_I2S_SLAVE_IRQ_STATUS_SET_BUFFER_OVERFLOW ,Set irq_status.buffer_overflow RESET:0x0"
          
tree.end

tree "I2S_SLV_2__WDMA"
base e:0x40035040
width 80.
group.long  0x0++0x3
    line.long 0x00 "I2S_SLV_2_WDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " I2S_SLV_2_WDMA_CTRL_ENABLE ,Global enable for the WDMA RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_SLV_2_WDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next write will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " I2S_SLV_2_WDMA_CTRL_ADDR_DECREMENT ,When = 1, address is decremented in the AXI master RESET:0x0"
          
         bitfld.long 0x00 3. " I2S_SLV_2_WDMA_CTRL_CONT_MODE ,Enables continuous mode if set to 1, transmission is finalized, if HW signals last access RESET:0x0"
          
         bitfld.long 0x00 4. " I2S_SLV_2_WDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 5.--12. 1. " I2S_SLV_2_WDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "I2S_SLV_2_WDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " I2S_SLV_2_WDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " I2S_SLV_2_WDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "I2S_SLV_2_WDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " I2S_SLV_2_WDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " I2S_SLV_2_WDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "I2S_SLV_2_WDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " I2S_SLV_2_WDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "I2S_SLV_2_WDMA_SIZE1, SIZE1 interrupt triggers in case buffer is filled with size1 byte / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " I2S_SLV_2_WDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "I2S_SLV_2_WDMA_CURR_ADDR, the current address of the DMA write pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " I2S_SLV_2_WDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "I2S_SLV_2_WDMA_IRQ_STATUS, interrupt status bits / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_2_WDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_SLV_2_WDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " I2S_SLV_2_WDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " I2S_SLV_2_WDMA_IRQ_STATUS_OVFL ,Overflow: data from AXI-4S is coming too fast to be written to the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "I2S_SLV_2_WDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_2_WDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_SLV_2_WDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " I2S_SLV_2_WDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " I2S_SLV_2_WDMA_IRQ_STATUS_ENABLE_OVFL ,Enable interrupt ovfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "I2S_SLV_2_WDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to force an interrupt event (used for Software debugging or integration testing) RESET:0x0"
         bitfld.long 0x00 0. " I2S_SLV_2_WDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize for one cycle RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_SLV_2_WDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 for one cycle RESET:0x0"
          
         bitfld.long 0x00 2. " I2S_SLV_2_WDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr for one cycle RESET:0x0"
          
         bitfld.long 0x00 3. " I2S_SLV_2_WDMA_IRQ_STATUS_SET_OVFL ,Set interrupt ovfl for one cycle RESET:0x0"
          
tree.end

tree "BTSPI_MST"
base e:0x40043000
width 80.
tree.end

tree "BTSPI_MST__WRAP"
base e:0x40043000
width 80.
group.long  0x0++0x3
    line.long 0x00 "BTSPI_MST_WRAP_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " BTSPI_MST_WRAP_CTRL_EN ,Enable SPI Master RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_WRAP_CTRL_CPHA ,CPHA RESET:0x0"
          
         bitfld.long 0x00 2. " BTSPI_MST_WRAP_CTRL_CPOL ,CPOL RESET:0x0"
          
         bitfld.long 0x00 3. " BTSPI_MST_WRAP_CTRL_STOP ,End of Transfer. Must be set when last byte to be transmitted is added to the TX FIFO RESET:0x0"
          
         bitfld.long 0x00 4.--5. " BTSPI_MST_WRAP_CTRL_MODE ,SPI communication mode - 00: DMA (default) - 01: APB_WDMA - 10: APB_RDMA - 11: APB RESET:0x0" "DMA-0,APB_WDMA-1,APB_RDMA-2,APB-3"
          
rgroup.long 0x4++0x3
    line.long 0x00 "BTSPI_MST_WRAP_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " BTSPI_MST_WRAP_STATUS_RX_NOT_EMPTY ,Status: RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_WRAP_STATUS_RX_FULL ,Status: RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " BTSPI_MST_WRAP_STATUS_TX_EMPTY ,Status: TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 3. " BTSPI_MST_WRAP_STATUS_TX_NOT_FULL ,Status: TX FIFO not full RESET:0x0"
          
         bitfld.long 0x00 4. " BTSPI_MST_WRAP_STATUS_RX_TLAST ,Status: RX Path, last byte was received RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "BTSPI_MST_WRAP_IRQ_STATUS_ENABLE, None RESET:0x0"
         bitfld.long 0x00 0. " BTSPI_MST_WRAP_IRQ_STATUS_ENABLE_RX_OVFL ,Enable IRQ for RX FIFO overflow RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_WRAP_IRQ_STATUS_ENABLE_RX_FULL ,Enable IRQ for RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " BTSPI_MST_WRAP_IRQ_STATUS_ENABLE_RX_NOT_EMPTY ,Enable IRQ for RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 3. " BTSPI_MST_WRAP_IRQ_STATUS_ENABLE_TX_EMPTY ,Enable IRQ for TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 4. " BTSPI_MST_WRAP_IRQ_STATUS_ENABLE_TX_NOT_FULL ,Enable IRQ for TX FIFO not full RESET:0x0"
          
         bitfld.long 0x00 5. " BTSPI_MST_WRAP_IRQ_STATUS_ENABLE_TX_DONE ,Enable IRQ for last byte TX/RX done RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "BTSPI_MST_WRAP_IRQ_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " BTSPI_MST_WRAP_IRQ_STATUS_RX_OVFL ,IRQ Status for RX FIFO overflow RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_WRAP_IRQ_STATUS_RX_FULL ,IRQ Status for RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " BTSPI_MST_WRAP_IRQ_STATUS_RX_NOT_EMPTY ,Enable IRQ for RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 3. " BTSPI_MST_WRAP_IRQ_STATUS_TX_EMPTY ,IRQ Status for TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 4. " BTSPI_MST_WRAP_IRQ_STATUS_TX_NOT_FULL ,IRQ Status for TX FIFO not full RESET:0x0"
          
         bitfld.long 0x00 5. " BTSPI_MST_WRAP_IRQ_STATUS_TX_DONE ,IRQ Status for last byte TX/RX done RESET:0x0"
          
wgroup.long 0x10++0x3
    line.long 0x00 "BTSPI_MST_WRAP_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev) (singlepulse) RESET:0x0"
         bitfld.long 0x00 0. " BTSPI_MST_WRAP_IRQ_STATUS_SET_RX_OVFL ,Set rx_ovfl irq RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_WRAP_IRQ_STATUS_SET_RX_FULL ,Set rx_full irq RESET:0x0"
          
         bitfld.long 0x00 2. " BTSPI_MST_WRAP_IRQ_STATUS_SET_RX_NOT_EMPTY ,Set rx_not_empty irq RESET:0x0"
          
         bitfld.long 0x00 3. " BTSPI_MST_WRAP_IRQ_STATUS_SET_TX_EMPTY ,Set tx_empty irq RESET:0x0"
          
         bitfld.long 0x00 4. " BTSPI_MST_WRAP_IRQ_STATUS_SET_TX_NOT_FULL ,Set tx_not_full irq RESET:0x0"
          
         bitfld.long 0x00 5. " BTSPI_MST_WRAP_IRQ_STATUS_SET_TX_DONE ,Set tx_done irq RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "BTSPI_MST_WRAP_SCLK_FREQ, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " BTSPI_MST_WRAP_SCLK_FREQ_TICKS ,Set clock ticks for half of SCLK_PERIOD. SCLK_FREQ = SPI_MST_CLK_FREQ/(2*(ticks+1)) RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "BTSPI_MST_WRAP_TX, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " BTSPI_MST_WRAP_TX_DATA ,Data to be added on TX FIFO RESET:0x0"
          
         bitfld.long 0x00 8. " BTSPI_MST_WRAP_TX_DATA_WTRIG ,Set wtrig signal to indicate data is valid (singlepulse first check on none full tx_fifo!!!) RESET:0x0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "BTSPI_MST_WRAP_RX, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " BTSPI_MST_WRAP_RX_DATA ,Data to be read from the RX FIFO. Data is not consumed on read. Use RX_FIFO register to consume/clear RX FIFO RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "BTSPI_MST_WRAP_RX_FIFO, None RESET:0x0"
         bitfld.long 0x00 0. " BTSPI_MST_WRAP_RX_FIFO_POP ,Consume one item on RX FIFO (singlepulse) RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_WRAP_RX_FIFO_RX_FLUSH ,Flush RX FIFO (constant enable) RESET:0x0"
          
tree.end

tree "BTSPI_MST__QSPI"
base e:0x40043040
width 80.
group.long  0x0++0x3
    line.long 0x00 "BTSPI_MST_QSPI_CFG_ITF, Configuration for (Q)SPI master interface RESET:0x40"
         bitfld.long 0x00 0.--1. " BTSPI_MST_QSPI_CFG_ITF_SPI_MODE ,SPI interface mode - 00: 1 bit SPI (single SPI) (default) - 01: 2 bit SPI (dual SPI) - 10: 4 bit SPI (quad SPI) - 11: reserved RESET:0x0" "SNGL_SPI-0,DUAL_SPI-1,QUAD_SPI-2"
          
         bitfld.long 0x00 2. " BTSPI_MST_QSPI_CFG_ITF_CPHA ,SPI clock phase - 0: change data on falling egde, sample data on rising  edge (default) - 1: change data on rising  egde, sample data on falling edge RESET:0x0"
          
         bitfld.long 0x00 3. " BTSPI_MST_QSPI_CFG_ITF_CPOL ,SPI clock polarity - 0: clock in idle state is low (default) - 1: clock in idle state is high RESET:0x0"
          
         bitfld.long 0x00 4.--5. " BTSPI_MST_QSPI_CFG_ITF_MOSI_SEL ,select QSPI data port for SPI MOSI (output) in single SPI mode - 0: MOSI[0] (default) - 1: MOSI[1] - 2: MOSI[2] - 3: MOSI[3] RESET:0x0" "MOSI_0-0,MOSI_1-1,MOSI_2-2,MOSI_3-3"
          
         bitfld.long 0x00 6.--7. " BTSPI_MST_QSPI_CFG_ITF_MISO_SEL ,select QSPI data port for SPI MISO (input) in single SPI mode - 0: MISO[0] - 1: MISO[1] (default) - 2: MISO[2] - 3: MISO[3] RESET:0x1" "MISO_0-0,MISO_1-1,MISO_2-2,MISO_3-3"
          
group.long  0x4++0x3
    line.long 0x00 "BTSPI_MST_QSPI_CFG_SCLK, Configuration for SPI clock RESET:0x10001"
         hexmask.long 0x00 0.--7. 1. " BTSPI_MST_QSPI_CFG_SCLK_CDIV ,SPI clock divider SPI clock[freq] = sys_clk / (2*(cdiv+1))     duty cycle is 50% RESET:0x1"
          
         hexmask.long 0x00 16.--24. 1. " BTSPI_MST_QSPI_CFG_SCLK_SMPL_POINT ,sample point - [8]   : SPI clock high/low - [7:0] : clk_div_phase example: sample at rising edge: [8]   = 0 [7:0] = cdiv RESET:0x1"
          
group.long  0x8++0x3
    line.long 0x00 "BTSPI_MST_QSPI_CFG_SS_TIMING, configure SPI slave select timing RESET:0x100"
         hexmask.long 0x00 0.--3. 1. " BTSPI_MST_QSPI_CFG_SS_TIMING_SETUP ,setup time, time from falling edge of 'slave select' to first active SPI clock edge, number of SPI clock periods, values 0-15 (default = 0) RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " BTSPI_MST_QSPI_CFG_SS_TIMING_HOLD ,hold time, time from last active SPI clock edge to rising edge of 'slave select', number of SPI clock periods, values 0-15 (default = 0) RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " BTSPI_MST_QSPI_CFG_SS_TIMING_INACTIVE ,minimum inactive time (inter transaction gap), SPI slave select is high for minimum this period between transactions, number of SPI clock periods, values 0-15 (default = 1) RESET:0x1"
          
group.long  0xc++0x3
    line.long 0x00 "BTSPI_MST_QSPI_CTRL, (Q)SPI master control RESET:0x0"
         bitfld.long 0x00 0. " BTSPI_MST_QSPI_CTRL_RESTART ,Restart (Q)SPI master interface (single pulse / self clearing) reset state and flush buffers RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "BTSPI_MST_QSPI_EXT_SS_CTRL, (Q)SPI slave select control RESET:0x2"
         bitfld.long 0x00 0. " BTSPI_MST_QSPI_EXT_SS_CTRL_ENABLE ,enable external slave select RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_QSPI_EXT_SS_CTRL_VALUE ,value of external slave select 0: low 1: high (default) RESET:0x1"
          
rgroup.long 0x14++0x3
    line.long 0x00 "BTSPI_MST_QSPI_STATUS, (Q)SPI state RESET:0x0"
         bitfld.long 0x00 0.--2. " BTSPI_MST_QSPI_STATUS_STATE ,FSM state of (Q)SPI master RESET:0x0" "IDLE-0,SS_SETUP-1,SS_HOLD-2,SS_INACTIVE-3,SHIFTING-4,SHIFT_LAST_WORD-5,WAIT-6,FINISH_TRANSFER-7"
          
tree.end

tree "BTSPI_MST__WDMA"
base e:0x40043080
width 80.
group.long  0x0++0x3
    line.long 0x00 "BTSPI_MST_WDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " BTSPI_MST_WDMA_CTRL_ENABLE ,Global enable for the WDMA RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_WDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next write will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " BTSPI_MST_WDMA_CTRL_ADDR_DECREMENT ,When = 1, address is decremented in the AXI master RESET:0x0"
          
         bitfld.long 0x00 3. " BTSPI_MST_WDMA_CTRL_CONT_MODE ,Enables continuous mode if set to 1, transmission is finalized, if HW signals last access RESET:0x0"
          
         bitfld.long 0x00 4. " BTSPI_MST_WDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 5.--12. 1. " BTSPI_MST_WDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "BTSPI_MST_WDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " BTSPI_MST_WDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " BTSPI_MST_WDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "BTSPI_MST_WDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " BTSPI_MST_WDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " BTSPI_MST_WDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "BTSPI_MST_WDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " BTSPI_MST_WDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "BTSPI_MST_WDMA_SIZE1, SIZE1 interrupt triggers in case buffer is filled with size1 byte / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " BTSPI_MST_WDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "BTSPI_MST_WDMA_CURR_ADDR, the current address of the DMA write pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " BTSPI_MST_WDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "BTSPI_MST_WDMA_IRQ_STATUS, interrupt status bits / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " BTSPI_MST_WDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_WDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " BTSPI_MST_WDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " BTSPI_MST_WDMA_IRQ_STATUS_OVFL ,Overflow: data from AXI-4S is coming too fast to be written to the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "BTSPI_MST_WDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " BTSPI_MST_WDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_WDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " BTSPI_MST_WDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " BTSPI_MST_WDMA_IRQ_STATUS_ENABLE_OVFL ,Enable interrupt ovfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "BTSPI_MST_WDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to force an interrupt event (used for Software debugging or integration testing) RESET:0x0"
         bitfld.long 0x00 0. " BTSPI_MST_WDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize for one cycle RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_WDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 for one cycle RESET:0x0"
          
         bitfld.long 0x00 2. " BTSPI_MST_WDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr for one cycle RESET:0x0"
          
         bitfld.long 0x00 3. " BTSPI_MST_WDMA_IRQ_STATUS_SET_OVFL ,Set interrupt ovfl for one cycle RESET:0x0"
          
tree.end

tree "BTSPI_MST__RDMA"
base e:0x400430c0
width 80.
group.long  0x0++0x3
    line.long 0x00 "BTSPI_MST_RDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " BTSPI_MST_RDMA_CTRL_ENABLE ,Global enable for the RDMA RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_RDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next read will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " BTSPI_MST_RDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " BTSPI_MST_RDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
         bitfld.long 0x00 11. " BTSPI_MST_RDMA_CTRL_TERMINATE ,Manual termination of stream, concludes transaction and sends tlast. Self-clearing RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "BTSPI_MST_RDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " BTSPI_MST_RDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " BTSPI_MST_RDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "BTSPI_MST_RDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " BTSPI_MST_RDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " BTSPI_MST_RDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "BTSPI_MST_RDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " BTSPI_MST_RDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "BTSPI_MST_RDMA_SIZE1, SIZE1 interrupt triggers in case size1 byte have been read from the buffer / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " BTSPI_MST_RDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "BTSPI_MST_RDMA_CURR_ADDR, the current address of the DMA read pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " BTSPI_MST_RDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "BTSPI_MST_RDMA_IRQ_STATUS, interrupt status bits reflect the occurrence of an event / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " BTSPI_MST_RDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_RDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " BTSPI_MST_RDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " BTSPI_MST_RDMA_IRQ_STATUS_UNFL ,Underflow: data towards AXI-4S is consumed faster than the DMA is able to read data from the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "BTSPI_MST_RDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " BTSPI_MST_RDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_RDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " BTSPI_MST_RDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " BTSPI_MST_RDMA_IRQ_STATUS_ENABLE_UNFL ,Enable interrupt unfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "BTSPI_MST_RDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev) RESET:0x0"
         bitfld.long 0x00 0. " BTSPI_MST_RDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " BTSPI_MST_RDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " BTSPI_MST_RDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " BTSPI_MST_RDMA_IRQ_STATUS_SET_UNFL ,Set interrupt unfl RESET:0x0"
          
tree.end

tree "I2C_MST"
base e:0x40046000
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "I2C_MST_STATUS, I2C Master Status Register RESET:0x0"
         bitfld.long 0x00 0. " I2C_MST_STATUS_RX_ACK ,Received acknowledge from slave RESET:0x0"
          
         bitfld.long 0x00 1. " I2C_MST_STATUS_BUSY ,bus busy (start signal detected) RESET:0x0"
          
         bitfld.long 0x00 2. " I2C_MST_STATUS_TIP ,byte transfer in progress RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "I2C_MST_CTRL, I2C Master Control Register RESET:0x0"
         bitfld.long 0x00 0. " I2C_MST_CTRL_CORE_EN ,core enable bit RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "I2C_MST_IRQ_STATUS, I2C Master Interrupt Status Register RESET:0x0"
         bitfld.long 0x00 0. " I2C_MST_IRQ_STATUS_ACK ,WRITE: slave sent acknowledge READ: master generated ACK RESET:0x0"
          
         bitfld.long 0x00 1. " I2C_MST_IRQ_STATUS_NACK ,WRITE: slave did not send acknowledge READ: master generated an NACK RESET:0x0"
          
         bitfld.long 0x00 2. " I2C_MST_IRQ_STATUS_STOP ,STOP bit sent, transfer finished RESET:0x0"
          
         bitfld.long 0x00 3. " I2C_MST_IRQ_STATUS_ARBLOST ,arbitration lost RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "I2C_MST_IRQ_STATUS_ENABLE, I2C Master Interrupt Status Register RESET:0x0"
         bitfld.long 0x00 0. " I2C_MST_IRQ_STATUS_ENABLE_ACK ,Enable irq_status.ack RESET:0x0"
          
         bitfld.long 0x00 1. " I2C_MST_IRQ_STATUS_ENABLE_NACK ,Enable irq_status.nack RESET:0x0"
          
         bitfld.long 0x00 2. " I2C_MST_IRQ_STATUS_ENABLE_STOP ,Enable irq_status.stop RESET:0x0"
          
         bitfld.long 0x00 3. " I2C_MST_IRQ_STATUS_ENABLE_ARBLOST ,Enable irq_status.arblost RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "I2C_MST_TX, I2C Master TX Data Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " I2C_MST_TX_DATA ,Write data to transmit RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "I2C_MST_RX, I2C Master RX FIFO Control Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " I2C_MST_RX_DATA ,Read received data RESET:0x0"
          
wgroup.long 0x18++0x3
    line.long 0x00 "I2C_MST_CMD, I2C Master COMMAND Register - a combination of bits generates the according command RESET:0x0"
         bitfld.long 0x00 0. " I2C_MST_CMD_START ,generate START - combined with WRITE and address with rwn-bit8 set 0:w 1:r RESET:0x0"
          
         bitfld.long 0x00 1. " I2C_MST_CMD_STOP ,generate STOP RESET:0x0"
          
         bitfld.long 0x00 2. " I2C_MST_CMD_READ ,read next byte from slave, when in read mode - combine with STOP|NACK RESET:0x0"
          
         bitfld.long 0x00 3. " I2C_MST_CMD_WRITE ,write address or write next byte RESET:0x0"
          
         bitfld.long 0x00 4. " I2C_MST_CMD_NACK ,generate an NACK, when in read mode RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "I2C_MST_CLK_PRESCALER, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " I2C_MST_CLK_PRESCALER_DATA ,must be (clk/(5*scl_clk))-1 RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "I2C_MST_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev) RESET:0x0"
         bitfld.long 0x00 0. " I2C_MST_IRQ_STATUS_SET_ACK ,Set irq_status.ack. RESET:0x0"
          
         bitfld.long 0x00 1. " I2C_MST_IRQ_STATUS_SET_NACK ,Set irq_status.nack. RESET:0x0"
          
         bitfld.long 0x00 2. " I2C_MST_IRQ_STATUS_SET_STOP ,Set irq_status.stop. RESET:0x0"
          
         bitfld.long 0x00 3. " I2C_MST_IRQ_STATUS_SET_ARBLOST ,Set irq_status.arblost. RESET:0x0"
          
tree.end
    

tree "UART"
base e:0x40048000
width 80.
tree.end

tree "UART__CMSDK_APB_UART_REGISTER_ADDRESSBLOCK"
base e:0x40048000
width 80.
group.long  0x0++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_DATA, Data Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_DATA_DATA ,Read/Write data RESET:0x0"
          
          
group.long  0x4++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_STATE, Status Register RESET:0x0"
         bitfld.long 0x00 0. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_STATE_TX_BUFFER_FULL ,TX Buffer full RESET:0x0"
          
         bitfld.long 0x00 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_STATE_RX_BUFFER_FULL ,RX Buffer full RESET:0x0"
          
         bitfld.long 0x00 2. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_STATE_TX_BUFFER_OVERRUN ,TX Buffer overrun RESET:0x0"
          
         bitfld.long 0x00 3. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_STATE_RX_BUFFER_OVERRUN ,RX Buffer overrun status RESET:0x0"
          
          
group.long  0x8++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CTRL, Control Register RESET:0x0"
         bitfld.long 0x00 0. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CTRL_TX_EN ,TX Enable RESET:0x0"
          
         bitfld.long 0x00 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CTRL_RX_EN ,RX Enable RESET:0x0"
          
         bitfld.long 0x00 2. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CTRL_TX_INT_EN ,TX interrupt enable RESET:0x0"
          
         bitfld.long 0x00 3. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CTRL_RX_INT_EN ,RX interrupt enable RESET:0x0"
          
         bitfld.long 0x00 4. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CTRL_TX_OVERRUN_INT_EN ,TX Buffer overrun interrupt enable RESET:0x0"
          
         bitfld.long 0x00 5. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CTRL_RX_OVERRUN_INT_EN ,RX Buffer overrun interrupt enable RESET:0x0"
          
         bitfld.long 0x00 6. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CTRL_TX_HIGH_SPEED_TEST_MODE_EN ,High-speed test mode for TX only RESET:0x0"
          
          
group.long  0xc++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_INTSTATUS, Interrupt Status Register RESET:0x0"
         bitfld.long 0x00 0. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_INTSTATUS_TX_INT ,TX interrupt status RESET:0x0"
          
         bitfld.long 0x00 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_INTSTATUS_RX_INT ,RX interrupt status RESET:0x0"
          
         bitfld.long 0x00 2. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_INTSTATUS_TX_OVERRUN_INT ,TX Buffer overrun interrupt status RESET:0x0"
          
         bitfld.long 0x00 3. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_INTSTATUS_RX_OVERRUN_INT ,rx buffer overrun interrupt status RESET:0x0"
          
          
group.long  0x10++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_BAUDDIV, Baudrate Control Register RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_BAUDDIV_BAUD_RATE ,Minimum value is 16 RESET:0x0"
          
          
rgroup.long 0xfd0++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID4, Peripheral ID Register 4 RESET:0x4"
         hexmask.long 0x00 0.--3. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID4_JEP106_C_CODE ,jep106_c_code RESET:0x4"
          
         hexmask.long 0x00 4.--7. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID4_BLOCK_COUNT ,4KB block count RESET:0x0"
          
          
rgroup.long 0xfd4++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID5, Peripheral ID Register 5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID5_PID5 ,Peripheral ID Register 5 RESET:0x0"
          
          
rgroup.long 0xfd8++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID6, Peripheral ID Register 6 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID6_PID6 ,Peripheral ID Register 6 RESET:0x0"
          
          
rgroup.long 0xfdc++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID7, Peripheral ID Register 7 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID7_PID7 ,Peripheral ID Register 7 RESET:0x0"
          
          
rgroup.long 0xfe0++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID0, Peripheral ID Register 0 RESET:0x21"
         hexmask.long 0x00 0.--7. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID0_PART_NUM ,Part number[7:0] RESET:0x21"
          
          
rgroup.long 0xfe4++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID1, Peripheral ID Register 1 RESET:0xb8"
         hexmask.long 0x00 0.--3. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID1_PART_NUM ,Part number[11:8] RESET:0x8"
          
         hexmask.long 0x00 4.--7. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID1_JEP106_ID_3_0 ,jep106_id_3_0 RESET:0xb"
          
          
rgroup.long 0xfe8++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID2, Peripheral ID Register 2 RESET:0x1b"
         hexmask.long 0x00 0.--2. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID2_JEP106_ID_6_4 ,jep106_id_6_4 RESET:0x3"
          
         bitfld.long 0x00 3. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID2_JEDEC_USED ,jedec_used RESET:0x1"
          
         hexmask.long 0x00 4.--7. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID2_REVISION_NUM ,Revision RESET:0x1"
          
          
rgroup.long 0xfec++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID3, Peripheral ID Register 3 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID3_CUSTOMER_MOD_NUM ,Customer Modification Number RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_PID3_ECO_REV_NUM ,ECO revision number RESET:0x0"
          
          
rgroup.long 0xff0++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CID0, Component ID Register 0 RESET:0xd"
         hexmask.long 0x00 0.--7. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CID0_CID0 ,Component ID Register 0 RESET:0xd"
          
          
rgroup.long 0xff4++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CID1, Component ID Register 1 RESET:0xf0"
         hexmask.long 0x00 0.--7. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CID1_CID1 ,Component ID Register 1 RESET:0xf0"
          
          
rgroup.long 0xff8++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CID2, Component ID Register 2 RESET:0x5"
         hexmask.long 0x00 0.--7. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CID2_CID2 ,Component ID Register 2 RESET:0x5"
          
          
rgroup.long 0xffc++0x3
    line.long 0x00 "UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CID3, Component ID Register 3 RESET:0xb1"
         hexmask.long 0x00 0.--7. 1. " UART_CMSDK_APB_UART_REGISTER_ADDRESSBLOCK_CID3_CID3 ,Component ID Register 3 RESET:0xb1"
          
          
tree.end
    

tree "DUALTIMER1"
base e:0x40050000
width 80.
tree.end

tree "DUALTIMER1__ADDRESSBLOCK0"
base e:0x40050000
width 80.
group.long  0x0++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMER1LOAD, Contains the value from which the Timer 1 counter is to decrement. This is the value used to reload the counter when Periodic mode is enabled, and the current count reaches 0. When this register is written to directly, the current count is immediately reset to the new value. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMER1LOAD_TIMER1LOAD ,Timer 1 Load value. A write sets the current value RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMER1VALUE, This register provides the current value of the Timer 1 decrementing counter. RESET:0xffffffff"
         hexmask.long 0x00 0.--31. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMER1VALUE_VALUE ,Timer 1 Current value RESET:0xffffffff"
          
group.long  0x8++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMER1CONTROL, This is a read or write register RESET:0x20"
         bitfld.long 0x00 0. " DUALTIMER1_ADDRESSBLOCK0_TIMER1CONTROL_ONESHOTCOUNT ,Selects one-shot or wrapping counter mode (default 0, wrapping) RESET:0x0" "ONESHOTCOUNT_0X0-0,ONESHOTCOUNT_0X1-1"
          
         bitfld.long 0x00 1. " DUALTIMER1_ADDRESSBLOCK0_TIMER1CONTROL_TIMERSIZE ,Selects 16-bit or 32-bit counter operation (default 0, 16-bit) RESET:0x0" "TIMERSIZE_0X0-0,TIMERSIZE_0X1-1"
          
         bitfld.long 0x00 2.--3. " DUALTIMER1_ADDRESSBLOCK0_TIMER1CONTROL_TIMERPRE ,Prescale bits (default 00, 0 stages of prescale, clock is divided by 1) RESET:0x0" "TIMERPRE_0X0-0,TIMERPRE_0X1-1,TIMERPRE_0X2-2,TIMERPRE_0X3-3"
          
          
         bitfld.long 0x00 5. " DUALTIMER1_ADDRESSBLOCK0_TIMER1CONTROL_INTERRUPTENABLE ,Interrupt enable bit (default 1, enabled) RESET:0x1" "INTERRUPT_DISABLE-0,INTERRUPT_ENABLE-1"
          
         bitfld.long 0x00 6. " DUALTIMER1_ADDRESSBLOCK0_TIMER1CONTROL_TIMERMODE ,Timer mode bit (default 0, free-running) RESET:0x0" "TIMERMODE_0X0-0,TIMERMODE_0X1-1"
          
         bitfld.long 0x00 7. " DUALTIMER1_ADDRESSBLOCK0_TIMER1CONTROL_TIMERENABLE ,Timer enable bit (default 0, disabled) RESET:0x0" "TIMER_DISABLE-0,TIMER_ENABLE-1"
          
          
group.long  0xc++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMER1INTCLR, A write to the this register clears the interrupt output from Timer 1 counter RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER1_ADDRESSBLOCK0_TIMER1INTCLR_TIMER1INTCLR ,Timer 1 Interrupt clear RESET:0x0"
          
          
rgroup.long 0x10++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMER1RIS, This register indicates the raw interrupt status from Timer 1 counter. This value is ANDed with the Interrupt enable bit from Timer 1 Control Register to create the masked interrupt, that is passed to the Timer 1 Interrupt output pin. RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER1_ADDRESSBLOCK0_TIMER1RIS_RAWTIMERINTERRUPT ,Timer 1 Raw interrupt status from the counter RESET:0x0" "TIMER1RIS_DISABLED-0,TIMER1RIS_ENABLED-1"
          
          
rgroup.long 0x14++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMER1MIS, This register indicates the masked interrupt status from Timer 1 counter. This value is the logical AND of the Raw interrupt status with the Timer interrupt enable bit from Timer 1 Timer Control Register, and is the same value that is passed to the Timer 1 Interrupt output pin. RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER1_ADDRESSBLOCK0_TIMER1MIS_TIMERINTERRUPT ,Timer 1 Enabled interrupt status from the counter RESET:0x0" "TIMER1MIS_DISABLED-0,TIMER1MIS_ENABLED-1"
          
          
group.long  0x18++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMER1BGLOAD, This register contains the value from which Timer 1 counter is to decrement. This is the value used to reload the Timer 1 counter when Periodic mode is enabled, and the current count reaches 0. This register provides an alternative method of accessing Timer 1 Load value register. The difference is that writes to this register do not cause Timer 1 counter to immediately restart from the new value. Reading from this register returns the same value returned from Timer 1 Load value. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMER1BGLOAD_TIMER1BGLOAD ,Timer 1 Background load value. A write does not cause Timer 1 counter to immediately restart from the new value. RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMER2LOAD, Contains the value from which the Timer 2 counter is to decrement. This is the value used to reload the counter when Periodic mode is enabled, and the current count reaches 0. When this register is written to directly, the current count is immediately reset to the new value. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMER2LOAD_TIMER2LOAD ,Timer 2 Load value. A write sets the current value RESET:0x0"
          
rgroup.long 0x24++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMER2VALUE, This register provides the current value of the Timer 2 decrementing counter. RESET:0xffffffff"
         hexmask.long 0x00 0.--31. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMER2VALUE_VALUE ,Timer 2 Current value RESET:0xffffffff"
          
group.long  0x28++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMER2CONTROL, This is a read or write register RESET:0x20"
         bitfld.long 0x00 0. " DUALTIMER1_ADDRESSBLOCK0_TIMER2CONTROL_ONESHOTCOUNT ,Selects one-shot or wrapping counter mode (default 0, wrapping) RESET:0x0" "ONESHOTCOUNT_0X0-0,ONESHOTCOUNT_0X1-1"
          
         bitfld.long 0x00 1. " DUALTIMER1_ADDRESSBLOCK0_TIMER2CONTROL_TIMERSIZE ,Selects 16-bit or 32-bit counter operation (default 0, 16-bit) RESET:0x0" "TIMERSIZE_0X0-0,TIMERSIZE_0X1-1"
          
         bitfld.long 0x00 2.--3. " DUALTIMER1_ADDRESSBLOCK0_TIMER2CONTROL_TIMERPRE ,Prescale bits (default 00, 0 stages of prescale, clock is divided by 1) RESET:0x0" "TIMERPRE_0X0-0,TIMERPRE_0X1-1,TIMERPRE_0X2-2,TIMERPRE_0X3-3"
          
          
         bitfld.long 0x00 5. " DUALTIMER1_ADDRESSBLOCK0_TIMER2CONTROL_INTERRUPTENABLE ,Interrupt enable bit (default 1, enabled) RESET:0x1" "INTERRUPT_DISABLE-0,INTERRUPT_ENABLE-1"
          
         bitfld.long 0x00 6. " DUALTIMER1_ADDRESSBLOCK0_TIMER2CONTROL_TIMERMODE ,Timer mode bit (default 0, free-running) RESET:0x0" "TIMERMODE_0X0-0,TIMERMODE_0X1-1"
          
         bitfld.long 0x00 7. " DUALTIMER1_ADDRESSBLOCK0_TIMER2CONTROL_TIMERENABLE ,Timer enable bit (default 0, disabled) RESET:0x0" "TIMER_DISABLE-0,TIMER_ENABLE-1"
          
          
group.long  0x2c++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMER2INTCLR, A write to the this register clears the interrupt output from Timer 2 counter RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER1_ADDRESSBLOCK0_TIMER2INTCLR_TIMER2INTCLR ,Timer 2 Interrupt clear RESET:0x0"
          
          
rgroup.long 0x30++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMER2RIS, This register indicates the raw interrupt status from Timer 2 counter. This value is ANDed with the Interrupt enable bit from Timer 2 Control Register to create the masked interrupt, that is passed to the Timer 2 Interrupt output pin. RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER1_ADDRESSBLOCK0_TIMER2RIS_RAWTIMERINTERRUPT ,Timer 2 Raw interrupt status from the counter RESET:0x0" "TIMER2RIS_DISABLED-0,TIMER2RIS_ENABLED-1"
          
          
rgroup.long 0x34++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMER2MIS, This register indicates the masked interrupt status from Timer 2 counter. This value is the logical AND of the Raw interrupt status with the Timer interrupt enable bit from Timer 2 Timer Control Register, and is the same value that is passed to the Timer 2 Interrupt output pin. RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER1_ADDRESSBLOCK0_TIMER2MIS_TIMERINTERRUPT ,Timer 2 Enabled interrupt status from the counter RESET:0x0" "TIMER2MIS_DISABLED-0,TIMER2MIS_ENABLED-1"
          
          
group.long  0x38++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMER2BGLOAD, This register contains the value from which Timer 2 counter is to decrement. This is the value used to reload the Timer 2 counter when Periodic mode is enabled, and the current count reaches 0. This register provides an alternative method of accessing Timer 2 Load value register. The difference is that writes to this register do not cause Timer 2 counter to immediately restart from the new value. Reading from this register returns the same value returned from Timer 2 Load value. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMER2BGLOAD_TIMER2BGLOAD ,Timer 2 Background load value. A write does not cause the counter to immediately restart from the new value RESET:0x0"
          
group.long  0xf00++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMERITCR, This register enables Integration test mode. When in this mode, the Integration test output set register directly controls the masked interrupt outputs. The combined interrupt output of Timer 1 and Timer 2 then becomes the logical OR of the interrupt values set in the Integration test output set register. RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER1_ADDRESSBLOCK0_TIMERITCR_INTEGRATIONTESTMODEENABLE ,When set high places dualtimers into Integration test mode. RESET:0x0" "TESTMODE_DISABLE-0,TESTMODE_ENABLE-1"
          
          
group.long  0xf04++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMERITOP, When in Integration test mode, the values in this write-only register directly drive the enabled interrupt outputs of Timer 1 and Timer 2. RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER1_ADDRESSBLOCK0_TIMERITOP_INTEGRATIONTESTTIMINT1VALUE ,Value output on Timer 1 Interrupt, TIMINT1, when in Integration test mode RESET:0x0"
          
         bitfld.long 0x00 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERITOP_INTEGRATIONTESTTIMINT2VALUE ,Value output on Timer 2 Interrupt, TIMINT2, when in Integration test mode RESET:0x0"
          
          
rgroup.long 0xfd0++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID4, Peripheral identification register 4 RESET:0x4"
         hexmask.long 0x00 0.--3. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID4_JEP106_C_CODE ,jep106_c_code RESET:0x4"
          
         hexmask.long 0x00 4.--7. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID4_BLOCK_COUNT ,Block count RESET:0x0"
          
          
rgroup.long 0xfd4++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID5, Peripheral identification register 5 (unused) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID5_TIMERPERIPHID5 ,Peripheral identification register 5 RESET:0x0"
          
          
rgroup.long 0xfd8++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID6, Peripheral identification register 6 (unused) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID6_TIMERPERIPHID6 ,Peripheral identification register 6 RESET:0x0"
          
          
rgroup.long 0xfdc++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID7, Peripheral identification register 7 (unused) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID7_TIMERPERIPHID7 ,Peripheral identification register 7 RESET:0x0"
          
          
rgroup.long 0xfe0++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID0, Peripheral identification register 0 RESET:0x23"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID0_TIMERPERIPHID0 ,Part number[7:0] RESET:0x23"
          
          
rgroup.long 0xfe4++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID1, Peripheral identification register 1 RESET:0xb8"
         hexmask.long 0x00 0.--3. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID1_PART_NUMBER_11_8 ,Part number[11:8] RESET:0x8"
          
         hexmask.long 0x00 4.--7. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID1_JEP106_ID_3_0 ,jep106_id_3_0 RESET:0xb"
          
          
rgroup.long 0xfe8++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID2, Peripheral identification register 2 RESET:0x1b"
         hexmask.long 0x00 0.--2. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID2_JEP106_ID_6_4 ,jep106_id_6_4 RESET:0x3"
          
         bitfld.long 0x00 3. " DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID2_JEDEC_USED ,jedec_used RESET:0x1"
          
         hexmask.long 0x00 4.--7. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID2_REVISION ,Revision RESET:0x1"
          
          
rgroup.long 0xfec++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID3, Peripheral identification register 3 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID3_CUST_MOD_NUM ,Customer modification number RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPERIPHID3_ECO_REV_NUM ,ECO revision number RESET:0x0"
          
          
rgroup.long 0xff0++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMERPCELLID0, Component identification register 0 RESET:0xd"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPCELLID0_TIMERPCELLID0 ,Component identification register 0 RESET:0xd"
          
          
rgroup.long 0xff4++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMERPCELLID1, Component identification register 1 RESET:0xf0"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPCELLID1_TIMERPCELLID1 ,Component identification register 1 RESET:0xf0"
          
          
rgroup.long 0xff8++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMERPCELLID2, Component identification register 2 RESET:0x5"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPCELLID2_TIMERPCELLID2 ,Component identification register 2 RESET:0x5"
          
          
rgroup.long 0xffc++0x3
    line.long 0x00 "DUALTIMER1_ADDRESSBLOCK0_TIMERPCELLID3, Component identification register 3 RESET:0xb1"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER1_ADDRESSBLOCK0_TIMERPCELLID3_TIMERPCELLID3 ,Component identification register 3 RESET:0xb1"
          
          
tree.end
    

tree "DUALTIMER2"
base e:0x40051000
width 80.
tree.end

tree "DUALTIMER2__ADDRESSBLOCK0"
base e:0x40051000
width 80.
group.long  0x0++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMER1LOAD, Contains the value from which the Timer 1 counter is to decrement. This is the value used to reload the counter when Periodic mode is enabled, and the current count reaches 0. When this register is written to directly, the current count is immediately reset to the new value. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMER1LOAD_TIMER1LOAD ,Timer 1 Load value. A write sets the current value RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMER1VALUE, This register provides the current value of the Timer 1 decrementing counter. RESET:0xffffffff"
         hexmask.long 0x00 0.--31. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMER1VALUE_VALUE ,Timer 1 Current value RESET:0xffffffff"
          
group.long  0x8++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMER1CONTROL, This is a read or write register RESET:0x20"
         bitfld.long 0x00 0. " DUALTIMER2_ADDRESSBLOCK0_TIMER1CONTROL_ONESHOTCOUNT ,Selects one-shot or wrapping counter mode (default 0, wrapping) RESET:0x0" "ONESHOTCOUNT_0X0-0,ONESHOTCOUNT_0X1-1"
          
         bitfld.long 0x00 1. " DUALTIMER2_ADDRESSBLOCK0_TIMER1CONTROL_TIMERSIZE ,Selects 16-bit or 32-bit counter operation (default 0, 16-bit) RESET:0x0" "TIMERSIZE_0X0-0,TIMERSIZE_0X1-1"
          
         bitfld.long 0x00 2.--3. " DUALTIMER2_ADDRESSBLOCK0_TIMER1CONTROL_TIMERPRE ,Prescale bits (default 00, 0 stages of prescale, clock is divided by 1) RESET:0x0" "TIMERPRE_0X0-0,TIMERPRE_0X1-1,TIMERPRE_0X2-2,TIMERPRE_0X3-3"
          
          
         bitfld.long 0x00 5. " DUALTIMER2_ADDRESSBLOCK0_TIMER1CONTROL_INTERRUPTENABLE ,Interrupt enable bit (default 1, enabled) RESET:0x1" "INTERRUPT_DISABLE-0,INTERRUPT_ENABLE-1"
          
         bitfld.long 0x00 6. " DUALTIMER2_ADDRESSBLOCK0_TIMER1CONTROL_TIMERMODE ,Timer mode bit (default 0, free-running) RESET:0x0" "TIMERMODE_0X0-0,TIMERMODE_0X1-1"
          
         bitfld.long 0x00 7. " DUALTIMER2_ADDRESSBLOCK0_TIMER1CONTROL_TIMERENABLE ,Timer enable bit (default 0, disabled) RESET:0x0" "TIMER_DISABLE-0,TIMER_ENABLE-1"
          
          
group.long  0xc++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMER1INTCLR, A write to the this register clears the interrupt output from Timer 1 counter RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER2_ADDRESSBLOCK0_TIMER1INTCLR_TIMER1INTCLR ,Timer 1 Interrupt clear RESET:0x0"
          
          
rgroup.long 0x10++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMER1RIS, This register indicates the raw interrupt status from Timer 1 counter. This value is ANDed with the Interrupt enable bit from Timer 1 Control Register to create the masked interrupt, that is passed to the Timer 1 Interrupt output pin. RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER2_ADDRESSBLOCK0_TIMER1RIS_RAWTIMERINTERRUPT ,Timer 1 Raw interrupt status from the counter RESET:0x0" "TIMER1RIS_DISABLED-0,TIMER1RIS_ENABLED-1"
          
          
rgroup.long 0x14++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMER1MIS, This register indicates the masked interrupt status from Timer 1 counter. This value is the logical AND of the Raw interrupt status with the Timer interrupt enable bit from Timer 1 Timer Control Register, and is the same value that is passed to the Timer 1 Interrupt output pin. RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER2_ADDRESSBLOCK0_TIMER1MIS_TIMERINTERRUPT ,Timer 1 Enabled interrupt status from the counter RESET:0x0" "TIMER1MIS_DISABLED-0,TIMER1MIS_ENABLED-1"
          
          
group.long  0x18++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMER1BGLOAD, This register contains the value from which Timer 1 counter is to decrement. This is the value used to reload the Timer 1 counter when Periodic mode is enabled, and the current count reaches 0. This register provides an alternative method of accessing Timer 1 Load value register. The difference is that writes to this register do not cause Timer 1 counter to immediately restart from the new value. Reading from this register returns the same value returned from Timer 1 Load value. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMER1BGLOAD_TIMER1BGLOAD ,Timer 1 Background load value. A write does not cause Timer 1 counter to immediately restart from the new value. RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMER2LOAD, Contains the value from which the Timer 2 counter is to decrement. This is the value used to reload the counter when Periodic mode is enabled, and the current count reaches 0. When this register is written to directly, the current count is immediately reset to the new value. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMER2LOAD_TIMER2LOAD ,Timer 2 Load value. A write sets the current value RESET:0x0"
          
rgroup.long 0x24++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMER2VALUE, This register provides the current value of the Timer 2 decrementing counter. RESET:0xffffffff"
         hexmask.long 0x00 0.--31. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMER2VALUE_VALUE ,Timer 2 Current value RESET:0xffffffff"
          
group.long  0x28++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMER2CONTROL, This is a read or write register RESET:0x20"
         bitfld.long 0x00 0. " DUALTIMER2_ADDRESSBLOCK0_TIMER2CONTROL_ONESHOTCOUNT ,Selects one-shot or wrapping counter mode (default 0, wrapping) RESET:0x0" "ONESHOTCOUNT_0X0-0,ONESHOTCOUNT_0X1-1"
          
         bitfld.long 0x00 1. " DUALTIMER2_ADDRESSBLOCK0_TIMER2CONTROL_TIMERSIZE ,Selects 16-bit or 32-bit counter operation (default 0, 16-bit) RESET:0x0" "TIMERSIZE_0X0-0,TIMERSIZE_0X1-1"
          
         bitfld.long 0x00 2.--3. " DUALTIMER2_ADDRESSBLOCK0_TIMER2CONTROL_TIMERPRE ,Prescale bits (default 00, 0 stages of prescale, clock is divided by 1) RESET:0x0" "TIMERPRE_0X0-0,TIMERPRE_0X1-1,TIMERPRE_0X2-2,TIMERPRE_0X3-3"
          
          
         bitfld.long 0x00 5. " DUALTIMER2_ADDRESSBLOCK0_TIMER2CONTROL_INTERRUPTENABLE ,Interrupt enable bit (default 1, enabled) RESET:0x1" "INTERRUPT_DISABLE-0,INTERRUPT_ENABLE-1"
          
         bitfld.long 0x00 6. " DUALTIMER2_ADDRESSBLOCK0_TIMER2CONTROL_TIMERMODE ,Timer mode bit (default 0, free-running) RESET:0x0" "TIMERMODE_0X0-0,TIMERMODE_0X1-1"
          
         bitfld.long 0x00 7. " DUALTIMER2_ADDRESSBLOCK0_TIMER2CONTROL_TIMERENABLE ,Timer enable bit (default 0, disabled) RESET:0x0" "TIMER_DISABLE-0,TIMER_ENABLE-1"
          
          
group.long  0x2c++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMER2INTCLR, A write to the this register clears the interrupt output from Timer 2 counter RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER2_ADDRESSBLOCK0_TIMER2INTCLR_TIMER2INTCLR ,Timer 2 Interrupt clear RESET:0x0"
          
          
rgroup.long 0x30++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMER2RIS, This register indicates the raw interrupt status from Timer 2 counter. This value is ANDed with the Interrupt enable bit from Timer 2 Control Register to create the masked interrupt, that is passed to the Timer 2 Interrupt output pin. RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER2_ADDRESSBLOCK0_TIMER2RIS_RAWTIMERINTERRUPT ,Timer 2 Raw interrupt status from the counter RESET:0x0" "TIMER2RIS_DISABLED-0,TIMER2RIS_ENABLED-1"
          
          
rgroup.long 0x34++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMER2MIS, This register indicates the masked interrupt status from Timer 2 counter. This value is the logical AND of the Raw interrupt status with the Timer interrupt enable bit from Timer 2 Timer Control Register, and is the same value that is passed to the Timer 2 Interrupt output pin. RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER2_ADDRESSBLOCK0_TIMER2MIS_TIMERINTERRUPT ,Timer 2 Enabled interrupt status from the counter RESET:0x0" "TIMER2MIS_DISABLED-0,TIMER2MIS_ENABLED-1"
          
          
group.long  0x38++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMER2BGLOAD, This register contains the value from which Timer 2 counter is to decrement. This is the value used to reload the Timer 2 counter when Periodic mode is enabled, and the current count reaches 0. This register provides an alternative method of accessing Timer 2 Load value register. The difference is that writes to this register do not cause Timer 2 counter to immediately restart from the new value. Reading from this register returns the same value returned from Timer 2 Load value. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMER2BGLOAD_TIMER2BGLOAD ,Timer 2 Background load value. A write does not cause the counter to immediately restart from the new value RESET:0x0"
          
group.long  0xf00++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMERITCR, This register enables Integration test mode. When in this mode, the Integration test output set register directly controls the masked interrupt outputs. The combined interrupt output of Timer 1 and Timer 2 then becomes the logical OR of the interrupt values set in the Integration test output set register. RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER2_ADDRESSBLOCK0_TIMERITCR_INTEGRATIONTESTMODEENABLE ,When set high places dualtimers into Integration test mode. RESET:0x0" "TESTMODE_DISABLE-0,TESTMODE_ENABLE-1"
          
          
group.long  0xf04++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMERITOP, When in Integration test mode, the values in this write-only register directly drive the enabled interrupt outputs of Timer 1 and Timer 2. RESET:0x0"
         bitfld.long 0x00 0. " DUALTIMER2_ADDRESSBLOCK0_TIMERITOP_INTEGRATIONTESTTIMINT1VALUE ,Value output on Timer 1 Interrupt, TIMINT1, when in Integration test mode RESET:0x0"
          
         bitfld.long 0x00 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERITOP_INTEGRATIONTESTTIMINT2VALUE ,Value output on Timer 2 Interrupt, TIMINT2, when in Integration test mode RESET:0x0"
          
          
rgroup.long 0xfd0++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID4, Peripheral identification register 4 RESET:0x4"
         hexmask.long 0x00 0.--3. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID4_JEP106_C_CODE ,jep106_c_code RESET:0x4"
          
         hexmask.long 0x00 4.--7. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID4_BLOCK_COUNT ,Block count RESET:0x0"
          
          
rgroup.long 0xfd4++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID5, Peripheral identification register 5 (unused) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID5_TIMERPERIPHID5 ,Peripheral identification register 5 RESET:0x0"
          
          
rgroup.long 0xfd8++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID6, Peripheral identification register 6 (unused) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID6_TIMERPERIPHID6 ,Peripheral identification register 6 RESET:0x0"
          
          
rgroup.long 0xfdc++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID7, Peripheral identification register 7 (unused) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID7_TIMERPERIPHID7 ,Peripheral identification register 7 RESET:0x0"
          
          
rgroup.long 0xfe0++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID0, Peripheral identification register 0 RESET:0x23"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID0_TIMERPERIPHID0 ,Part number[7:0] RESET:0x23"
          
          
rgroup.long 0xfe4++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID1, Peripheral identification register 1 RESET:0xb8"
         hexmask.long 0x00 0.--3. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID1_PART_NUMBER_11_8 ,Part number[11:8] RESET:0x8"
          
         hexmask.long 0x00 4.--7. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID1_JEP106_ID_3_0 ,jep106_id_3_0 RESET:0xb"
          
          
rgroup.long 0xfe8++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID2, Peripheral identification register 2 RESET:0x1b"
         hexmask.long 0x00 0.--2. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID2_JEP106_ID_6_4 ,jep106_id_6_4 RESET:0x3"
          
         bitfld.long 0x00 3. " DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID2_JEDEC_USED ,jedec_used RESET:0x1"
          
         hexmask.long 0x00 4.--7. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID2_REVISION ,Revision RESET:0x1"
          
          
rgroup.long 0xfec++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID3, Peripheral identification register 3 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID3_CUST_MOD_NUM ,Customer modification number RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPERIPHID3_ECO_REV_NUM ,ECO revision number RESET:0x0"
          
          
rgroup.long 0xff0++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMERPCELLID0, Component identification register 0 RESET:0xd"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPCELLID0_TIMERPCELLID0 ,Component identification register 0 RESET:0xd"
          
          
rgroup.long 0xff4++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMERPCELLID1, Component identification register 1 RESET:0xf0"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPCELLID1_TIMERPCELLID1 ,Component identification register 1 RESET:0xf0"
          
          
rgroup.long 0xff8++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMERPCELLID2, Component identification register 2 RESET:0x5"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPCELLID2_TIMERPCELLID2 ,Component identification register 2 RESET:0x5"
          
          
rgroup.long 0xffc++0x3
    line.long 0x00 "DUALTIMER2_ADDRESSBLOCK0_TIMERPCELLID3, Component identification register 3 RESET:0xb1"
         hexmask.long 0x00 0.--7. 1. " DUALTIMER2_ADDRESSBLOCK0_TIMERPCELLID3_TIMERPCELLID3 ,Component identification register 3 RESET:0xb1"
          
          
tree.end
    

tree "WATCHDOG"
base e:0x40052000
width 80.
tree.end

tree "WATCHDOG__ADDRESSBLOCK0"
base e:0x40052000
width 80.
group.long  0x0++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGLOAD, Watchdog Load value register contains the value from which the counter is to decrement. When this register is written to the count is immediately restarted from the new value. The minimum valid value for WDOGLOAD is 1. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGLOAD_WDOGLOAD ,Watchdog Load value RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGVALUE, Watchdog Current value register gives the current value of the decrementing counter RESET:0xffffffff"
         hexmask.long 0x00 0.--31. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGVALUE_VALUE ,Watchdog Current value RESET:0xffffffff"
          
group.long  0x8++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGCONTROL, Watchdog Control register enables the software to control the watchdog unit RESET:0x0"
         bitfld.long 0x00 0. " WATCHDOG_ADDRESSBLOCK0_WDOGCONTROL_INTEN ,Interrupt enable (default 0, disable). Enable the interrupt output event. Set HIGH to enable the counter and the interrupt or LOW to disable the counter and interrupt. Reloads the counter from the load value when the interrupt is enabled after being disabled. RESET:0x0" "INTERRUPT_DISABLE-0,INTERRUPT_ENABLE-1"
          
         bitfld.long 0x00 1. " WATCHDOG_ADDRESSBLOCK0_WDOGCONTROL_RESEN ,Reset enable (default 0, disable). Enable watchdog reset output. Acts as a mask for the reset output. Set HIGH to enable the reset, or LOW to disable the reset. RESET:0x0" "RESET_DISABLE-0,RESET_ENABLE-1"
          
          
group.long  0xc++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGINTCLR, A write to this register clears the watchdog interrupt and reloads the counter from the value in WDOGLOAD RESET:0x0"
         bitfld.long 0x00 0. " WATCHDOG_ADDRESSBLOCK0_WDOGINTCLR_WDOGINTCLR ,Watchdog Interrupt clear RESET:0x0"
          
          
rgroup.long 0x10++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGRIS, Watchdog Raw interrupt status register indicates the raw interrupt status from the counter. This value is ANDed with the interrupt enable bit from the control register to create the masked interrupt that is passed to the interrupt output pin. RESET:0x0"
         bitfld.long 0x00 0. " WATCHDOG_ADDRESSBLOCK0_WDOGRIS_RAWWATCHDOGINTERRUPT ,Raw interrupt status from the counter RESET:0x0" "WDOGRIS_DISABLED-0,WDOGRIS_ENABLED-1"
          
          
rgroup.long 0x14++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGMIS, Watchdog Interrupt status register indicates the masked interrupt status from the counter. This value is the logical AND of the Raw interrupt status with the Interrupt enable bit from the Control register, and is the same value that is passed to the interrupt output pin. RESET:0x0"
         bitfld.long 0x00 0. " WATCHDOG_ADDRESSBLOCK0_WDOGMIS_WATCHDOGINTERRUPT ,Enabled interrupt status from the counter RESET:0x0" "WDOGMIS_DISABLED-0,WDOGMIS_ENABLED-1"
          
          
group.long  0xc00++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGLOCK, Watchdog Lock register disables write accesses to all other registers to prevent rogue software from disabling the watchdog functionality. A read from this register returns only the bottom bit. RESET:0x0"
         bitfld.long 0x00 0. " WATCHDOG_ADDRESSBLOCK0_WDOGLOCK_REGISTERWRITEENABLESTATUS ,Register write enable status (default 0, write access is enabled, not locked) RESET:0x0" "WRITE_ENABLED-0,WRITE_LOCKED-1"
          
         hexmask.long 0x00 1.--31. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGLOCK_ENABLEREGISTERWRITES ,Enable write access to all other registers by writing value '0x1ACCE551'. Disable write access by writing any other value. RESET:0x0"
          
group.long  0xf00++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGITCR, Watchdog Integration test control register enables integration test mode. When in this mode the test output register directly controls the masked interrupt output WDOGINT and reset output WDOGRES. RESET:0x0"
         bitfld.long 0x00 0. " WATCHDOG_ADDRESSBLOCK0_WDOGITCR_INTEGRATIONTESTMODEENABLE ,Integration test mode enable (default 0, disable). When set HIGH, places the watchdog into integration test mode. RESET:0x0" "TESTMODE_DISABLE-0,TESTMODE_ENABLE-1"
          
          
group.long  0xf04++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGITOP, Watchdog Integration test output set register values directly drive the enabled interrupt output and reset output when in Integration test mode. RESET:0x0"
         bitfld.long 0x00 0. " WATCHDOG_ADDRESSBLOCK0_WDOGITOP_INTEGRATIONTESTWGODRESVALUE ,Value output on WDOGRES when in Integration test mode RESET:0x0"
          
         bitfld.long 0x00 1. " WATCHDOG_ADDRESSBLOCK0_WDOGITOP_INTEGRATIONTESTWDOGINTVALUE ,Value output on WDOGINT when in Integration test mode RESET:0x0"
          
          
rgroup.long 0xfd0++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID4, Peripheral identification register 4 RESET:0x4"
         hexmask.long 0x00 0.--3. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID4_JEP106_C_CODE ,jep106_c_code RESET:0x4"
          
         hexmask.long 0x00 4.--7. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID4_BLOCKCOUNT ,Block count RESET:0x0"
          
          
rgroup.long 0xfd4++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID5, Peripheral identification register 5 (unused) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID5_WDOGPERIPHID5 ,Peripheral identification register 5 RESET:0x0"
          
          
rgroup.long 0xfd8++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID6, Peripheral identification register 6 (unused) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID6_WDOGPERIPHID6 ,Peripheral identification register 6 RESET:0x0"
          
          
rgroup.long 0xfdc++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID7, Peripheral identification register 7 (unused) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID7_WDOGPERIPHID7 ,Peripheral identification register 7 RESET:0x0"
          
          
rgroup.long 0xfe0++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID0, Peripheral identification register 0 RESET:0x24"
         hexmask.long 0x00 0.--7. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID0_WDOGPERIPHID0 ,Part number[7:0] RESET:0x24"
          
          
rgroup.long 0xfe4++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID1, Peripheral identification register 1 RESET:0xb8"
         hexmask.long 0x00 0.--3. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID1_PART_NUMBER_11_8 ,Part number[11:8] RESET:0x8"
          
         hexmask.long 0x00 4.--7. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID1_JEP106_ID_3_0 ,jep106_id_3_0 RESET:0xb"
          
          
rgroup.long 0xfe8++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID2, Peripheral identification register 2 RESET:0x1b"
         hexmask.long 0x00 0.--2. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID2_JEP106_ID_6_4 ,jep106_id_6_4 RESET:0x3"
          
         bitfld.long 0x00 3. " WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID2_JEDEC_USED ,jedec_used RESET:0x1"
          
         hexmask.long 0x00 4.--7. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID2_REVISION ,Revision RESET:0x1"
          
          
rgroup.long 0xfec++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID3, Peripheral identification register 3 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID3_CUSTOMERMODIFICATIONNUMBER ,Customer modification number RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPERIPHID3_ECOREVISIONNUMBER ,ECO revision number RESET:0x0"
          
          
rgroup.long 0xff0++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGPCELLID0, Watchdog Component identification register 0 RESET:0xd"
         hexmask.long 0x00 0.--7. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPCELLID0_WDOGPCELLID0 ,Watchdog Component identification register 0 RESET:0xd"
          
          
rgroup.long 0xff4++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGPCELLID1, Watchdog Component identification register 1 RESET:0xf0"
         hexmask.long 0x00 0.--7. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPCELLID1_WDOGPCELLID1 ,Watchdog Component identification register 1 RESET:0xf0"
          
          
rgroup.long 0xff8++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGPCELLID2, Watchdog Component identification register 2 RESET:0x5"
         hexmask.long 0x00 0.--7. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPCELLID2_WDOGPCELLID2 ,Watchdog Component identification register 2 RESET:0x5"
          
          
rgroup.long 0xffc++0x3
    line.long 0x00 "WATCHDOG_ADDRESSBLOCK0_WDOGPCELLID3, Watchdog Component identification register 3 RESET:0xb1"
         hexmask.long 0x00 0.--7. 1. " WATCHDOG_ADDRESSBLOCK0_WDOGPCELLID3_WDOGPCELLID3 ,Watchdog Component identification register 3 RESET:0xb1"
          
          
tree.end

tree "I2S_MST"
base e:0x40055000
width 80.
tree.end

tree "I2S_MST__I2S_MASTER"
base e:0x40055000
width 80.
group.long  0x0++0x3
    line.long 0x00 "I2S_MST_I2S_MASTER_CFG, Configuration for I2S master RESET:0x0"
         bitfld.long 0x00 0.--2. " I2S_MST_I2S_MASTER_CFG_MCLK_RATIO ,ratio between audio sample clock (fs/ws/lrck) and MCLK RESET:0x0" "MCLK_128-0,MCLK_192-1,MCLK_256-2,MCLK_384-3,MCLK_512-4"
          
         bitfld.long 0x00 3.--5. " I2S_MST_I2S_MASTER_CFG_BCLK_RATIO ,ratio between audio sample clock (fs/ws/lrck) and BCLK RESET:0x0" "BCLK__32-0,BCLK__48-1,BCLK__64-2,BCLK_128-3,BCLK_256-4"
          
         bitfld.long 0x00 6. " I2S_MST_I2S_MASTER_CFG_BCLK_POLARITY ,BCLK polarity 0: data valid on rising edge 1: data valid on falling edge RESET:0x0"
          
         bitfld.long 0x00 7. " I2S_MST_I2S_MASTER_CFG_LRCK_POLARITY ,LRCK polarity 0: FSYNC on rising edge 1: FSYNC on falling edge RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "I2S_MST_I2S_MASTER_CTRL, Control for I2S master RESET:0x0"
         bitfld.long 0x00 0. " I2S_MST_I2S_MASTER_CTRL_ENABLE ,enable I2S master output RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_MST_I2S_MASTER_CTRL_BUF_CLR ,clear buffers RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "I2S_MST_I2S_MASTER_STATUS, I2S master buffer state RESET:0x0"
         bitfld.long 0x00 0. " I2S_MST_I2S_MASTER_STATUS_BUF_READY ,buffer ready 1: buffer prefill done RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_MST_I2S_MASTER_STATUS_BUF_UNDERRUN ,buffer underflow write 1 to clear RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "I2S_MST_I2S_MASTER_IRQ_STATUS, I2S master IRQ status RESET:0x0"
         bitfld.long 0x00 0. " I2S_MST_I2S_MASTER_IRQ_STATUS_BUFFER_UNDERRUN ,IRQ status : buffer underrun; I2S master was reading from an empty audio buffer RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "I2S_MST_I2S_MASTER_IRQ_STATUS_ENABLE, I2S master IRQ status enable mask RESET:0x0"
         bitfld.long 0x00 0. " I2S_MST_I2S_MASTER_IRQ_STATUS_ENABLE_BUFFER_UNDERRUN ,IRQ enable : buffer underrun RESET:0x0"
          
wgroup.long 0x14++0x3
    line.long 0x00 "I2S_MST_I2S_MASTER_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev). RESET:0x0"
         bitfld.long 0x00 0. " I2S_MST_I2S_MASTER_IRQ_STATUS_SET_BUFFER_UNDERRUN ,Set irq_status.buffer_underrun RESET:0x0"
          
tree.end

tree "I2S_MST__RDMA"
base e:0x40055040
width 80.
group.long  0x0++0x3
    line.long 0x00 "I2S_MST_RDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " I2S_MST_RDMA_CTRL_ENABLE ,Global enable for the RDMA RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_MST_RDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next read will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " I2S_MST_RDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " I2S_MST_RDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
         bitfld.long 0x00 11. " I2S_MST_RDMA_CTRL_TERMINATE ,Manual termination of stream, concludes transaction and sends tlast. Self-clearing RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "I2S_MST_RDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " I2S_MST_RDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " I2S_MST_RDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "I2S_MST_RDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " I2S_MST_RDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " I2S_MST_RDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "I2S_MST_RDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " I2S_MST_RDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "I2S_MST_RDMA_SIZE1, SIZE1 interrupt triggers in case size1 byte have been read from the buffer / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " I2S_MST_RDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "I2S_MST_RDMA_CURR_ADDR, the current address of the DMA read pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " I2S_MST_RDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "I2S_MST_RDMA_IRQ_STATUS, interrupt status bits reflect the occurrence of an event / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " I2S_MST_RDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_MST_RDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " I2S_MST_RDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " I2S_MST_RDMA_IRQ_STATUS_UNFL ,Underflow: data towards AXI-4S is consumed faster than the DMA is able to read data from the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "I2S_MST_RDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " I2S_MST_RDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_MST_RDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " I2S_MST_RDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " I2S_MST_RDMA_IRQ_STATUS_ENABLE_UNFL ,Enable interrupt unfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "I2S_MST_RDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev) RESET:0x0"
         bitfld.long 0x00 0. " I2S_MST_RDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " I2S_MST_RDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " I2S_MST_RDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " I2S_MST_RDMA_IRQ_STATUS_SET_UNFL ,Set interrupt unfl RESET:0x0"
          
tree.end

tree "SPI_MST"
base e:0x40057000
width 80.
tree.end

tree "SPI_MST__WRAP"
base e:0x40057000
width 80.
group.long  0x0++0x3
    line.long 0x00 "SPI_MST_WRAP_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " SPI_MST_WRAP_CTRL_EN ,Enable SPI Master RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_WRAP_CTRL_CPHA ,CPHA RESET:0x0"
          
         bitfld.long 0x00 2. " SPI_MST_WRAP_CTRL_CPOL ,CPOL RESET:0x0"
          
         bitfld.long 0x00 3. " SPI_MST_WRAP_CTRL_STOP ,End of Transfer. Must be set when last byte to be transmitted is added to the TX FIFO RESET:0x0"
          
         bitfld.long 0x00 4.--5. " SPI_MST_WRAP_CTRL_MODE ,SPI communication mode - 00: DMA (default) - 01: APB_WDMA - 10: APB_RDMA - 11: APB RESET:0x0" "DMA-0,APB_WDMA-1,APB_RDMA-2,APB-3"
          
rgroup.long 0x4++0x3
    line.long 0x00 "SPI_MST_WRAP_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " SPI_MST_WRAP_STATUS_RX_NOT_EMPTY ,Status: RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_WRAP_STATUS_RX_FULL ,Status: RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " SPI_MST_WRAP_STATUS_TX_EMPTY ,Status: TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 3. " SPI_MST_WRAP_STATUS_TX_NOT_FULL ,Status: TX FIFO not full RESET:0x0"
          
         bitfld.long 0x00 4. " SPI_MST_WRAP_STATUS_RX_TLAST ,Status: RX Path, last byte was received RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "SPI_MST_WRAP_IRQ_STATUS_ENABLE, None RESET:0x0"
         bitfld.long 0x00 0. " SPI_MST_WRAP_IRQ_STATUS_ENABLE_RX_OVFL ,Enable IRQ for RX FIFO overflow RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_WRAP_IRQ_STATUS_ENABLE_RX_FULL ,Enable IRQ for RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " SPI_MST_WRAP_IRQ_STATUS_ENABLE_RX_NOT_EMPTY ,Enable IRQ for RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 3. " SPI_MST_WRAP_IRQ_STATUS_ENABLE_TX_EMPTY ,Enable IRQ for TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 4. " SPI_MST_WRAP_IRQ_STATUS_ENABLE_TX_NOT_FULL ,Enable IRQ for TX FIFO not full RESET:0x0"
          
         bitfld.long 0x00 5. " SPI_MST_WRAP_IRQ_STATUS_ENABLE_TX_DONE ,Enable IRQ for last byte TX/RX done RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "SPI_MST_WRAP_IRQ_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " SPI_MST_WRAP_IRQ_STATUS_RX_OVFL ,IRQ Status for RX FIFO overflow RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_WRAP_IRQ_STATUS_RX_FULL ,IRQ Status for RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " SPI_MST_WRAP_IRQ_STATUS_RX_NOT_EMPTY ,Enable IRQ for RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 3. " SPI_MST_WRAP_IRQ_STATUS_TX_EMPTY ,IRQ Status for TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 4. " SPI_MST_WRAP_IRQ_STATUS_TX_NOT_FULL ,IRQ Status for TX FIFO not full RESET:0x0"
          
         bitfld.long 0x00 5. " SPI_MST_WRAP_IRQ_STATUS_TX_DONE ,IRQ Status for last byte TX/RX done RESET:0x0"
          
wgroup.long 0x10++0x3
    line.long 0x00 "SPI_MST_WRAP_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev) (singlepulse) RESET:0x0"
         bitfld.long 0x00 0. " SPI_MST_WRAP_IRQ_STATUS_SET_RX_OVFL ,Set rx_ovfl irq RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_WRAP_IRQ_STATUS_SET_RX_FULL ,Set rx_full irq RESET:0x0"
          
         bitfld.long 0x00 2. " SPI_MST_WRAP_IRQ_STATUS_SET_RX_NOT_EMPTY ,Set rx_not_empty irq RESET:0x0"
          
         bitfld.long 0x00 3. " SPI_MST_WRAP_IRQ_STATUS_SET_TX_EMPTY ,Set tx_empty irq RESET:0x0"
          
         bitfld.long 0x00 4. " SPI_MST_WRAP_IRQ_STATUS_SET_TX_NOT_FULL ,Set tx_not_full irq RESET:0x0"
          
         bitfld.long 0x00 5. " SPI_MST_WRAP_IRQ_STATUS_SET_TX_DONE ,Set tx_done irq RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "SPI_MST_WRAP_SCLK_FREQ, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " SPI_MST_WRAP_SCLK_FREQ_TICKS ,Set clock ticks for half of SCLK_PERIOD. SCLK_FREQ = SPI_MST_CLK_FREQ/(2*(ticks+1)) RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "SPI_MST_WRAP_TX, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " SPI_MST_WRAP_TX_DATA ,Data to be added on TX FIFO RESET:0x0"
          
         bitfld.long 0x00 8. " SPI_MST_WRAP_TX_DATA_WTRIG ,Set wtrig signal to indicate data is valid (singlepulse first check on none full tx_fifo!!!) RESET:0x0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "SPI_MST_WRAP_RX, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " SPI_MST_WRAP_RX_DATA ,Data to be read from the RX FIFO. Data is not consumed on read. Use RX_FIFO register to consume/clear RX FIFO RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "SPI_MST_WRAP_RX_FIFO, None RESET:0x0"
         bitfld.long 0x00 0. " SPI_MST_WRAP_RX_FIFO_POP ,Consume one item on RX FIFO (singlepulse) RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_WRAP_RX_FIFO_RX_FLUSH ,Flush RX FIFO (constant enable) RESET:0x0"
          
tree.end

tree "SPI_MST__QSPI"
base e:0x40057040
width 80.
group.long  0x0++0x3
    line.long 0x00 "SPI_MST_QSPI_CFG_ITF, Configuration for (Q)SPI master interface RESET:0x40"
         bitfld.long 0x00 0.--1. " SPI_MST_QSPI_CFG_ITF_SPI_MODE ,SPI interface mode - 00: 1 bit SPI (single SPI) (default) - 01: 2 bit SPI (dual SPI) - 10: 4 bit SPI (quad SPI) - 11: reserved RESET:0x0" "SNGL_SPI-0,DUAL_SPI-1,QUAD_SPI-2"
          
         bitfld.long 0x00 2. " SPI_MST_QSPI_CFG_ITF_CPHA ,SPI clock phase - 0: change data on falling egde, sample data on rising  edge (default) - 1: change data on rising  egde, sample data on falling edge RESET:0x0"
          
         bitfld.long 0x00 3. " SPI_MST_QSPI_CFG_ITF_CPOL ,SPI clock polarity - 0: clock in idle state is low (default) - 1: clock in idle state is high RESET:0x0"
          
         bitfld.long 0x00 4.--5. " SPI_MST_QSPI_CFG_ITF_MOSI_SEL ,select QSPI data port for SPI MOSI (output) in single SPI mode - 0: MOSI[0] (default) - 1: MOSI[1] - 2: MOSI[2] - 3: MOSI[3] RESET:0x0" "MOSI_0-0,MOSI_1-1,MOSI_2-2,MOSI_3-3"
          
         bitfld.long 0x00 6.--7. " SPI_MST_QSPI_CFG_ITF_MISO_SEL ,select QSPI data port for SPI MISO (input) in single SPI mode - 0: MISO[0] - 1: MISO[1] (default) - 2: MISO[2] - 3: MISO[3] RESET:0x1" "MISO_0-0,MISO_1-1,MISO_2-2,MISO_3-3"
          
group.long  0x4++0x3
    line.long 0x00 "SPI_MST_QSPI_CFG_SCLK, Configuration for SPI clock RESET:0x10001"
         hexmask.long 0x00 0.--7. 1. " SPI_MST_QSPI_CFG_SCLK_CDIV ,SPI clock divider SPI clock[freq] = sys_clk / (2*(cdiv+1))     duty cycle is 50% RESET:0x1"
          
         hexmask.long 0x00 16.--24. 1. " SPI_MST_QSPI_CFG_SCLK_SMPL_POINT ,sample point - [8]   : SPI clock high/low - [7:0] : clk_div_phase example: sample at rising edge: [8]   = 0 [7:0] = cdiv RESET:0x1"
          
group.long  0x8++0x3
    line.long 0x00 "SPI_MST_QSPI_CFG_SS_TIMING, configure SPI slave select timing RESET:0x100"
         hexmask.long 0x00 0.--3. 1. " SPI_MST_QSPI_CFG_SS_TIMING_SETUP ,setup time, time from falling edge of 'slave select' to first active SPI clock edge, number of SPI clock periods, values 0-15 (default = 0) RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " SPI_MST_QSPI_CFG_SS_TIMING_HOLD ,hold time, time from last active SPI clock edge to rising edge of 'slave select', number of SPI clock periods, values 0-15 (default = 0) RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " SPI_MST_QSPI_CFG_SS_TIMING_INACTIVE ,minimum inactive time (inter transaction gap), SPI slave select is high for minimum this period between transactions, number of SPI clock periods, values 0-15 (default = 1) RESET:0x1"
          
group.long  0xc++0x3
    line.long 0x00 "SPI_MST_QSPI_CTRL, (Q)SPI master control RESET:0x0"
         bitfld.long 0x00 0. " SPI_MST_QSPI_CTRL_RESTART ,Restart (Q)SPI master interface (single pulse / self clearing) reset state and flush buffers RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "SPI_MST_QSPI_EXT_SS_CTRL, (Q)SPI slave select control RESET:0x2"
         bitfld.long 0x00 0. " SPI_MST_QSPI_EXT_SS_CTRL_ENABLE ,enable external slave select RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_QSPI_EXT_SS_CTRL_VALUE ,value of external slave select 0: low 1: high (default) RESET:0x1"
          
rgroup.long 0x14++0x3
    line.long 0x00 "SPI_MST_QSPI_STATUS, (Q)SPI state RESET:0x0"
         bitfld.long 0x00 0.--2. " SPI_MST_QSPI_STATUS_STATE ,FSM state of (Q)SPI master RESET:0x0" "IDLE-0,SS_SETUP-1,SS_HOLD-2,SS_INACTIVE-3,SHIFTING-4,SHIFT_LAST_WORD-5,WAIT-6,FINISH_TRANSFER-7"
          
tree.end

tree "SPI_MST__WDMA"
base e:0x40057080
width 80.
group.long  0x0++0x3
    line.long 0x00 "SPI_MST_WDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " SPI_MST_WDMA_CTRL_ENABLE ,Global enable for the WDMA RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_WDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next write will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " SPI_MST_WDMA_CTRL_ADDR_DECREMENT ,When = 1, address is decremented in the AXI master RESET:0x0"
          
         bitfld.long 0x00 3. " SPI_MST_WDMA_CTRL_CONT_MODE ,Enables continuous mode if set to 1, transmission is finalized, if HW signals last access RESET:0x0"
          
         bitfld.long 0x00 4. " SPI_MST_WDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 5.--12. 1. " SPI_MST_WDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "SPI_MST_WDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " SPI_MST_WDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " SPI_MST_WDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "SPI_MST_WDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " SPI_MST_WDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " SPI_MST_WDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "SPI_MST_WDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " SPI_MST_WDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "SPI_MST_WDMA_SIZE1, SIZE1 interrupt triggers in case buffer is filled with size1 byte / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " SPI_MST_WDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "SPI_MST_WDMA_CURR_ADDR, the current address of the DMA write pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " SPI_MST_WDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "SPI_MST_WDMA_IRQ_STATUS, interrupt status bits / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " SPI_MST_WDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_WDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " SPI_MST_WDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " SPI_MST_WDMA_IRQ_STATUS_OVFL ,Overflow: data from AXI-4S is coming too fast to be written to the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "SPI_MST_WDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " SPI_MST_WDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_WDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " SPI_MST_WDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " SPI_MST_WDMA_IRQ_STATUS_ENABLE_OVFL ,Enable interrupt ovfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "SPI_MST_WDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to force an interrupt event (used for Software debugging or integration testing) RESET:0x0"
         bitfld.long 0x00 0. " SPI_MST_WDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize for one cycle RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_WDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 for one cycle RESET:0x0"
          
         bitfld.long 0x00 2. " SPI_MST_WDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr for one cycle RESET:0x0"
          
         bitfld.long 0x00 3. " SPI_MST_WDMA_IRQ_STATUS_SET_OVFL ,Set interrupt ovfl for one cycle RESET:0x0"
          
tree.end

tree "SPI_MST__RDMA"
base e:0x400570c0
width 80.
group.long  0x0++0x3
    line.long 0x00 "SPI_MST_RDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " SPI_MST_RDMA_CTRL_ENABLE ,Global enable for the RDMA RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_RDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next read will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " SPI_MST_RDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " SPI_MST_RDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
         bitfld.long 0x00 11. " SPI_MST_RDMA_CTRL_TERMINATE ,Manual termination of stream, concludes transaction and sends tlast. Self-clearing RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "SPI_MST_RDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " SPI_MST_RDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " SPI_MST_RDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "SPI_MST_RDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " SPI_MST_RDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " SPI_MST_RDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "SPI_MST_RDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " SPI_MST_RDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "SPI_MST_RDMA_SIZE1, SIZE1 interrupt triggers in case size1 byte have been read from the buffer / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " SPI_MST_RDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "SPI_MST_RDMA_CURR_ADDR, the current address of the DMA read pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " SPI_MST_RDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "SPI_MST_RDMA_IRQ_STATUS, interrupt status bits reflect the occurrence of an event / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " SPI_MST_RDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_RDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " SPI_MST_RDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " SPI_MST_RDMA_IRQ_STATUS_UNFL ,Underflow: data towards AXI-4S is consumed faster than the DMA is able to read data from the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "SPI_MST_RDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " SPI_MST_RDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_RDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " SPI_MST_RDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " SPI_MST_RDMA_IRQ_STATUS_ENABLE_UNFL ,Enable interrupt unfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "SPI_MST_RDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev) RESET:0x0"
         bitfld.long 0x00 0. " SPI_MST_RDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " SPI_MST_RDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " SPI_MST_RDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " SPI_MST_RDMA_IRQ_STATUS_SET_UNFL ,Set interrupt unfl RESET:0x0"
          
tree.end

tree "DECTSPI_MST"
base e:0x40061000
width 80.
tree.end

tree "DECTSPI_MST__WRAP"
base e:0x40061000
width 80.
group.long  0x0++0x3
    line.long 0x00 "DECTSPI_MST_WRAP_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " DECTSPI_MST_WRAP_CTRL_EN ,Enable SPI Master RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_WRAP_CTRL_CPHA ,CPHA RESET:0x0"
          
         bitfld.long 0x00 2. " DECTSPI_MST_WRAP_CTRL_CPOL ,CPOL RESET:0x0"
          
         bitfld.long 0x00 3. " DECTSPI_MST_WRAP_CTRL_STOP ,End of Transfer. Must be set when last byte to be transmitted is added to the TX FIFO RESET:0x0"
          
         bitfld.long 0x00 4.--5. " DECTSPI_MST_WRAP_CTRL_MODE ,SPI communication mode - 00: DMA (default) - 01: APB_WDMA - 10: APB_RDMA - 11: APB RESET:0x0" "DMA-0,APB_WDMA-1,APB_RDMA-2,APB-3"
          
rgroup.long 0x4++0x3
    line.long 0x00 "DECTSPI_MST_WRAP_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " DECTSPI_MST_WRAP_STATUS_RX_NOT_EMPTY ,Status: RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_WRAP_STATUS_RX_FULL ,Status: RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " DECTSPI_MST_WRAP_STATUS_TX_EMPTY ,Status: TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 3. " DECTSPI_MST_WRAP_STATUS_TX_NOT_FULL ,Status: TX FIFO not full RESET:0x0"
          
         bitfld.long 0x00 4. " DECTSPI_MST_WRAP_STATUS_RX_TLAST ,Status: RX Path, last byte was received RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "DECTSPI_MST_WRAP_IRQ_STATUS_ENABLE, None RESET:0x0"
         bitfld.long 0x00 0. " DECTSPI_MST_WRAP_IRQ_STATUS_ENABLE_RX_OVFL ,Enable IRQ for RX FIFO overflow RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_WRAP_IRQ_STATUS_ENABLE_RX_FULL ,Enable IRQ for RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " DECTSPI_MST_WRAP_IRQ_STATUS_ENABLE_RX_NOT_EMPTY ,Enable IRQ for RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 3. " DECTSPI_MST_WRAP_IRQ_STATUS_ENABLE_TX_EMPTY ,Enable IRQ for TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 4. " DECTSPI_MST_WRAP_IRQ_STATUS_ENABLE_TX_NOT_FULL ,Enable IRQ for TX FIFO not full RESET:0x0"
          
         bitfld.long 0x00 5. " DECTSPI_MST_WRAP_IRQ_STATUS_ENABLE_TX_DONE ,Enable IRQ for last byte TX/RX done RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "DECTSPI_MST_WRAP_IRQ_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " DECTSPI_MST_WRAP_IRQ_STATUS_RX_OVFL ,IRQ Status for RX FIFO overflow RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_WRAP_IRQ_STATUS_RX_FULL ,IRQ Status for RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " DECTSPI_MST_WRAP_IRQ_STATUS_RX_NOT_EMPTY ,Enable IRQ for RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 3. " DECTSPI_MST_WRAP_IRQ_STATUS_TX_EMPTY ,IRQ Status for TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 4. " DECTSPI_MST_WRAP_IRQ_STATUS_TX_NOT_FULL ,IRQ Status for TX FIFO not full RESET:0x0"
          
         bitfld.long 0x00 5. " DECTSPI_MST_WRAP_IRQ_STATUS_TX_DONE ,IRQ Status for last byte TX/RX done RESET:0x0"
          
wgroup.long 0x10++0x3
    line.long 0x00 "DECTSPI_MST_WRAP_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev) (singlepulse) RESET:0x0"
         bitfld.long 0x00 0. " DECTSPI_MST_WRAP_IRQ_STATUS_SET_RX_OVFL ,Set rx_ovfl irq RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_WRAP_IRQ_STATUS_SET_RX_FULL ,Set rx_full irq RESET:0x0"
          
         bitfld.long 0x00 2. " DECTSPI_MST_WRAP_IRQ_STATUS_SET_RX_NOT_EMPTY ,Set rx_not_empty irq RESET:0x0"
          
         bitfld.long 0x00 3. " DECTSPI_MST_WRAP_IRQ_STATUS_SET_TX_EMPTY ,Set tx_empty irq RESET:0x0"
          
         bitfld.long 0x00 4. " DECTSPI_MST_WRAP_IRQ_STATUS_SET_TX_NOT_FULL ,Set tx_not_full irq RESET:0x0"
          
         bitfld.long 0x00 5. " DECTSPI_MST_WRAP_IRQ_STATUS_SET_TX_DONE ,Set tx_done irq RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "DECTSPI_MST_WRAP_SCLK_FREQ, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DECTSPI_MST_WRAP_SCLK_FREQ_TICKS ,Set clock ticks for half of SCLK_PERIOD. SCLK_FREQ = SPI_MST_CLK_FREQ/(2*(ticks+1)) RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "DECTSPI_MST_WRAP_TX, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DECTSPI_MST_WRAP_TX_DATA ,Data to be added on TX FIFO RESET:0x0"
          
         bitfld.long 0x00 8. " DECTSPI_MST_WRAP_TX_DATA_WTRIG ,Set wtrig signal to indicate data is valid (singlepulse first check on none full tx_fifo!!!) RESET:0x0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "DECTSPI_MST_WRAP_RX, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DECTSPI_MST_WRAP_RX_DATA ,Data to be read from the RX FIFO. Data is not consumed on read. Use RX_FIFO register to consume/clear RX FIFO RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "DECTSPI_MST_WRAP_RX_FIFO, None RESET:0x0"
         bitfld.long 0x00 0. " DECTSPI_MST_WRAP_RX_FIFO_POP ,Consume one item on RX FIFO (singlepulse) RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_WRAP_RX_FIFO_RX_FLUSH ,Flush RX FIFO (constant enable) RESET:0x0"
          
tree.end

tree "DECTSPI_MST__QSPI"
base e:0x40061040
width 80.
group.long  0x0++0x3
    line.long 0x00 "DECTSPI_MST_QSPI_CFG_ITF, Configuration for (Q)SPI master interface RESET:0x40"
         bitfld.long 0x00 0.--1. " DECTSPI_MST_QSPI_CFG_ITF_SPI_MODE ,SPI interface mode - 00: 1 bit SPI (single SPI) (default) - 01: 2 bit SPI (dual SPI) - 10: 4 bit SPI (quad SPI) - 11: reserved RESET:0x0" "SNGL_SPI-0,DUAL_SPI-1,QUAD_SPI-2"
          
         bitfld.long 0x00 2. " DECTSPI_MST_QSPI_CFG_ITF_CPHA ,SPI clock phase - 0: change data on falling egde, sample data on rising  edge (default) - 1: change data on rising  egde, sample data on falling edge RESET:0x0"
          
         bitfld.long 0x00 3. " DECTSPI_MST_QSPI_CFG_ITF_CPOL ,SPI clock polarity - 0: clock in idle state is low (default) - 1: clock in idle state is high RESET:0x0"
          
         bitfld.long 0x00 4.--5. " DECTSPI_MST_QSPI_CFG_ITF_MOSI_SEL ,select QSPI data port for SPI MOSI (output) in single SPI mode - 0: MOSI[0] (default) - 1: MOSI[1] - 2: MOSI[2] - 3: MOSI[3] RESET:0x0" "MOSI_0-0,MOSI_1-1,MOSI_2-2,MOSI_3-3"
          
         bitfld.long 0x00 6.--7. " DECTSPI_MST_QSPI_CFG_ITF_MISO_SEL ,select QSPI data port for SPI MISO (input) in single SPI mode - 0: MISO[0] - 1: MISO[1] (default) - 2: MISO[2] - 3: MISO[3] RESET:0x1" "MISO_0-0,MISO_1-1,MISO_2-2,MISO_3-3"
          
group.long  0x4++0x3
    line.long 0x00 "DECTSPI_MST_QSPI_CFG_SCLK, Configuration for SPI clock RESET:0x10001"
         hexmask.long 0x00 0.--7. 1. " DECTSPI_MST_QSPI_CFG_SCLK_CDIV ,SPI clock divider SPI clock[freq] = sys_clk / (2*(cdiv+1))     duty cycle is 50% RESET:0x1"
          
         hexmask.long 0x00 16.--24. 1. " DECTSPI_MST_QSPI_CFG_SCLK_SMPL_POINT ,sample point - [8]   : SPI clock high/low - [7:0] : clk_div_phase example: sample at rising edge: [8]   = 0 [7:0] = cdiv RESET:0x1"
          
group.long  0x8++0x3
    line.long 0x00 "DECTSPI_MST_QSPI_CFG_SS_TIMING, configure SPI slave select timing RESET:0x100"
         hexmask.long 0x00 0.--3. 1. " DECTSPI_MST_QSPI_CFG_SS_TIMING_SETUP ,setup time, time from falling edge of 'slave select' to first active SPI clock edge, number of SPI clock periods, values 0-15 (default = 0) RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DECTSPI_MST_QSPI_CFG_SS_TIMING_HOLD ,hold time, time from last active SPI clock edge to rising edge of 'slave select', number of SPI clock periods, values 0-15 (default = 0) RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " DECTSPI_MST_QSPI_CFG_SS_TIMING_INACTIVE ,minimum inactive time (inter transaction gap), SPI slave select is high for minimum this period between transactions, number of SPI clock periods, values 0-15 (default = 1) RESET:0x1"
          
group.long  0xc++0x3
    line.long 0x00 "DECTSPI_MST_QSPI_CTRL, (Q)SPI master control RESET:0x0"
         bitfld.long 0x00 0. " DECTSPI_MST_QSPI_CTRL_RESTART ,Restart (Q)SPI master interface (single pulse / self clearing) reset state and flush buffers RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "DECTSPI_MST_QSPI_EXT_SS_CTRL, (Q)SPI slave select control RESET:0x2"
         bitfld.long 0x00 0. " DECTSPI_MST_QSPI_EXT_SS_CTRL_ENABLE ,enable external slave select RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_QSPI_EXT_SS_CTRL_VALUE ,value of external slave select 0: low 1: high (default) RESET:0x1"
          
rgroup.long 0x14++0x3
    line.long 0x00 "DECTSPI_MST_QSPI_STATUS, (Q)SPI state RESET:0x0"
         bitfld.long 0x00 0.--2. " DECTSPI_MST_QSPI_STATUS_STATE ,FSM state of (Q)SPI master RESET:0x0" "IDLE-0,SS_SETUP-1,SS_HOLD-2,SS_INACTIVE-3,SHIFTING-4,SHIFT_LAST_WORD-5,WAIT-6,FINISH_TRANSFER-7"
          
tree.end

tree "DECTSPI_MST__WDMA"
base e:0x40061080
width 80.
group.long  0x0++0x3
    line.long 0x00 "DECTSPI_MST_WDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " DECTSPI_MST_WDMA_CTRL_ENABLE ,Global enable for the WDMA RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_WDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next write will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " DECTSPI_MST_WDMA_CTRL_ADDR_DECREMENT ,When = 1, address is decremented in the AXI master RESET:0x0"
          
         bitfld.long 0x00 3. " DECTSPI_MST_WDMA_CTRL_CONT_MODE ,Enables continuous mode if set to 1, transmission is finalized, if HW signals last access RESET:0x0"
          
         bitfld.long 0x00 4. " DECTSPI_MST_WDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 5.--12. 1. " DECTSPI_MST_WDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "DECTSPI_MST_WDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " DECTSPI_MST_WDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " DECTSPI_MST_WDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "DECTSPI_MST_WDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " DECTSPI_MST_WDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " DECTSPI_MST_WDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "DECTSPI_MST_WDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DECTSPI_MST_WDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "DECTSPI_MST_WDMA_SIZE1, SIZE1 interrupt triggers in case buffer is filled with size1 byte / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DECTSPI_MST_WDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "DECTSPI_MST_WDMA_CURR_ADDR, the current address of the DMA write pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DECTSPI_MST_WDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "DECTSPI_MST_WDMA_IRQ_STATUS, interrupt status bits / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " DECTSPI_MST_WDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_WDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " DECTSPI_MST_WDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " DECTSPI_MST_WDMA_IRQ_STATUS_OVFL ,Overflow: data from AXI-4S is coming too fast to be written to the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "DECTSPI_MST_WDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " DECTSPI_MST_WDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_WDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " DECTSPI_MST_WDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " DECTSPI_MST_WDMA_IRQ_STATUS_ENABLE_OVFL ,Enable interrupt ovfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "DECTSPI_MST_WDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to force an interrupt event (used for Software debugging or integration testing) RESET:0x0"
         bitfld.long 0x00 0. " DECTSPI_MST_WDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize for one cycle RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_WDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 for one cycle RESET:0x0"
          
         bitfld.long 0x00 2. " DECTSPI_MST_WDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr for one cycle RESET:0x0"
          
         bitfld.long 0x00 3. " DECTSPI_MST_WDMA_IRQ_STATUS_SET_OVFL ,Set interrupt ovfl for one cycle RESET:0x0"
          
tree.end

tree "DECTSPI_MST__RDMA"
base e:0x400610c0
width 80.
group.long  0x0++0x3
    line.long 0x00 "DECTSPI_MST_RDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " DECTSPI_MST_RDMA_CTRL_ENABLE ,Global enable for the RDMA RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_RDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next read will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " DECTSPI_MST_RDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " DECTSPI_MST_RDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
         bitfld.long 0x00 11. " DECTSPI_MST_RDMA_CTRL_TERMINATE ,Manual termination of stream, concludes transaction and sends tlast. Self-clearing RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "DECTSPI_MST_RDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " DECTSPI_MST_RDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " DECTSPI_MST_RDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "DECTSPI_MST_RDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " DECTSPI_MST_RDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " DECTSPI_MST_RDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "DECTSPI_MST_RDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DECTSPI_MST_RDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "DECTSPI_MST_RDMA_SIZE1, SIZE1 interrupt triggers in case size1 byte have been read from the buffer / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DECTSPI_MST_RDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "DECTSPI_MST_RDMA_CURR_ADDR, the current address of the DMA read pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DECTSPI_MST_RDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "DECTSPI_MST_RDMA_IRQ_STATUS, interrupt status bits reflect the occurrence of an event / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " DECTSPI_MST_RDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_RDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " DECTSPI_MST_RDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " DECTSPI_MST_RDMA_IRQ_STATUS_UNFL ,Underflow: data towards AXI-4S is consumed faster than the DMA is able to read data from the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "DECTSPI_MST_RDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " DECTSPI_MST_RDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_RDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " DECTSPI_MST_RDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " DECTSPI_MST_RDMA_IRQ_STATUS_ENABLE_UNFL ,Enable interrupt unfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "DECTSPI_MST_RDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev) RESET:0x0"
         bitfld.long 0x00 0. " DECTSPI_MST_RDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " DECTSPI_MST_RDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " DECTSPI_MST_RDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " DECTSPI_MST_RDMA_IRQ_STATUS_SET_UNFL ,Set interrupt unfl RESET:0x0"
          
tree.end
    

tree "DMA350"
base e:0x40062000
width 80.
tree.end

tree "DMA350__APB4SLVADDRESSBLOCK"
base e:0x40062000
width 80.
rgroup.long 0x200++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_NSEC_CHINTRSTATUS0, Non-Secure Channel Interrupt Status Register 0  This register shows the overall interrupt status of every Non-secure channel from Channel 0 to Channel 31. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CHINTRSTATUS0_CHINTRSTATUS0 ,Collated Non-Secure Channel Interrupt flags for channel 0 to channel 31. Limited by NUM_CHANNELS, all unimplemented bits are reserved. RESET:0x0"
          
group.long  0x208++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUS, Non-Secure Status Register  This register provides information about the overall status of the Non-secure channels. RESET:0x0"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUS_INTR_ANYCHINTR ,Combined Non-Secure Channel Interrupt Flag. Set to '1' when any Non-secure channel has an interrupt request in CHINTRSTATUS0 and NSECCTRL.INTREN_ANYCHINTR = 1. Cleared automatically when the source of the channel interrupt is cleared. RESET:0x0"
          
         bitfld.long 0x00 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUS_INTR_ALLCHIDLE ,All Non-Secure Channel Idle Interrupt Status. Set to '1' when NSECCTRL.STAT_ALLCHIDLE is asserted and NSECCTRL.INTREN_ALLCHIDLE = 1. Cleared automatically when STAT_ALLCHIDLE is cleared. RESET:0x0"
          
         bitfld.long 0x00 2. " DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUS_INTR_ALLCHSTOPPED ,All Non-Secure Channel Stopped Interrupt Status. Set to '1' when NSECCTRL.STAT_ALLCHSTOPPED is asserted and NSECCTRL.INTREN_ALLCHSTOPPED = 1. Cleared automatically when STAT_ALLCHSTOPPED is cleared. RESET:0x0"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUS_INTR_ALLCHPAUSED ,All Non-Secure Channel Paused Interrupt Status. Set to '1' when NSECCTRL.STAT_ALLCHPAUSED is asserted and NSECCTRL.INTREN_ALLCHPAUSED = 1. Cleared automatically when STAT_ALLCHPAUSED is cleared. RESET:0x0"
          
         hexmask.long 0x00 4.--16. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUS_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 17. " DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUS_STAT_ALLCHIDLE ,All Non-Secure Channel Idle Status. Set to '1' whenever all Non-secure DMA channel is in idle state after at least one channel was running. Cleared by writing '1' to this bit. RESET:0x0"
          
         bitfld.long 0x00 18. " DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUS_STAT_ALLCHSTOPPED ,All Non-Secure Channel Stopped Status. Set to '1' whenever all Non-secure DMA channels are in stopped or inactive state and the ALLCHSTOP request is active. Not set when channels reach the stopped state for other reasons. All Non-secure channels are forced to an immediate stopped state until ALLCHSTOP request is asserted even if they were enabled after the request. Cleared by writing '1' to this bit. The ALLCHSTOP request is also cleared when this bit is cleared. RESET:0x0"
          
         bitfld.long 0x00 19. " DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUS_STAT_ALLCHPAUSED ,All Non-Secure Channel Paused Status. Set to '1' whenever all Non-secure DMA channel is in paused or inactive state and the ALLCHPAUSE request is active. Not set when channels reach the paused state for other reasons. All Non-secure channels are forced to an immediate pause until ALLCHPAUSE request is asserted even if they were enabled after the request. Cleared by writing '1' to this bit which results in all Non-secure channels to resume their operation. The ALLCHPAUSE request is also cleared when this bit is cleared. RESET:0x0"
          
         hexmask.long 0x00 20.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUS_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x20c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_NSEC_CTRL, Non-Secure Control Register  This registers can be used to adjust the interrupt generation and general behavior of the Non-secure channels. RESET:0x0"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CTRL_INTREN_ANYCHINTR ,Combined Non-Secure Channel Interrupt Enable RESET:0x0"
          
         bitfld.long 0x00 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CTRL_INTREN_ALLCHIDLE ,All Non-Secure Channel Idle Interrupt Enable RESET:0x0"
          
         bitfld.long 0x00 2. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CTRL_INTREN_ALLCHSTOPPED ,All Non-Secure Channels Stopped Interrupt Enable RESET:0x0"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CTRL_INTREN_ALLCHPAUSED ,All Non-Secure Channel Paused Interrupt Enable RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CTRL_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 8. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CTRL_ALLCHSTOP ,Non-Secure All Channel Stop Request. When set to '1', all Non-secure channels get a stop request. Stays asserted until the STAT_ALLCHSTOPPED status flag is set. Cleared automatically when the STAT_ALLCHSTOPPED status flag is cleared. RESET:0x0"
          
         bitfld.long 0x00 9. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CTRL_ALLCHPAUSE ,Non-Secure All Channel Pause Request. When set to '1', all Non-secure channels get a pause request. Stays asserted until the channels are paused and the STAT_ALLCHPAUSED status flag is set. Cleared automatically when the STAT_ALLCHPAUSED status flag is cleared. RESET:0x0"
          
         hexmask.long 0x00 10.--26. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CTRL_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 27. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CTRL_DBGHALTNSRO ,Debug Halt Enable Non-Secure Read Only. When set to '1', the NSEC_CTRL.DBGHALTEN register becomes read-only. When set to '0', NSEC_CTRL.DBGHALTEN has read-write access. This register is read-only for the non-secure SW. RESET:0x0"
          
         bitfld.long 0x00 28. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CTRL_DBGHALTEN ,Debug Halt Enabled. When set to '0', the DMA ignores the halt request from an external debugger. Clearing this bit while halt is ongoing results in continuing the operation. When set to '1', the debugger request to halt the DMA is allowed. This field is common for non-secure and secure side of the DMA, but access to this register is limited by the DBGHALTNSRO register field. RESET:0x0"
          
         bitfld.long 0x00 29. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CTRL_IDLERETEN ,Idle Channel Retention Enable. Allows retention for non-secure channels that are enabled and waiting for an event in IDLE state. - 0: disabled - 1: enabled RESET:0x0"
          
         hexmask.long 0x00 30.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CTRL_DISMINPWR ,Minimum Power state of the DMAC when at least one non-secure channel is present. - 00: OFF - 01: Retention - 10: ON - Others: Reserved RESET:0x0"
          
group.long  0x214++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_NSEC_CHPTR, Non-Secure Channel Pointer  This register is used to select one channel that needs to be configured through the following registers that have NSEC_CH prefix. RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CHPTR_CHPTR ,Non-Secure Channel Pointer. Selects which channel settings can be adjusted by the following registers. RESET:0x0"
          
         hexmask.long 0x00 6.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CHPTR_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x218++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_NSEC_CHCFG, Non-Secure Channel Configuration Register  This register provides configuration fields for channel attributes. RESET:0x0"
         hexmask.long 0x00 0.--16. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CHCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 17. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CHCFG_CHPRIV ,Non-Secure Channel Privilege Enable. NSECCHPTR selects the channel. When set to '1' it allows the channel to send transfers marked as Privileged only. The configuration registers of the selected channel are also given privileged only access rights. When set to '0' the channel is only allowed to send unprivileged transfers and the channel registers can be accessed by both privileged and unprivileged register accesses. RESET:0x0"
          
         hexmask.long 0x00 18.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_CHCFG_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x2f0++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUSPTR, Non-Secure Unit Status Pointer Register  This register can set a pointer to an internal status register that can show the global state of the Non-secure channels. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUSPTR_NSECSTATUSPTR ,Non-Secure DMA Unit status pointer used to select which status value to view using STATUSVALUE register. Pointer values are: - 0: Channel Enabled Status for channel numbers [31 : 0]. - 1: Reserved - 2: Channel Stopped Status for channel numbers [31 : 0]. - 3: Reserved - 4: Channel Paused Status for channel numbers [31 : 0]. - Others: Reserved. RESET:0x0"
          
         hexmask.long 0x00 4.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUSPTR_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0x2f4++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUSVAL, Non-Secure Unit Status Value Register  This register shows the current value of a status register on Non-secure channels selected by the pointer in NSEC_STATUSPTR. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_STATUSVAL_NSECSTATUSVAL ,Non-Secure DMA Unit status value. Can be used for reading internal status values of the DMA Unit for debug purposes. Values shown here are dependent on STATUSPTR. Note that inputs are masked by security mapping before being presented here. This means that only status values mapped to Non-secure world are visible as non-Zero values. All unimplemented bits are RAZWI. RESET:0x0"
          
group.long  0x2f8++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_NSEC_SIGNALPTR, Non-Secure Unit Signal Pointer  This register can set a pointer to an internal register that shows the state of the Non-secure interfaces attached to the DMAC. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_SIGNALPTR_NSECSIGNALPTR ,Non-Secure DMA Unit signal pointer used to select which inputs or outputs to view using SIGNALVAL register. Pointer values, x,  are: - 0 to 7: Trigger Input Requests [31+32*x : 32*x] - 8 to 9: Trigger output Acknowledges [31+32*(x-8) :  32*(x-8)] - 10 to 11: GPO output value [31+32*(x-10) : 32*(x-10)], only present when HAS_GPOSEL is set - Others: Reserved RESET:0x0"
          
         hexmask.long 0x00 4.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_SIGNALPTR_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x2fc++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_NSEC_SIGNALVAL, Non-Secure Unit Signal Value Register  This register shows the current value of the Non-secure interfaces selected by the pointer in NSEC_SIGNALPTR. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_NSEC_SIGNALVAL_NSECSIGNALVAL ,Non-Secure DMA Unit signal status. Can be used for reading signal values of triggers and GPOs for debug. Values shown here are dependent on SIGNALPTR. Note that inputs are masked by security mapping before being presented here. This means that only signals mapped to Non-secure world are visible as non-zero values. Writing to this register has the following effect:  - Writing '1' to a Non-secure Trigger Input Request that are not selected by any DMA channel will cause a deny response for it. This can attempt to clear an unwanted trigger input.  - Writing '1' to any Trigger Output Acknowledges status, GPO status and all Trigger Input Request already selected by any DMA channel is ignored. All unimplemented bits are RAZWI. RESET:0x0"
          
rgroup.long 0xfb0++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG0, DMA Build Configuration Register 0  This register is used to provide information about the configuration parameters of the DMAC. RESET:0x49c10"
         hexmask.long 0x00 0.--2. 1. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG0_FRAMETYPE ,Register Frame Type.  - 000: Combined Frame,  - 001: Security Configuration Frame,  - 010: Secure Control Frame, or if TrustZone not implemented, Control Frame.  - 011: Non-Secure Control Frame,  - 100: DMA Channel Frame. Note that each frame replicates the Information fields. RESET:0x0"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG0_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 4.--9. 1. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG0_NUM_CHANNELS ,Number of Channels + 1 supported by the DMAC RESET:0x1"
          
         hexmask.long 0x00 10.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG0_ADDR_WIDTH ,Address Width in bits = ADDR_WIDTH + 1 RESET:0x27"
          
         hexmask.long 0x00 16.--18. 1. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG0_DATA_WIDTH ,Data Width. - 000: 8-bit - 001: 16-bit - 010: 32-bit - 011: 64-bit - 100: 128-bit - 101: 256-bit - 110: 512-bit - 111: 1024-bit RESET:0x4"
          
         bitfld.long 0x00 19. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG0_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 20.--24. 1. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG0_CHID_WIDTH ,Channel ID Width. '0' means CHID is not present. RESET:0x0"
          
         hexmask.long 0x00 25.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG0_RAZWI_2 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0xfb4++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG1, DMA Build Configuration Register 1  This register is used to provide information about the configuration parameters of the DMAC. RESET:0x10000"
         hexmask.long 0x00 0.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG1_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 16. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG1_HAS_TRIGSEL ,Has Selectable Trigger Support RESET:0x1"
          
         hexmask.long 0x00 17.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG1_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0xfb8++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG2, DMA Build Configuration Register 2  This register is used to provide information about the configuration parameters of the DMAC. RESET:0x200"
         hexmask.long 0x00 0.--6. 1. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG2_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 7. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG2_HAS_GPOSEL ,Has Shared and hence Selectable GPO Support. RESET:0x0"
          
         bitfld.long 0x00 8. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG2_HAS_TZ ,Has TrustZone Support RESET:0x0"
          
         bitfld.long 0x00 9. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG2_HAS_RET ,Has Retention Support RESET:0x1"
          
         hexmask.long 0x00 10.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMA_BUILDCFG2_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0xfc8++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_IIDR, Implementation Identification Register  This register provides information about the implementer of the DMAC. RESET:0x3a00043b"
         hexmask.long 0x00 0.--11. 1. " DMA350_APB4SLVADDRESSBLOCK_IIDR_IMPLEMENTER ,Contains the JEP106 code of the company that implemented the IP:  - [11:8]: JEP106 continuation code of implementer.  - [7]: Always 0.  - [6:0]: JEP106 identity code of implementer. For Arm this field reads as 0x43B. RESET:0x43b"
          
         hexmask.long 0x00 12.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_IIDR_REVISION ,Indicates the minor revision of the product rxpy identifier RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " DMA350_APB4SLVADDRESSBLOCK_IIDR_VARIANT ,Indicates the major revision, or variant, of the product rxpy identifier RESET:0x0"
          
         hexmask.long 0x00 20.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_IIDR_PRODUCTID ,Indicates the product ID RESET:0x3a0"
          
rgroup.long 0xfcc++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_AIDR, Architecture Identification Register  This register provides information about the architecture revision supported by the DMAC. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_AIDR_ARCH_MINOR_REV ,Architecture Minor Revision. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_AIDR_ARCH_MAJOR_REV ,Architecture Major Revision. RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_AIDR_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0xfd0++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_PIDR4, Peripheral ID4 Register  This register returns byte[4] of the peripheral ID. RESET:0x4"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_PIDR4_DES_2 ,JEP106 Continuation Code RESET:0x4"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_PIDR4_SIZE ,4KB Count - the number of 4K pages used. - 0x00: 4K - 0x01: 8K - 0x02: 16K - 0x03: 32K RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_PIDR4_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0xfe0++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_PIDR0, Peripheral ID0 Register  This register returns byte[0] of the peripheral ID. RESET:0xa0"
         hexmask.long 0x00 0.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_PIDR0_PART_0 ,Part Number [7:0] RESET:0xa0"
          
         hexmask.long 0x00 8.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_PIDR0_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0xfe4++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_PIDR1, Peripheral ID1 Register  This register returns byte[1] of the peripheral ID. RESET:0xb3"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_PIDR1_PART_1 ,Part Number [11:8]. RESET:0x3"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_PIDR1_DES_0 ,JEP106 Identity Code [3:0] RESET:0xb"
          
         hexmask.long 0x00 8.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_PIDR1_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0xfe8++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_PIDR2, Peripheral ID2 Register  This register returns byte[2] of the peripheral ID. RESET:0xb"
         hexmask.long 0x00 0.--2. 1. " DMA350_APB4SLVADDRESSBLOCK_PIDR2_DES_1 ,JEP106 Identity Code [6:4] RESET:0x3"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_PIDR2_JEDEC ,JEDEC RESET:0x1"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_PIDR2_REVISION ,Revision Code RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_PIDR2_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0xfec++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_PIDR3, Peripheral ID 3 Register  This register returns byte[3] of the peripheral ID. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_PIDR3_CMOD ,Customer Modified RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_PIDR3_REVAND ,Manufacturer revision number RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_PIDR3_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0xff0++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_CIDR0, Component ID0 Register  This register returns byte[0] of the component ID. RESET:0xd"
         hexmask.long 0x00 0.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_CIDR0_PRMBL_0 ,Preamble RESET:0xd"
          
         hexmask.long 0x00 8.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_CIDR0_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0xff4++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_CIDR1, Component ID1 Register  This register returns byte[1] of the component ID. RESET:0xf0"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_CIDR1_PRMBL_1 ,Preamble RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_CIDR1_CLASS ,Component class RESET:0xf"
          
         hexmask.long 0x00 8.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_CIDR1_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0xff8++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_CIDR2, Component ID2 Register  This register returns byte[2] of the component ID. RESET:0x5"
         hexmask.long 0x00 0.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_CIDR2_PRMBL_2 ,Preamble RESET:0x5"
          
         hexmask.long 0x00 8.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_CIDR2_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0xffc++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_CIDR3, Component ID3 Register  This register returns byte[3] of the component ID. RESET:0xb1"
         hexmask.long 0x00 0.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_CIDR3_PRMBL_3 ,Preamble RESET:0xb1"
          
         hexmask.long 0x00 8.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_CIDR3_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1000++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CMD, Channel DMA Command Register  This register allows the SW to control the operation of a DMA command. RESET:0x0"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CMD_ENABLECMD ,Channel Enable. When set to '1', enables the channel to run its programmed task. When set to '1', it cannot be set back to zero, and this field will automatically clear to zero when a DMA process is completed. To force the DMA to stop prematurely, you must use CH_CMD.STOPCMD instead. RESET:0x0"
          
         bitfld.long 0x00 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CMD_CLEARCMD ,DMA Clear command. When set to '1', it will remain high until all DMA channel registers and any internal queues and buffers are cleared, before returning to '0'. When set at the same time as ENABLECMD or while the DMA channel is already enabled, the clear will only occur after any ongoing DMA operation is either completed, stopped or disabled and the ENABLECMD bit is deasserted by the DMA. RESET:0x0"
          
         bitfld.long 0x00 2. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CMD_DISABLECMD ,Disable DMA Operation at the end of the current DMA command operation. Once set to '1', this field will stay high and the current DMA command will be allowed to complete, but the DMA will not fetch the next linked command or will it auto-restart the DMA command even if they are set. Once the DMA has stopped, it will return to '0' and ENABLECMD is also cleared. When set at the same time as ENABLECMD or when the channel is not enabled then write to this register is ignored. RESET:0x0"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CMD_STOPCMD ,Stop Current DMA Operation. Once set to '1', his will remain high until the DMA channel is stopped cleanly. Then this will return to '0' and ENABLECMD is also cleared. When set at the same time as ENABLECMD or when the channel is not enabled then write to this register is ignored. Note that each DMA channel can have other sources of a stop request and this field will not reflect the state of the other sources. RESET:0x0"
          
         bitfld.long 0x00 4. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CMD_PAUSECMD ,Pause Current DMA Operation. Once set to '1' the status cannot change until the DMA operation reached the paused state indicated by the STAT_PAUSED and STAT_RESUMEWAIT bits. The bit can be set by SW by writing it to '1', the current active DMA operation will be paused as soon as possible, but the ENABLECMD bit will remain HIGH to show that the operation is still active.  Cleared automatically when STAT_RESUMEWAIT is set and the RESUMECMD bit is written to '1', meaning that the SW continues the operation of the channel. Note that each DMA channel can have other sources of a pause request and this field will not reflect the state of the other sources. When set at the same time as ENABLECMD or when the channel is not enabled then write to this register is ignored. RESET:0x0"
          
         bitfld.long 0x00 5. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CMD_RESUMECMD ,Resume Current DMA Operation. Writing this bit to '1' means that the DMAC can continue the operation of a paused channel. Can be set to '1' when the PAUSECMD or a STAT_DONE assertion with DONEPAUSEEN set HIGH results in pausing the current DMA channel operation indicated by the STAT_PAUSED and STAT_RESUMEWAIT bits. Otherwise, writes to this bit are ignored. RESET:0x0"
          
         hexmask.long 0x00 6.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CMD_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 16. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CMD_SRCSWTRIGINREQ ,Software Generated Source Trigger Input Request. Write to '1' to create a SW trigger request to the DMA with the specified type in the SRCSWTRIGINTYPE register. Once set to '1', this will remain high until the DMA accepted the trigger and will return this to '0'. It will also be cleared automatically if the current command is completed without expecting another trigger event. When the channel is not enabled, write to this register is ignored. RESET:0x0"
          
         hexmask.long 0x00 17.--19. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CMD_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 20. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CMD_DESSWTRIGINREQ ,Software Generated Destination Trigger Input Request. Write to '1' to create a SW trigger request to the DMA with the specified type in the DESSWTRIGINTYPE register. Once set to '1', this will remain high until the DMA is accepted the trigger and will return this to '0'. It will also be cleared automatically if the current command is completed without expecting another trigger event. When the channel is not enabled, write to this register is ignored. RESET:0x0"
          
         hexmask.long 0x00 21.--23. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CMD_RAZWI_2 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 24. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CMD_SWTRIGOUTACK ,Software Generated Trigger Output Acknowledge. Write '1' to acknowledge a Trigger Output request from the DMA. Once set to '1', this will remain high until the DMA Trigger Output is raised (either on the trigger output signal or as an interrupt) and the acknowledge is accepted. When the channel is not enabled, write to this register is ignored. RESET:0x0"
          
         hexmask.long 0x00 25.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CMD_RAZWI_3 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1004++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS, Channel Status Register  This register shows the internal status of the DMA command and also reports interrupts about internal events. RESET:0x0"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_INTR_DONE ,Done Interrupt Flag. This interrupt will be set to HIGH if the INTREN_DONE is set and the STAT_DONE status flag gets raised. Automatically cleared when STAT_DONE is cleared. RESET:0x0"
          
         bitfld.long 0x00 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_INTR_ERR ,Error Interrupt Flag. This interrupt will be set to HIGH if the INTREN_ERR is set and the STAT_ERR status flag gets raised. Automatically cleared when STAT_ERR is cleared. RESET:0x0"
          
         bitfld.long 0x00 2. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_INTR_DISABLED ,Disabled Interrupt Flag. This interrupt will be set to HIGH if the INTREN_DISABLED is set and the STAT_DISABLED flag gets raised. Automatically cleared when STAT_DISABLED is cleared. RESET:0x0"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_INTR_STOPPED ,Stopped Interrupt Flag. This interrupt will be set to HIGH if the INTREN_STOPPED is set and the STAT_STOPPED flag gets raised. Automatically cleared when STAT_STOPPED is cleared. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 8. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_INTR_SRCTRIGINWAIT ,Channel is waiting for Source Trigger Interrupt Flag. This interrupt will be set to HIGH if the INTREN_SRCTRIGINWAIT is set and the STAT_SRCTRIGINWAIT status flag is asserted. Automatically cleared when STAT_SRCTRIGINWAIT is cleared. RESET:0x0"
          
         bitfld.long 0x00 9. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_INTR_DESTRIGINWAIT ,Channel is waiting for Destination Trigger Interrupt Flag. This interrupt will be set to HIGH if the INTREN_DESTRIGINWAIT is set and the STAT_DESTRIGINWAIT status flag is asserted. Automatically cleared when STAT_DESTRIGINWAIT is cleared. RESET:0x0"
          
         bitfld.long 0x00 10. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_INTR_TRIGOUTACKWAIT ,Channel is waiting for output Trigger Acknowledgement Interrupt Flag.  This interrupt will be set to HIGH if the INTREN_TRIGOUTACKWAIT is set and the STAT_TRIGOUTACKWAIT status flag is asserted. Automatically cleared when STAT_TRIGOUTACKWAIT is cleared. RESET:0x0"
          
         hexmask.long 0x00 11.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 16. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_STAT_DONE ,Done Status Flag. This flag will be set to HIGH when the DMA command reaches the state defined by the DONETYPE settings. When DONEPAUSEEN is set the DMA command operation is paused when this flag is asserted. Write '1' to this bit to clear it. Automatically cleared when the ENABLECMD is set. RESET:0x0"
          
         bitfld.long 0x00 17. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_STAT_ERR ,Error Status Flag. This flag will be set to HIGH if the DMA encounters an error during its operation. The details about the error event can be found in the ERRINFO register. Write '1' to this bit to clear it. When cleared, it also clears the ERRINFO register. Automatically cleared when the ENABLECMD is set. RESET:0x0"
          
         bitfld.long 0x00 18. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_STAT_DISABLED ,Disabled Status Flag. This flag will be set to HIGH if the DMA channel is successfully disabled using the DISABLECMD command. Write '1' to this bit to clear it. Automatically cleared when the ENABLECMD is set. RESET:0x0"
          
         bitfld.long 0x00 19. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_STAT_STOPPED ,Stopped Status Flag. This flag will be set to HIGH if the DMA channel successfully reached the stopped state. The stop request can come from many internal or external sources. Write '1' to this bit to clear it. Automatically cleared when the ENABLECMD is set. RESET:0x0"
          
         bitfld.long 0x00 20. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_STAT_PAUSED ,Paused Status Flag. This flag will be set to HIGH if the DMA channel successfully paused the operation of the command. The pause request can come from many internal or external sources. When the request to pause is not asserted anymore the bit will be cleared automatically and the command operation can continue. RESET:0x0"
          
         bitfld.long 0x00 21. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_STAT_RESUMEWAIT ,Waiting for resume from software Flag. This flag indicates that the DMA channel successfully paused the operation of the command and needs SW acknowledgment to resume the operation. Will be set to HIGH if STAT_PAUSED is asserted and the PAUSECMD bit set in the command register or when the STAT_DONE is asserted and the DONEPAUSEEN bit is set. Cleared when the RESUMECMD bit is set in the command register. RESET:0x0"
          
         hexmask.long 0x00 22.--23. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_RAZWI_2 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 24. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_STAT_SRCTRIGINWAIT ,Channel is waiting for Source Trigger Status. This bit is set to HIGH when DMA channel starts waiting for source input trigger request. Automatically cleared when the source trigger request is received either from HW or SW source. RESET:0x0"
          
         bitfld.long 0x00 25. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_STAT_DESTRIGINWAIT ,Channel is waiting for Destination Trigger Status. This bit is set to HIGH when DMA channel starts waiting for destination input trigger request. Automatically cleared when the destination trigger request is received either from HW or SW source. RESET:0x0"
          
         bitfld.long 0x00 26. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_STAT_TRIGOUTACKWAIT ,Channel is waiting for output Trigger Acknowledgement Status. This bit is set to HIGH when DMA channel starts waiting for output trigger acknowledgement. Automatically cleared when the output trigger acknowledgement is received either from HW or SW source. RESET:0x0"
          
         hexmask.long 0x00 27.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_STATUS_RAZWI_3 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1008++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_INTREN, Channel Interrupt Enable Register  This register can enable the interrupt generation for internal events.  The content of this register can be updated during command linking by setting bit[2] in the command link header. RESET:0x0"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_INTREN_INTREN_DONE ,Done Interrupt Enable. When set to HIGH, enables the INTR_DONE to be set and raise an interrupt when the STAT_DONE status flag is asserted. When set to LOW, it prevents INTR_DONE to be asserted. Currently pending interrupts are not affected by clearing this bit. RESET:0x0"
          
         bitfld.long 0x00 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_INTREN_INTREN_ERR ,Error Interrupt Enable. When set to HIGH, enables INTR_ERROR to be set and raise an interrupt when the STAT_ERR status flag is asserted. When set to LOW, it prevents INTR_ERR to be asserted. Currently pending interrupts are not affected by clearing this bit. RESET:0x0"
          
         bitfld.long 0x00 2. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_INTREN_INTREN_DISABLED ,Disabled Interrupt Enable. When set to HIGH, enables INTR_DISABLED to be set and raise an interrupt when STAT_DISABLED status flag is asserted. When set to LOW, it prevents INTR_DISABLED to be asserted. Currently pending interrupts are not affected by clearing this bit. RESET:0x0"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_INTREN_INTREN_STOPPED ,Stopped Interrupt Enable. When set to HIGH, enables INTR_STOPPED to be set and raise an interrupt when STAT_STOPPED status flag is asserted. When set to LOW, it prevents INTR_STOPPED to be asserted. Currently pending interrupts are not affected by clearing this bit. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_INTREN_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 8. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_INTREN_INTREN_SRCTRIGINWAIT ,Channel is waiting for Source Trigger Interrupt Enable. When set to HIGH, enables INTR_SRCTRIGINWAIT to be set and raise an interrupt when STAT_SRCTRIGINWAIT status flag is asserted. When set to LOW, it prevents INTR_SRCTRIGINWAIT to be asserted. Currently pending interrupts are not affected by clearing this bit. RESET:0x0"
          
         bitfld.long 0x00 9. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_INTREN_INTREN_DESTRIGINWAIT ,Channel is waiting for destination Trigger Interrupt Enable. When set to HIGH, enables INTR_DESTRIGINWAIT to be set and raise an interrupt when STAT_DESTRIGINWAIT status flag is asserted. When set to LOW, it prevents INTR_DESTRIGINWAIT to be asserted. Currently pending interrupts are not affected by clearing this bit. RESET:0x0"
          
         bitfld.long 0x00 10. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_INTREN_INTREN_TRIGOUTACKWAIT ,Channel is waiting for output Trigger Acknowledgement Interrupt Enable. When set to HIGH, enables INTR_TRIGOUTACKWAIT to be set and raise an interrupt when STAT_TRIGOUTACKWAIT status flag is asserted. When set to LOW, it prevents INTR_TRIGOUTACKWAIT to be asserted. Currently pending interrupts are not affected by clearing this bit. RESET:0x0"
          
         hexmask.long 0x00 11.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_INTREN_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x100c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL, Channel Control Register  This register can be used to configure the type of the transfers and the resources needed by the currently executed DMA command. It also defines how the command shall behave when the command is complete. The content of this register can be updated during command linking by setting bit[3] in the command link header. RESET:0x200200"
         hexmask.long 0x00 0.--2. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL_TRANSIZE ,Transfer Entity Size. Size in bytes = 2^TRANSIZE.  - 000: Byte  - 001: Halfworld  - 010: Word  - 011: Doubleword  - 100: 128bits  - 101: 256bits  - 110: 512bits  - 111: 1024bits Note that DATA_WIDTH limits this field. Address will be aligned to TRANSIZE by the DMAC by ignoring the lower bits. RESET:0x0"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL_CHPRIO ,Channel Priority. - 0: Lowest Priority - 15: Highest Priority RESET:0x0"
          
         bitfld.long 0x00 8. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 9.--11. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL_XTYPE ,Operation type for X direction: - 000: 'disable' - No data transfer will take place for this command. This mode can be used to create empty commands that wait for an event or set GPOs. - 001: 'continue' - Copy data in a continuous manner from source to the destination. For 1D operations it is expected that SRCXSIZE is equal to DESXSIZE, other combinations result in UNPREDICTABLE behavior. For 2D operations, this mode can be used for simple 2D to 2D copy but it also allows the reshaping of the data like 1D to 2D or 2D to 1D conversions. If the DESXSIZE is smaller than SRCXSIZE then the read data from the current source line goes to the next destination line. If SRCXSIZE is smaller than DESXSIZE then the reads start on the next line and data is written to the remainder of the current destination line. Note: For 1D to 2D the SRCYSIZE for 2D to 1D conversion the DESYSIZE needs to be set to 1 when using this mode. - 010: 'wrap' - Wrap source data within a destination line when the end of the source line is reached. Read starts again from the beginning of the source line and copied to the remainder of the destination line. If the DESXSIZE is smaller than SRCXSIZE then the behavior is UNPREDICTABLE. Not supported when HAS_WRAP is 0 in HW - 011: 'fill' - Fill the remainder of the destination line with FILLVAL when the end of the source line is reached. If the DESXSIZE is smaller than SRCXSIZE then the behavior is UNPREDICTABLE. Not supported when HAS_WRAP is 0 in HW. - Others: Reserved. RESET:0x1"
          
         hexmask.long 0x00 12.--14. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL_YTYPE ,Operation type for Y direction: - 000: 'disable' - Only do 1D transfers. When HAS_2D is 0, meaning 2D capability is not supported in HW, the YTYPE is always '000'. - 001: 'continue' - Copy 2D data in a continuous manner from source area to the destination area by using the YSIZE registers. The copy stops when the source runs out of data or the destination runs out of space. Not supported when HAS_2D is 0 in HW. - 010: 'wrap' - Wrap the 2D source area within the destination 2D area by starting to copy data from the beginning of the first source line to the remaining space in the destination area. If the destination area is smaller than the source area then the behavior is UNPREDICTABLE. Not supported when HAS_WRAP or HAS_2D is 0 in HW. - 011:  Fill the remainder of the destination area with FILLVAL when the source area runs out of data. If the destination area is smaller than the source area then the behavior is UNPREDICTABLE. Not supported when HAS_WRAP or HAS_2D is 0 in HW - Others: Reserved RESET:0x0"
          
         hexmask.long 0x00 15.--17. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL_RAZWI_2 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 18.--20. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL_REGRELOADTYPE ,Automatic register reload type. Defines how the DMA command reloads initial values at the end of a DMA command before autorestarting, ending or linking to a new DMA command:  - 000: Reload Disabled.  - 001: Reload source and destination size registers only.  - 011: Reload source address only and all source and destination size registers.  - 101: Reload destination address only and all source and destination size registers.  - 111: Reload source and destination address and all source and destination size registers.  - Others: Reserved. NOTE: When CLEARCMD is set, the reloaded registers will also be cleared. RESET:0x0"
          
         hexmask.long 0x00 21.--23. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL_DONETYPE ,Done type selection. This field defines when the STAT_DONE status flag is asserted during the command operation. - 000: STAT_DONE flag is not asserted for this command. - 001: End of a command, before jumping to the next linked command. (default) - 011: End of an autorestart cycle, before starting the next cycle. - Others : Reserved. RESET:0x1"
          
         bitfld.long 0x00 24. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL_DONEPAUSEEN ,Done pause enable. When set to HIGH the assertion of the STAT_DONE flag results in an automatic pause request for the current DMA operation. When the paused state is reached the STAT_RESUMEWAIT flag is also set. When set to LOW the assertion of the STAT_DONE does not pause the progress of the command and the next operation of the channel will be started immediately after the STAT_DONE flag is set. RESET:0x0"
          
         bitfld.long 0x00 25. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL_USESRCTRIGIN ,Enable Source Trigger Input use for this command. - 0: disable - 1: enable RESET:0x0"
          
         bitfld.long 0x00 26. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL_USEDESTRIGIN ,Enable Destination Trigger Input use for this command. - 0: disable - 1: enable RESET:0x0"
          
         bitfld.long 0x00 27. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL_USETRIGOUT ,Enable Trigger Output use for this command. - 0: disable - 1: enable RESET:0x0"
          
         hexmask.long 0x00 28.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_CTRL_RAZWI_3 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1010++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCADDR, Channel Source Address Register  This register defines the 32-bit base address of the command to read the data from. When the register is read during the execution of the command it shows the actual address the DMA channel is going to read from.  The content of this register can be updated during command linking by setting bit[4] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCADDR_SRCADDR ,Source Address [31:0]. RESET:0x0"
          
group.long  0x1014++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCADDRHI, Channel Source Address Register High Bits [63:32]  This register defines the upper 32 bits of the read address in case more than 32-bit addressing is used in the system. When the register is read during the execution of the command it shows the actual address the DMA channel is going to read from.  The content of this register can be updated during command linking by setting bit[5] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCADDRHI_SRCADDRHI ,Source Address [63:32]. Allows 64-bit addressing but the system might need less address bits defined by ADDR_WIDTH. The not implemented bits remain reserved. RESET:0x0"
          
group.long  0x1018++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESADDR, Channel Destination Address Register  This register defines the 32-bit base address of the command to write the data to. When the register is read during the execution of the command it shows the actual address the DMA channel is going to write to.  The content of this register can be updated during command linking by setting bit[6] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESADDR_DESADDR ,Destination Address[31:0] RESET:0x0"
          
group.long  0x101c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESADDRHI, Channel Destination Address Register, High Bits [63:32]  This register defines the upper 32 bits of the write address in case more than 32-bit addressing is used in the system. When the register is read during the execution of the command it shows the actual address the DMA channel is going to write to.  The content of this register can be updated during command linking by setting bit[7] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESADDRHI_DESADDRHI ,Destination Address[63:32]. Allows 64-bit addressing but the system might need less address bits defined by ADDR_WIDTH. The not implemented bits remain reserved. RESET:0x0"
          
group.long  0x1020++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_XSIZE, Channel X Dimension Size Register, Lower Bits [15:0]  This register defines the number of data units copied during the DMA command up to 16 bits in the X dimension. The source and destination size of the command may be different for some transfer types. When read during the execution of the DMA command, the register shows the remaining number of units in both read and write directions.  The content of this register can be updated during command linking by setting bit[8] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_XSIZE_SRCXSIZE ,Source Number of Transfers in the X Dimension lower bits [15:0]. This register along with SRCXSIZEHI defines the source data block size of the DMA operation for any 1D operation, and defines the X dimension of the 2D source block for 2D operation. RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_XSIZE_DESXSIZE ,Destination Number of Transfers in the X Dimension lower bits [15:0]. This register along with DESXSIZEHI defines the destination data block size of the DMA operation for or any 1D operation, and defines the X dimension of the 2D destination block for a 2D operation. HAS_WRAP or HAS_STREAM configuration needs to be set to allow writes to this register, otherwise it is read-only and writing to SRCXSIZE will also update the value of this register. RESET:0x0"
          
group.long  0x1024++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_XSIZEHI, Channel X Dimension Size Register, High Bits [31:16]  This register defines the number of data units copied during the DMA command up to 32 bits in the X dimension. The source and destination size of the command may be different for some transfer types. When read during the execution of the DMA command, the register shows the higher bits of the remaining number of units in both read and write directions.  The content of this register can be updated during command linking by setting bit[9] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_XSIZEHI_SRCXSIZEHI ,Source Number of Transfers in the X Dimension high bits [31:16]. This register along with SRCXSIZE defines the source data block size of the DMA operation for any 1D operation, and defines the X dimension of the 2D source block for 2D operation. RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_XSIZEHI_DESXSIZEHI ,Destination Number of Transfers in the X Dimension high bits [31:16]. This register along with DESXSIZE defines the destination data block size of the DMA operation for or any 1D operation, and defines the X dimension of the 2D destination block for a 2D operation. HAS_WRAP or HAS_STREAM configuration needs to be set to allow writes to this register, otherwise it is read-only and writing to SRCXSIZEHI will also update the value of this register. RESET:0x0"
          
group.long  0x1028++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTRANSCFG, Channel Source Transfer Configuration Register  This register provides transfer attribute settings in the read direction of the DMA command.  The content of this register can be updated during command linking by setting bit[10] in the command link header. RESET:0xf0400"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTRANSCFG_SRCMEMATTRLO ,Source Transfer Memory Attribute field [3:0]. When SRCMEMATTRHI is Device type (0000) then this field means:  - 0000: Device-nGnRnE  - 0100: Device-nGnRE  - 1000: Device-nGRE  - 1100: Device-GRE  - Others: Invalid resulting in UNPREDICTABLE behavior When SRCMEMATTRHI is Normal memory type (other than 0000) then this field means:  - 0000: Reserved  - 0001: Normal memory, Inner Write allocate, Inner Write-through transient  - 0010: Normal memory, Inner Read allocate, Inner Write-through transient  - 0011: Normal memory, Inner Read/Write allocate, Inner Write-through transient  - 0100: Normal memory, Inner non-cacheable  - 0101: Normal memory, Inner Write allocate, Inner Write-back transient  - 0110: Normal memory, Inner Read allocate, Inner Write-back transient  - 0111: Normal memory, Inner Read/Write allocate, Inner Write-back transient  - 1000: Normal memory, Inner Write-through non-transient  - 1001: Normal memory, Inner Write allocate, Inner Write-through non-transient  - 1010: Normal memory, Inner Read allocate, Inner Write-through non-transient  - 1011: Normal memory, Inner Read/Write allocate, Inner Write-through non-transient  - 1100: Normal memory, Inner Write-back non-transient  - 1101: Normal memory, Inner Write allocate, Inner Write-back non-transient  - 1110: Normal memory, Inner Read allocate, Inner Write-back non-transient  - 1111: Normal memory, Inner Read/Write allocate, Inner Write-back non-transient RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTRANSCFG_SRCMEMATTRHI ,Source Transfer Memory Attribute field [7:4]. - 0000: Device memory - 0001: Normal memory, Outer Write allocate, Outer Write-through transient - 0010: Normal memory, Outer Read allocate, Outer Write-through transient - 0011: Normal memory, Outer Read/Write allocate, Outer Write-through transient - 0100: Normal memory, Outer non-cacheable - 0101: Normal memory, Outer Write allocate, Outer Write-back transient - 0110: Normal memory, Outer Read allocate, Outer Write-back transient - 0111: Normal memory, Outer Read/Write allocate, Outer Write-back transient - 1000: Normal memory, Outer Write-through non-transient - 1001: Normal memory, Outer Write allocate, Outer Write-through non-transient - 1010: Normal memory, Outer Read allocate, Outer Write-through non-transient - 1011: Normal memory, Outer Read/Write allocate, Outer Write-through non-transient - 1100: Normal memory, Outer Write-back non-transient - 1101: Normal memory, Outer Write allocate, Outer Write-back non-transient - 1110: Normal memory, Outer Read allocate, Outer Write-back non-transient - 1111: Normal memory, Outer Read/Write allocate, Outer Write-back non-transient RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTRANSCFG_SRCSHAREATTR ,Source Transfer Shareability Attribute. - 00: Non-shareable - 01: Reserved - 10: Outer shareable - 11: Inner shareable RESET:0x0"
          
         bitfld.long 0x00 10. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTRANSCFG_SRCNONSECATTR ,Source Transfer Non-secure Attribute. - 0: Secure - 1: Non-secure When a channel is Non-secure this bit is tied to 1. RESET:0x1"
          
         bitfld.long 0x00 11. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTRANSCFG_SRCPRIVATTR ,Source Transfer Privilege Attribute. - 0: Unprivileged - 1: Privileged When a channel is unprivileged this bit is tied to 0. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTRANSCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTRANSCFG_SRCMAXBURSTLEN ,Source Max Burst Length. Hint for the DMA on what is the maximum allowed burst size it can use for read transfers. The maximum number of beats sent by the DMA for a read burst is equal to SRCMAXBURSTLEN + 1. Default value is 16 beats, which allows the DMA to set all burst sizes. Note: Limited by the DATA_BUFF_SIZE so larger settings may not always result in larger bursts. RESET:0xf"
          
         hexmask.long 0x00 20.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTRANSCFG_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x102c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTRANSCFG, Channel Destination Transfer Configuration Register  This register provides transfer attribute settings in the write direction of the DMA command.  The content of this register can be updated during command linking by setting bit[11] in the command link header. RESET:0xf0400"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTRANSCFG_DESMEMATTRLO ,Destination Transfer Memory Attribute field [3:0]. When DESMEMATTRHI is Device type (0000) then this field means:  - 0000: Device-nGnRnE  - 0100: Device-nGnRE  - 1000: Device-nGRE  - 1100: Device-GRE  - Others: Invalid resulting in UNPREDICTABLE behavior When DESMEMATTRHI is Normal Memory type (other than 0000) then this field means:  - 0000: Reserved  - 0001: Normal memory, Inner Write allocate, Inner Write-through transient  - 0010: Normal memory, Inner Read allocate, Inner Write-through transient  - 0011: Normal memory, Inner Read/Write allocate, Inner Write-through transient  - 0100: Normal memory, Inner non-cacheable  - 0101: Normal memory, Inner Write allocate, Inner Write-back transient  - 0110: Normal memory, Inner Read allocate, Inner Write-back transient  - 0111: Normal memory, Inner Read/Write allocate, Inner Write-back transient  - 1000: Normal memory, Inner Write-through non-transient  - 1001: Normal memory, Inner Write allocate, Inner Write-through non-transient  - 1010: Normal memory, Inner Read allocate, Inner Write-through non-transient  - 1011: Normal memory, Inner Read/Write allocate, Inner Write-through non-transient  - 1100: Normal memory, Inner Write-back non-transient  - 1101: Normal memory, Inner Write allocate, Inner Write-back non-transient  - 1110: Normal memory, Inner Read allocate, Inner Write-back non-transient  - 1111: Normal memory, Inner Read/Write allocate, Inner Write-back non-transient RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTRANSCFG_DESMEMATTRHI ,Destination Transfer Memory Attribute field [7:4]. - 0000: Device memory - 0001: Normal memory, Outer Write allocate, Outer Write-through transient - 0010: Normal memory, Outer Read allocate, Outer Write-through transient - 0011: Normal memory, Outer Read/Write allocate, Outer Write-through transient - 0100: Normal memory, Outer non-cacheable - 0101: Normal memory, Outer Write allocate, Outer Write-back transient - 0110: Normal memory, Outer Read allocate, Outer Write-back transient - 0111: Normal memory, Outer Read/Write allocate, Outer Write-back transient - 1000: Normal memory, Outer Write-through non-transient - 1001: Normal memory, Outer Write allocate, Outer Write-through non-transient - 1010: Normal memory, Outer Read allocate, Outer Write-through non-transient - 1011: Normal memory, Outer Read/Write allocate, Outer Write-through non-transient - 1100: Normal memory, Outer Write-back non-transient - 1101: Normal memory, Outer Write allocate, Outer Write-back non-transient - 1110: Normal memory, Outer Read allocate, Outer Write-back non-transient - 1111: Normal memory, Outer Read/Write allocate, Outer Write-back non-transient RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTRANSCFG_DESSHAREATTR ,Destination Transfer Shareability Attribute. - 00: Non-shareable - 01: Reserved - 10: Outer shareable - 11: Inner shareable RESET:0x0"
          
         bitfld.long 0x00 10. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTRANSCFG_DESNONSECATTR ,Destination Transfer Non-secure Attribute. - 0: Secure - 1: Non-secure When a channel is Non-secure this bit is tied to 1. RESET:0x1"
          
         bitfld.long 0x00 11. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTRANSCFG_DESPRIVATTR ,Destination Transfer Privilege Attribute. - 0: Unprivileged - 1: Privileged When a channel is unprivileged this bit is tied to 0. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTRANSCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTRANSCFG_DESMAXBURSTLEN ,Destination Max Burst Length. Hint for the DMA on what is the maximum allowed burst size it can use for write transfers. The maximum number of beats sent by the DMA for a write burst is equal to DESMAXBURSTLEN + 1. Default value is 16 beats, which allows the DMA to set all burst sizes. Note: Limited by the DATA_BUFF_SIZE so larger settings may not always result in larger bursts. RESET:0xf"
          
         hexmask.long 0x00 20.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTRANSCFG_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1030++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_XADDRINC, Channel X Dimension Address Increment Register  This register sets the increment values used to update the source and destination addresses after each transferred data unit.  The content of this register can be updated during command linking by setting bit[12] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_XADDRINC_SRCXADDRINC ,Source X dimension Address Increment. This value is used as the increment between each TRANSIZE transfer. When a single bit is used then only 0 and 1 can be set. For wider increment registers, two's complement used with a range between -32768 to 32767 when the counter is 16-bits wide. The width of the register is indicated by the INC_WIDTH parameter. SRCADDR_next = SRCADDR + 2^TRANSIZE * SRCXADDRINC RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_XADDRINC_DESXADDRINC ,Destination X dimension Address Increment. This value is used as the increment between each TRANSIZE transfer. When a single bit is used then only 0 and 1 can be set. For wider increment registers, two's complement used with a range between -32768 to 32767 when the counter is 16-bits wide. The width of the register is indicated by the INC_WIDTH parameter. DESADDR_next = DESADDR + 2^TRANSIZE * DESXADDRINC RESET:0x0"
          
group.long  0x1034++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_YADDRSTRIDE, Channel Y Dimension Address Stride Register  This register sets the increment values used to update the source and destination line base addresses after each line is transferred.  The content of this register can be updated during command linking by setting bit[13] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_YADDRSTRIDE_SRCYADDRSTRIDE ,Source Address Stride between lines. Calculated in TRANSIZE aligned steps. This value is used to increment the SRCADDR after completing the transfer of a source line. SRCADDR_next_line_base = SRCADDR_line_base + 2^TRANSIZE * SRCYADDRSTRIDE. Two's complement used with a range between -32768 to 32767. When set to 0 the SRCADDR is not incremented after completing one line. Not present when HAS_2D is 0. RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_YADDRSTRIDE_DESYADDRSTRIDE ,Destination Address Stride between lines. Calculated in TRANSIZE aligned steps. This value is used to increment the DESADDR after completing the transfer of a destination line. DESADDR_next_line_base = DESADDR_line_base + 2^TRANSIZE * DESYADDRSTRIDE. Two's complement used with a range between -32768 to 32767. When set to 0 the DESADDR is not incremented after completing one line. Not present when HAS_2D is 0. RESET:0x0"
          
group.long  0x1038++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_FILLVAL, Channel Fill Pattern Value Register  This register provides a predefined value to be used to fill the remaining part of the destination memory area when the source side of the command is finished.  The content of this register can be updated during command linking by setting bit[14] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_FILLVAL_FILLVAL ,Fill pattern value. When XTYPE or YTYPE is set to fill mode, then this register value is used on the write data bus when the command starts to fill the memory area. The TRANSIZE defines the width of the FILLVAL used for the command. For byte transfers the FILLVAL[7:0] is used, other bits are ignored. For halfword transfers the FILLVAL[15:0] is used, other bits are ignored. For 64-bit and wider transfers the FILLVAL[31:0] pattern is repeated on the full width of the data bus. Not present when HAS_WRAP is 0. RESET:0x0"
          
group.long  0x103c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_YSIZE, Channel Y Dimensions Size Register  This register defines the number of lines copied during the DMA command up to 16 bits in the Y dimension. The read and write size of the command may be different for some transfer types. When read during the execution of the DMA command, the register shows the remaining number of lines in both read and write directions.  The content of this register can be updated during command linking by setting bit[15] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_YSIZE_SRCYSIZE ,Source Y dimension or number of lines. Not present when HAS_2D is 0. RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_YSIZE_DESYSIZE ,Destination Y dimension or number of lines. Not present when HAS_2D is 0. HAS_WRAP or HAS_STREAM configuration needs to be set to allow writes to this register, otherwise it is read-only. RESET:0x0"
          
group.long  0x1040++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_TMPLTCFG, Channel Template Configuration Register  This register provides configuration settings when using template pattern based copy operations.  The content of this register can be updated during command linking by setting bit[16] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_TMPLTCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 8.--12. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_TMPLTCFG_SRCTMPLTSIZE ,Source Template Size in number of transfers plus one. - 0: Source template is disabled. - 1 to 31: Bits SRCTMPLT[SRCTMPLTSIZE:0] is used as the source template. Not present when HAS_TMPLT is 0. RESET:0x0"
          
         hexmask.long 0x00 13.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_TMPLTCFG_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 16.--20. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_TMPLTCFG_DESTMPLTSIZE ,Destination Template Size in number of transfers plus one. - 0: Destination template is disabled. - 1 to 31: DESTMPLT[DESTMPLTSIZE:0] is used as the destination template. Not present when HAS_TMPLT is 0. RESET:0x0"
          
         hexmask.long 0x00 21.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_TMPLTCFG_RAZWI_2 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1044++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTMPLT, Channel Source Template Pattern Register  This register sets the template pattern used for reading the source memory area.  The content of this register can be updated during command linking by setting bit[17] in the command link header. RESET:0x1"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTMPLT_SRCTMPLTLSB ,Source Packing Template Least Significant Bit. This bit of the template is read only and always set to 1 as template patterns can only start from the base address of the transfer. Not present when HAS_TMPLT is 0. RESET:0x1"
          
         hexmask.long 0x00 1.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTMPLT_SRCTMPLT ,Source Packing Template. Bit[0] is read only and always set to 1 as template patterns can only start from the base address of the transfer. Not present when HAS_TMPLT is 0. RESET:0x0"
          
group.long  0x1048++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTMPLT, Channel Destination Template Pattern Register  This register sets the template pattern used for writing the destination memory area.  The content of this register can be updated during command linking by setting bit[18] in the command link header. RESET:0x1"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTMPLT_DESTMPLTLSB ,Destination Packing Template Least Significant Bit. This bit of the template is read only and always set to 1 as template patterns can only start from the base address of the transfer. Not present when HAS_TMPLT is 0. RESET:0x1"
          
         hexmask.long 0x00 1.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTMPLT_DESTMPLT ,Destination Packing Template.  Bit[0] is read only and always set to 1 as template patterns can only start from the base address of the transfer. Not present when HAS_TMPLT is 0. RESET:0x0"
          
group.long  0x104c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTRIGINCFG, Channel Source Trigger In Configuration Register  This register provides configuration settings when using source side trigger input for the current DMA command.  The content of this register can be updated during command linking by setting bit[19] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTRIGINCFG_SRCTRIGINSEL ,Source Trigger Input Select RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTRIGINCFG_SRCTRIGINTYPE ,Source Trigger Input Type:  - 00: Software only Trigger Request. SRCTRIGINSEL is ignored.  - 01: Reserved  - 10: HW Trigger Request. Only allowed when HAS_TRIGIN is enabled. SRCTRIGINSEL selects between external trigger inputs if HAS_TRIGSEL is enabled.  - 11: Internal Trigger Request. Only allowed when HAS_TRIGSEL is enabled and the DMAC has multiple channels, otherwise treated as HW Trigger Request. SRCTRIGINSEL selects between DMA channels. Note: SW triggers are also available when HW or Internal types are selected, but is is not recommended and caution must be taken when the these modes are combined. RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTRIGINCFG_SRCTRIGINMODE ,Source Trigger Input Mode:  - 00: Command  - 01: Reserved  - 10: DMA driven Flow control. Only allowed when HAS_TRIGIN is enabled.  - 11: Peripheral driven Flow control. Only allowed when HAS_TRIGIN is enabled. Note: This field is ignored for Internal triggers as they only support Command triggers. RESET:0x0"
          
         hexmask.long 0x00 12.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_SRCTRIGINCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1050++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTRIGINCFG, Channel Destination Trigger In Configuration Register  This register provides configuration settings when using destination side trigger input for the current DMA command.  The content of this register can be updated during command linking by setting bit[20] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTRIGINCFG_DESTRIGINSEL ,Destination Trigger Input Select RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTRIGINCFG_DESTRIGINTYPE ,Destination Trigger Input Type:  - 00: Software only Trigger Request. DESTRIGINSEL is ignored.  - 01: Reserved  - 10: HW Trigger Request. Only allowed when HAS_TRIGIN is enabled. DESTRIGINSEL selects between external trigger inputs if HAS_TRIGSEL is enabled.  - 11: Internal Trigger Request. Only allowed when HAS_TRIGSEL is enabled and the DMAC has multiple channels, otherwise treated as HW Trigger Request. DESTRIGINSEL selects between DMA channels. Note: SW triggers are also available when HW or Internal types are selected, but is is not recommended and caution must be taken when the these modes are combined. RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTRIGINCFG_DESTRIGINMODE ,Destination Trigger Input Mode:  - 00: Command  - 01: Reserved  - 10: DMA driven Flow control. Only allowed when HAS_TRIGIN is enabled.  - 11: Peripheral driven Flow control. Only allowed when HAS_TRIGIN is enabled. Note: This field is ignored for Internal triggers as they only support Command triggers. RESET:0x0"
          
         hexmask.long 0x00 12.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_DESTRIGINCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1054++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_TRIGOUTCFG, Channel Trigger Out Configuration Register  This register provides configuration settings when using trigger output for the current DMA command.  The content of this register can be updated during command linking by setting bit[21] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_TRIGOUTCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_TRIGOUTCFG_TRIGOUTTYPE ,Trigger Output Type - 00: Software only Trigger Acknowledgement. - 01: Reserved - 10: HW Trigger Acknowledgement. Only allowed when HAS_TRIGOUT is enabled. - 11: Internal Trigger Acknowledgement. Only allowed when HAS_TRIGSEL is enabled and the DMAC has multiple channels, otherwise treated as HW Trigger Acknowledgement. RESET:0x0"
          
         hexmask.long 0x00 10.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_TRIGOUTCFG_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1070++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_LINKATTR, Channel Link Address Memory Attributes Register  This register provides transfer attribute settings for the command link related read transfers. The security and privilege attributes cannot be adjusted, they match the attributes of the channel.  The content of this register can be updated during command linking by setting bit[28] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_LINKATTR_LINKMEMATTRLO ,Link Address Read Transfer Memory Attribute field [3:0]. When LINKMEMATTRHI is Device type (0000) then this field means:  - 0000: Device-nGnRnE  - 0100: Device-nGnRE  - 1000: Device-nGRE  - 1100: Device-GRE  - Others: Invalid resulting in UNPREDICTABLE behavior When LINKMEMATTRHI is Normal memory type (other than 0000) then this field means:  - 0000: Reserved  - 0001: Normal memory, Inner Write allocate, Inner Write-through transient  - 0010: Normal memory, Inner Read allocate, Inner Write-through transient  - 0011: Normal memory, Inner Read/Write allocate, Inner Write-through transient  - 0100: Normal memory, Inner non-cacheable  - 0101: Normal memory, Inner Write allocate, Inner Write-back transient  - 0110: Normal memory, Inner Read allocate, Inner Write-back transient  - 0111: Normal memory, Inner Read/Write allocate, Inner Write-back transient  - 1000: Normal memory, Inner Write-through non-transient  - 1001: Normal memory, Inner Write allocate, Inner Write-through non-transient  - 1010: Normal memory, Inner Read allocate, Inner Write-through non-transient  - 1011: Normal memory, Inner Read/Write allocate, Inner Write-through non-transient  - 1100: Normal memory, Inner Write-back non-transient  - 1101: Normal memory, Inner Write allocate, Inner Write-back non-transient  - 1110: Normal memory, Inner Read allocate, Inner Write-back non-transient  - 1111: Normal memory, Inner Read/Write allocate, Inner Write-back non-transient RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_LINKATTR_LINKMEMATTRHI ,Link Address Read Transfer Memory Attribute field [7:4]. - 0000: Device memory - 0001: Normal memory, Outer Write allocate, Outer Write-through transient - 0010: Normal memory, Outer Read allocate, Outer Write-through transient - 0011: Normal memory, Outer Read/Write allocate, Outer Write-through transient - 0100: Normal memory, Outer non-cacheable - 0101: Normal memory, Outer Write allocate, Outer Write-back transient - 0110: Normal memory, Outer Read allocate, Outer Write-back transient - 0111: Normal memory, Outer Read/Write allocate, Outer Write-back transient - 1000: Normal memory, Outer Write-through non-transient - 1001: Normal memory, Outer Write allocate, Outer Write-through non-transient - 1010: Normal memory, Outer Read allocate, Outer Write-through non-transient - 1011: Normal memory, Outer Read/Write allocate, Outer Write-through non-transient - 1100: Normal memory, Outer Write-back non-transient - 1101: Normal memory, Outer Write allocate, Outer Write-back non-transient - 1110: Normal memory, Outer Read allocate, Outer Write-back non-transient - 1111: Normal memory, Outer Read/Write allocate, Outer Write-back non-transient RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_LINKATTR_LINKSHAREATTR ,Link Address Transfer Shareability Attribute. - 00: Non-shareable - 01: Reserved - 10: Outer shareable - 11: Inner shareable RESET:0x0"
          
         hexmask.long 0x00 10.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_LINKATTR_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1074++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_AUTOCFG, Channel Automatic Command Restart Configuration Register  This register configures the automatic restart behavior of the currently running command.  The content of this register can be updated during command linking by setting bit[29] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_AUTOCFG_CMDRESTARTCNT ,Automatic Command Restart Counter. Defines the number of times automatic restarting will occur at end of DMA command. Auto restarting will occur after the command is completed, including output triggering if enabled and autoreloading the registers, but it will only perfrom a link to the next command when CMDRESTARTCNT == 0. When CMDRESTARTCNT and CMDRESTARTINF are both set to '0', autorestart is disabled. RESET:0x0"
          
         bitfld.long 0x00 16. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_AUTOCFG_CMDRESTARTINFEN ,Enable Infinite Automatic Command Restart. When set, CMDRESTARTCNT is ignored and the command is always restarted after it is completed, including output triggering if enabled and autoreloading the registers but it will not perform a link to the next command. This means that the infinite loop of automatic restarts can only be broken by DISABLECMD or STOPCMD. When CMDRESTARTINFEN is set to '0', then the autorestarting of a command depends on CMDRESTARTCNT and when that counter is set to 0 the autorestarting is finished. In this case the next linked command is read or the command is complete. RESET:0x0"
          
         hexmask.long 0x00 17.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_AUTOCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1078++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_LINKADDR, Channel Link Address Register  This register sets the 32-bit address of the next element in a command link. When the command execution is finished and this register is set then the DMA channel starts loading the next command from this address.  The content of this register can be updated during command linking by setting bit[30] in the command link header. RESET:0x0"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_LINKADDR_LINKADDREN ,Enable Link Address. When set to '1', the DMAC fetches the next command defined by LINKADDR. When set to '0' the DMAC will return to idle at the end of the current command.  NOTE: the linked command fetched by the DMAC needs to clear this field to mark the end of the command chain. Otherwise it may result in an infinite loop of the same command. RESET:0x0"
          
         bitfld.long 0x00 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_LINKADDR_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_LINKADDR_LINKADDR ,Link Address Pointer [31:2]. The DMAC fetches the next command from this address if LINKADDREN is set. NOTE: Commands are fetched with the security and privilege attribute of the channel and cannot be adjusted for the command link reads. RESET:0x0"
          
group.long  0x107c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_LINKADDRHI, Channel Link Address Register, High Bits [63:32]  This register sets the upper address bits of the next element in a command link.  The content of this register can be updated during command linking by setting bit[31] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_LINKADDRHI_LINKADDRHI ,Link Address Pointer [63:32]. Allows 64-bit addressing but the system might need less address bits. Limited by ADDR_WIDTH and the not implemented bits remain reserved. RESET:0x0"
          
group.long  0x1088++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_WRKREGPTR, Channel Working Register Pointer Register  This register can be used to select an internal work register of the DMA channel that will be visible in the CH_WRKREGVAL register. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_WRKREGPTR_WRKREGPTR ,Internal Working Register Pointer. These pointer refers to the following:  - 0: Reserved  - 1: SRCADDR_INITIAL  - 2: SRCADDRHI_INITIAL  - 3: DESADDR_INITIAL  - 4: DESADDRHI_INITIAL  - 5: SRCXSIZEHI_INITIAL, SRCXSIZE_INITIAL  - 6: DESXSIZEHI_INITIAL, DESXSIZE_INITIAL  - 7: SRCADDR_LINEINITIAL  - 8: SRCADDRHI_LINEINITIAL  - 9: DESADDR_LINEINITIAL  - 10: DESADDRHI_LINEINITIAL  - 11: SRCYSIZE_INITIAL (HAS_2D only)  - 12: DESYSIZE_INITIAL (HAS_2D only)  - Others: Reserved. NOTE: When the selected register is not supported by the DMA then it is read as 0 in the CH_WRKREGVAL register. For 1D modes the INITIAL and LINEINITIAL registers contain the same values. RESET:0x0"
          
         hexmask.long 0x00 4.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_WRKREGPTR_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0x108c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_WRKREGVAL, Channel - Working Register Value Register  This register shows the internal value of a work register of the DMA channel selected by the CH_WRKREGPTR register. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_WRKREGVAL_WRKREGVAL ,Internal Working Register Values. WRKREGPTR points to the register that is visible here. The values are only guaranteed to be stable for the current command when STAT_PAUSED is asserted, otherwise they depend on the current status of the channel which makes them UNPREDICTABLE. RESET:0x0"
          
rgroup.long 0x1090++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_ERRINFO, Channel Error Information Register  This register provides information about internal errors encountered during command exectuion by the DMA channel. RESET:0x0"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_ERRINFO_BUSERR ,Bus Error Flag. Set when the DMA encounters a bus error during data or command read transfers. RESET:0x0"
          
         bitfld.long 0x00 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_ERRINFO_CFGERR ,Configuration Error Flag. Set when the DMA command is enabled or a linked command is read but it is configured in a mode that is not supported by the implementation. RESET:0x0"
          
         bitfld.long 0x00 2. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_ERRINFO_SRCTRIGINSELERR ,Source Trigger Input Selection Error Flag. Set when the command selects a source trigger input that is not allowed for this channel. RESET:0x0"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_ERRINFO_DESTRIGINSELERR ,Destination Trigger Input Selection Error Flag. Set when the command selects a destination trigger input that is not allowed for this channel. RESET:0x0"
          
         bitfld.long 0x00 4. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_ERRINFO_TRIGOUTSELERR ,Trigger Output Selection Error Flag. Set when the command selects a trigger output that is not allowed for this channel. RESET:0x0"
          
         hexmask.long 0x00 5.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_ERRINFO_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_ERRINFO_ERRINFO ,Error information Register. Additional information for the error that is encountered by the DMA. The meaning of the bits are detailed in the Error Handling section. RESET:0x0"
          
rgroup.long 0x10c8++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_IIDR, Channel Implementation Identification Register  This register provides information about the revision of the product implementing the DMA channel. RESET:0x3a00043b"
         hexmask.long 0x00 0.--11. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_IIDR_IMPLEMENTER ,Contains the JEP106 code of the company that implemented the IP:  - [11:8]: JEP106 continuation code of implementer.  - [7]: Always 0.  - [6:0]: JEP106 identity code of implementer. For Arm this field reads as 0x43B. RESET:0x43b"
          
         hexmask.long 0x00 12.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_IIDR_REVISION ,Indicates the minor revision of the product rxpy identifier RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_IIDR_VARIANT ,Indicates the major revision, or variant, of the product rxpy identifier RESET:0x0"
          
         hexmask.long 0x00 20.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_IIDR_PRODUCTID ,Indicates the product ID RESET:0x3a0"
          
rgroup.long 0x10cc++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_AIDR, Channel Architecture Identification Register  This register provides information about the architecture version supported by the DMA channel. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_AIDR_ARCH_MINOR_REV ,Architecture Minor Revision. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_AIDR_ARCH_MAJOR_REV ,Architecture Major Revision. RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_AIDR_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x10e8++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_ISSUECAP, Used for setting issuing capability threshold. RESET:0x7"
         hexmask.long 0x00 0.--2. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_ISSUECAP_ISSUECAP ,ISSUECAP can be used by software to place a constraint on allowed issuing capability in both read and write direction. RESET:0x7"
          
         hexmask.long 0x00 3.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_ISSUECAP_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0x10f8++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG0, Channel Build Configuration and Capability Register 0  This register contains the configuration parameters can capabilities of the DMA channel. RESET:0x3d27000f"
         hexmask.long 0x00 0.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG0_DATA_BUFF_SIZE ,Data Buffer Size in entries - 1. Total Size = ((DATA_BUFF_SIZE + 1) * DATA_WIDTH /8) bytes. RESET:0xf"
          
         hexmask.long 0x00 8.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG0_CMD_BUFF_SIZE ,Command Buffer Size in command words - 1. Total Size = (CMD_BUFF_SIZE + 1) * 4 bytes. RESET:0x0"
          
         hexmask.long 0x00 16.--21. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG0_ADDR_WIDTH ,Address Width in bits = ADDR_WIDTH + 1 RESET:0x27"
          
         hexmask.long 0x00 22.--24. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG0_DATA_WIDTH ,Data Width. - 000: 8-bit - 001: 16-bit - 010: 32-bit - 011: 64-bit - 100: 128-bit - 101: 256-bit - 110: 512-bit - 111: 1024-bit RESET:0x4"
          
         bitfld.long 0x00 25. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG0_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 26.--29. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG0_INC_WIDTH ,Width of the increment register = INC_WIDTH + 1. When set to 0, then only 0 and 1 can be set as an increment. When larger values are used, then negative increments can be set using 2's complement: INC_WIDTH = 0: 0..1 INC_WIDTH = 1: -2..1 INC_WIDTH = 2: -4..3 INC_WIDTH = 3: -8..7 … INC_WIDTH = 15: -32768..32767 RESET:0xf"
          
         hexmask.long 0x00 30.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG0_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0x10fc++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1, Channel Build Configuration and Capability Register 1  This register contains the configuration parameters can capabilities of the DMA channel. RESET:0x79f"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_HAS_XSIZEHI ,Has 32-bit XSIZE counters. RESET:0x1"
          
         bitfld.long 0x00 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_HAS_WRAP ,Has wrap capability. RESET:0x1"
          
         bitfld.long 0x00 2. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_HAS_2D ,Has 2D capability. RESET:0x1"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_HAS_TMPLT ,Has template based pack and unpack capability. RESET:0x1"
          
         bitfld.long 0x00 4. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_HAS_TRIG ,Has trigger capability. RESET:0x1"
          
         bitfld.long 0x00 5. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_HAS_TRIGIN ,Has hardware trigger input ports. RESET:0x0"
          
         bitfld.long 0x00 6. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_HAS_TRIGOUT ,Has hardware trigger output port. RESET:0x0"
          
         bitfld.long 0x00 7. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_HAS_TRIGSEL ,Has selectable triggers. RESET:0x1"
          
         bitfld.long 0x00 8. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_HAS_CMDLINK ,Has command link list capability. RESET:0x1"
          
         bitfld.long 0x00 9. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_HAS_AUTO ,Has automatic reload and restart capability. RESET:0x1"
          
         bitfld.long 0x00 10. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_HAS_WRKREG ,Has internal register view capability. RESET:0x1"
          
         bitfld.long 0x00 11. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_HAS_STREAM ,Has stream interface support. RESET:0x0"
          
         bitfld.long 0x00 12. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_HAS_STREAMSEL ,Has selectable stream interfaces. RESET:0x0"
          
         hexmask.long 0x00 13.--17. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 18. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_HAS_GPOSEL ,Has shared GPO ports between channels. RESET:0x0"
          
         hexmask.long 0x00 19.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH0_CH_BUILDCFG1_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1100++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CMD, Channel DMA Command Register  This register allows the SW to control the operation of a DMA command. RESET:0x0"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CMD_ENABLECMD ,Channel Enable. When set to '1', enables the channel to run its programmed task. When set to '1', it cannot be set back to zero, and this field will automatically clear to zero when a DMA process is completed. To force the DMA to stop prematurely, you must use CH_CMD.STOPCMD instead. RESET:0x0"
          
         bitfld.long 0x00 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CMD_CLEARCMD ,DMA Clear command. When set to '1', it will remain high until all DMA channel registers and any internal queues and buffers are cleared, before returning to '0'. When set at the same time as ENABLECMD or while the DMA channel is already enabled, the clear will only occur after any ongoing DMA operation is either completed, stopped or disabled and the ENABLECMD bit is deasserted by the DMA. RESET:0x0"
          
         bitfld.long 0x00 2. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CMD_DISABLECMD ,Disable DMA Operation at the end of the current DMA command operation. Once set to '1', this field will stay high and the current DMA command will be allowed to complete, but the DMA will not fetch the next linked command or will it auto-restart the DMA command even if they are set. Once the DMA has stopped, it will return to '0' and ENABLECMD is also cleared. When set at the same time as ENABLECMD or when the channel is not enabled then write to this register is ignored. RESET:0x0"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CMD_STOPCMD ,Stop Current DMA Operation. Once set to '1', his will remain high until the DMA channel is stopped cleanly. Then this will return to '0' and ENABLECMD is also cleared. When set at the same time as ENABLECMD or when the channel is not enabled then write to this register is ignored. Note that each DMA channel can have other sources of a stop request and this field will not reflect the state of the other sources. RESET:0x0"
          
         bitfld.long 0x00 4. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CMD_PAUSECMD ,Pause Current DMA Operation. Once set to '1' the status cannot change until the DMA operation reached the paused state indicated by the STAT_PAUSED and STAT_RESUMEWAIT bits. The bit can be set by SW by writing it to '1', the current active DMA operation will be paused as soon as possible, but the ENABLECMD bit will remain HIGH to show that the operation is still active.  Cleared automatically when STAT_RESUMEWAIT is set and the RESUMECMD bit is written to '1', meaning that the SW continues the operation of the channel. Note that each DMA channel can have other sources of a pause request and this field will not reflect the state of the other sources. When set at the same time as ENABLECMD or when the channel is not enabled then write to this register is ignored. RESET:0x0"
          
         bitfld.long 0x00 5. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CMD_RESUMECMD ,Resume Current DMA Operation. Writing this bit to '1' means that the DMAC can continue the operation of a paused channel. Can be set to '1' when the PAUSECMD or a STAT_DONE assertion with DONEPAUSEEN set HIGH results in pausing the current DMA channel operation indicated by the STAT_PAUSED and STAT_RESUMEWAIT bits. Otherwise, writes to this bit are ignored. RESET:0x0"
          
         hexmask.long 0x00 6.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CMD_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 16. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CMD_SRCSWTRIGINREQ ,Software Generated Source Trigger Input Request. Write to '1' to create a SW trigger request to the DMA with the specified type in the SRCSWTRIGINTYPE register. Once set to '1', this will remain high until the DMA accepted the trigger and will return this to '0'. It will also be cleared automatically if the current command is completed without expecting another trigger event. When the channel is not enabled, write to this register is ignored. RESET:0x0"
          
         hexmask.long 0x00 17.--19. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CMD_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 20. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CMD_DESSWTRIGINREQ ,Software Generated Destination Trigger Input Request. Write to '1' to create a SW trigger request to the DMA with the specified type in the DESSWTRIGINTYPE register. Once set to '1', this will remain high until the DMA is accepted the trigger and will return this to '0'. It will also be cleared automatically if the current command is completed without expecting another trigger event. When the channel is not enabled, write to this register is ignored. RESET:0x0"
          
         hexmask.long 0x00 21.--23. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CMD_RAZWI_2 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 24. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CMD_SWTRIGOUTACK ,Software Generated Trigger Output Acknowledge. Write '1' to acknowledge a Trigger Output request from the DMA. Once set to '1', this will remain high until the DMA Trigger Output is raised (either on the trigger output signal or as an interrupt) and the acknowledge is accepted. When the channel is not enabled, write to this register is ignored. RESET:0x0"
          
         hexmask.long 0x00 25.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CMD_RAZWI_3 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1104++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS, Channel Status Register  This register shows the internal status of the DMA command and also reports interrupts about internal events. RESET:0x0"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_INTR_DONE ,Done Interrupt Flag. This interrupt will be set to HIGH if the INTREN_DONE is set and the STAT_DONE status flag gets raised. Automatically cleared when STAT_DONE is cleared. RESET:0x0"
          
         bitfld.long 0x00 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_INTR_ERR ,Error Interrupt Flag. This interrupt will be set to HIGH if the INTREN_ERR is set and the STAT_ERR status flag gets raised. Automatically cleared when STAT_ERR is cleared. RESET:0x0"
          
         bitfld.long 0x00 2. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_INTR_DISABLED ,Disabled Interrupt Flag. This interrupt will be set to HIGH if the INTREN_DISABLED is set and the STAT_DISABLED flag gets raised. Automatically cleared when STAT_DISABLED is cleared. RESET:0x0"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_INTR_STOPPED ,Stopped Interrupt Flag. This interrupt will be set to HIGH if the INTREN_STOPPED is set and the STAT_STOPPED flag gets raised. Automatically cleared when STAT_STOPPED is cleared. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 8. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_INTR_SRCTRIGINWAIT ,Channel is waiting for Source Trigger Interrupt Flag. This interrupt will be set to HIGH if the INTREN_SRCTRIGINWAIT is set and the STAT_SRCTRIGINWAIT status flag is asserted. Automatically cleared when STAT_SRCTRIGINWAIT is cleared. RESET:0x0"
          
         bitfld.long 0x00 9. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_INTR_DESTRIGINWAIT ,Channel is waiting for Destination Trigger Interrupt Flag. This interrupt will be set to HIGH if the INTREN_DESTRIGINWAIT is set and the STAT_DESTRIGINWAIT status flag is asserted. Automatically cleared when STAT_DESTRIGINWAIT is cleared. RESET:0x0"
          
         bitfld.long 0x00 10. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_INTR_TRIGOUTACKWAIT ,Channel is waiting for output Trigger Acknowledgement Interrupt Flag.  This interrupt will be set to HIGH if the INTREN_TRIGOUTACKWAIT is set and the STAT_TRIGOUTACKWAIT status flag is asserted. Automatically cleared when STAT_TRIGOUTACKWAIT is cleared. RESET:0x0"
          
         hexmask.long 0x00 11.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 16. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_STAT_DONE ,Done Status Flag. This flag will be set to HIGH when the DMA command reaches the state defined by the DONETYPE settings. When DONEPAUSEEN is set the DMA command operation is paused when this flag is asserted. Write '1' to this bit to clear it. Automatically cleared when the ENABLECMD is set. RESET:0x0"
          
         bitfld.long 0x00 17. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_STAT_ERR ,Error Status Flag. This flag will be set to HIGH if the DMA encounters an error during its operation. The details about the error event can be found in the ERRINFO register. Write '1' to this bit to clear it. When cleared, it also clears the ERRINFO register. Automatically cleared when the ENABLECMD is set. RESET:0x0"
          
         bitfld.long 0x00 18. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_STAT_DISABLED ,Disabled Status Flag. This flag will be set to HIGH if the DMA channel is successfully disabled using the DISABLECMD command. Write '1' to this bit to clear it. Automatically cleared when the ENABLECMD is set. RESET:0x0"
          
         bitfld.long 0x00 19. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_STAT_STOPPED ,Stopped Status Flag. This flag will be set to HIGH if the DMA channel successfully reached the stopped state. The stop request can come from many internal or external sources. Write '1' to this bit to clear it. Automatically cleared when the ENABLECMD is set. RESET:0x0"
          
         bitfld.long 0x00 20. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_STAT_PAUSED ,Paused Status Flag. This flag will be set to HIGH if the DMA channel successfully paused the operation of the command. The pause request can come from many internal or external sources. When the request to pause is not asserted anymore the bit will be cleared automatically and the command operation can continue. RESET:0x0"
          
         bitfld.long 0x00 21. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_STAT_RESUMEWAIT ,Waiting for resume from software Flag. This flag indicates that the DMA channel successfully paused the operation of the command and needs SW acknowledgment to resume the operation. Will be set to HIGH if STAT_PAUSED is asserted and the PAUSECMD bit set in the command register or when the STAT_DONE is asserted and the DONEPAUSEEN bit is set. Cleared when the RESUMECMD bit is set in the command register. RESET:0x0"
          
         hexmask.long 0x00 22.--23. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_RAZWI_2 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 24. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_STAT_SRCTRIGINWAIT ,Channel is waiting for Source Trigger Status. This bit is set to HIGH when DMA channel starts waiting for source input trigger request. Automatically cleared when the source trigger request is received either from HW or SW source. RESET:0x0"
          
         bitfld.long 0x00 25. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_STAT_DESTRIGINWAIT ,Channel is waiting for Destination Trigger Status. This bit is set to HIGH when DMA channel starts waiting for destination input trigger request. Automatically cleared when the destination trigger request is received either from HW or SW source. RESET:0x0"
          
         bitfld.long 0x00 26. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_STAT_TRIGOUTACKWAIT ,Channel is waiting for output Trigger Acknowledgement Status. This bit is set to HIGH when DMA channel starts waiting for output trigger acknowledgement. Automatically cleared when the output trigger acknowledgement is received either from HW or SW source. RESET:0x0"
          
         hexmask.long 0x00 27.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_STATUS_RAZWI_3 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1108++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_INTREN, Channel Interrupt Enable Register  This register can enable the interrupt generation for internal events.  The content of this register can be updated during command linking by setting bit[2] in the command link header. RESET:0x0"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_INTREN_INTREN_DONE ,Done Interrupt Enable. When set to HIGH, enables the INTR_DONE to be set and raise an interrupt when the STAT_DONE status flag is asserted. When set to LOW, it prevents INTR_DONE to be asserted. Currently pending interrupts are not affected by clearing this bit. RESET:0x0"
          
         bitfld.long 0x00 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_INTREN_INTREN_ERR ,Error Interrupt Enable. When set to HIGH, enables INTR_ERROR to be set and raise an interrupt when the STAT_ERR status flag is asserted. When set to LOW, it prevents INTR_ERR to be asserted. Currently pending interrupts are not affected by clearing this bit. RESET:0x0"
          
         bitfld.long 0x00 2. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_INTREN_INTREN_DISABLED ,Disabled Interrupt Enable. When set to HIGH, enables INTR_DISABLED to be set and raise an interrupt when STAT_DISABLED status flag is asserted. When set to LOW, it prevents INTR_DISABLED to be asserted. Currently pending interrupts are not affected by clearing this bit. RESET:0x0"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_INTREN_INTREN_STOPPED ,Stopped Interrupt Enable. When set to HIGH, enables INTR_STOPPED to be set and raise an interrupt when STAT_STOPPED status flag is asserted. When set to LOW, it prevents INTR_STOPPED to be asserted. Currently pending interrupts are not affected by clearing this bit. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_INTREN_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 8. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_INTREN_INTREN_SRCTRIGINWAIT ,Channel is waiting for Source Trigger Interrupt Enable. When set to HIGH, enables INTR_SRCTRIGINWAIT to be set and raise an interrupt when STAT_SRCTRIGINWAIT status flag is asserted. When set to LOW, it prevents INTR_SRCTRIGINWAIT to be asserted. Currently pending interrupts are not affected by clearing this bit. RESET:0x0"
          
         bitfld.long 0x00 9. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_INTREN_INTREN_DESTRIGINWAIT ,Channel is waiting for destination Trigger Interrupt Enable. When set to HIGH, enables INTR_DESTRIGINWAIT to be set and raise an interrupt when STAT_DESTRIGINWAIT status flag is asserted. When set to LOW, it prevents INTR_DESTRIGINWAIT to be asserted. Currently pending interrupts are not affected by clearing this bit. RESET:0x0"
          
         bitfld.long 0x00 10. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_INTREN_INTREN_TRIGOUTACKWAIT ,Channel is waiting for output Trigger Acknowledgement Interrupt Enable. When set to HIGH, enables INTR_TRIGOUTACKWAIT to be set and raise an interrupt when STAT_TRIGOUTACKWAIT status flag is asserted. When set to LOW, it prevents INTR_TRIGOUTACKWAIT to be asserted. Currently pending interrupts are not affected by clearing this bit. RESET:0x0"
          
         hexmask.long 0x00 11.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_INTREN_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x110c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL, Channel Control Register  This register can be used to configure the type of the transfers and the resources needed by the currently executed DMA command. It also defines how the command shall behave when the command is complete. The content of this register can be updated during command linking by setting bit[3] in the command link header. RESET:0x200200"
         hexmask.long 0x00 0.--2. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL_TRANSIZE ,Transfer Entity Size. Size in bytes = 2^TRANSIZE.  - 000: Byte  - 001: Halfworld  - 010: Word  - 011: Doubleword  - 100: 128bits  - 101: 256bits  - 110: 512bits  - 111: 1024bits Note that DATA_WIDTH limits this field. Address will be aligned to TRANSIZE by the DMAC by ignoring the lower bits. RESET:0x0"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL_CHPRIO ,Channel Priority. - 0: Lowest Priority - 15: Highest Priority RESET:0x0"
          
         bitfld.long 0x00 8. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 9.--11. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL_XTYPE ,Operation type for X direction: - 000: 'disable' - No data transfer will take place for this command. This mode can be used to create empty commands that wait for an event or set GPOs. - 001: 'continue' - Copy data in a continuous manner from source to the destination. For 1D operations it is expected that SRCXSIZE is equal to DESXSIZE, other combinations result in UNPREDICTABLE behavior. For 2D operations, this mode can be used for simple 2D to 2D copy but it also allows the reshaping of the data like 1D to 2D or 2D to 1D conversions. If the DESXSIZE is smaller than SRCXSIZE then the read data from the current source line goes to the next destination line. If SRCXSIZE is smaller than DESXSIZE then the reads start on the next line and data is written to the remainder of the current destination line. Note: For 1D to 2D the SRCYSIZE for 2D to 1D conversion the DESYSIZE needs to be set to 1 when using this mode. - 010: 'wrap' - Wrap source data within a destination line when the end of the source line is reached. Read starts again from the beginning of the source line and copied to the remainder of the destination line. If the DESXSIZE is smaller than SRCXSIZE then the behavior is UNPREDICTABLE. Not supported when HAS_WRAP is 0 in HW - 011: 'fill' - Fill the remainder of the destination line with FILLVAL when the end of the source line is reached. If the DESXSIZE is smaller than SRCXSIZE then the behavior is UNPREDICTABLE. Not supported when HAS_WRAP is 0 in HW. - Others: Reserved. RESET:0x1"
          
         hexmask.long 0x00 12.--14. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL_YTYPE ,Operation type for Y direction: - 000: 'disable' - Only do 1D transfers. When HAS_2D is 0, meaning 2D capability is not supported in HW, the YTYPE is always '000'. - 001: 'continue' - Copy 2D data in a continuous manner from source area to the destination area by using the YSIZE registers. The copy stops when the source runs out of data or the destination runs out of space. Not supported when HAS_2D is 0 in HW. - 010: 'wrap' - Wrap the 2D source area within the destination 2D area by starting to copy data from the beginning of the first source line to the remaining space in the destination area. If the destination area is smaller than the source area then the behavior is UNPREDICTABLE. Not supported when HAS_WRAP or HAS_2D is 0 in HW. - 011:  Fill the remainder of the destination area with FILLVAL when the source area runs out of data. If the destination area is smaller than the source area then the behavior is UNPREDICTABLE. Not supported when HAS_WRAP or HAS_2D is 0 in HW - Others: Reserved RESET:0x0"
          
         hexmask.long 0x00 15.--17. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL_RAZWI_2 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 18.--20. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL_REGRELOADTYPE ,Automatic register reload type. Defines how the DMA command reloads initial values at the end of a DMA command before autorestarting, ending or linking to a new DMA command:  - 000: Reload Disabled.  - 001: Reload source and destination size registers only.  - 011: Reload source address only and all source and destination size registers.  - 101: Reload destination address only and all source and destination size registers.  - 111: Reload source and destination address and all source and destination size registers.  - Others: Reserved. NOTE: When CLEARCMD is set, the reloaded registers will also be cleared. RESET:0x0"
          
         hexmask.long 0x00 21.--23. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL_DONETYPE ,Done type selection. This field defines when the STAT_DONE status flag is asserted during the command operation. - 000: STAT_DONE flag is not asserted for this command. - 001: End of a command, before jumping to the next linked command. (default) - 011: End of an autorestart cycle, before starting the next cycle. - Others : Reserved. RESET:0x1"
          
         bitfld.long 0x00 24. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL_DONEPAUSEEN ,Done pause enable. When set to HIGH the assertion of the STAT_DONE flag results in an automatic pause request for the current DMA operation. When the paused state is reached the STAT_RESUMEWAIT flag is also set. When set to LOW the assertion of the STAT_DONE does not pause the progress of the command and the next operation of the channel will be started immediately after the STAT_DONE flag is set. RESET:0x0"
          
         bitfld.long 0x00 25. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL_USESRCTRIGIN ,Enable Source Trigger Input use for this command. - 0: disable - 1: enable RESET:0x0"
          
         bitfld.long 0x00 26. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL_USEDESTRIGIN ,Enable Destination Trigger Input use for this command. - 0: disable - 1: enable RESET:0x0"
          
         bitfld.long 0x00 27. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL_USETRIGOUT ,Enable Trigger Output use for this command. - 0: disable - 1: enable RESET:0x0"
          
         hexmask.long 0x00 28.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_CTRL_RAZWI_3 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1110++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCADDR, Channel Source Address Register  This register defines the 32-bit base address of the command to read the data from. When the register is read during the execution of the command it shows the actual address the DMA channel is going to read from.  The content of this register can be updated during command linking by setting bit[4] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCADDR_SRCADDR ,Source Address [31:0]. RESET:0x0"
          
group.long  0x1114++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCADDRHI, Channel Source Address Register High Bits [63:32]  This register defines the upper 32 bits of the read address in case more than 32-bit addressing is used in the system. When the register is read during the execution of the command it shows the actual address the DMA channel is going to read from.  The content of this register can be updated during command linking by setting bit[5] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCADDRHI_SRCADDRHI ,Source Address [63:32]. Allows 64-bit addressing but the system might need less address bits defined by ADDR_WIDTH. The not implemented bits remain reserved. RESET:0x0"
          
group.long  0x1118++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESADDR, Channel Destination Address Register  This register defines the 32-bit base address of the command to write the data to. When the register is read during the execution of the command it shows the actual address the DMA channel is going to write to.  The content of this register can be updated during command linking by setting bit[6] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESADDR_DESADDR ,Destination Address[31:0] RESET:0x0"
          
group.long  0x111c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESADDRHI, Channel Destination Address Register, High Bits [63:32]  This register defines the upper 32 bits of the write address in case more than 32-bit addressing is used in the system. When the register is read during the execution of the command it shows the actual address the DMA channel is going to write to.  The content of this register can be updated during command linking by setting bit[7] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESADDRHI_DESADDRHI ,Destination Address[63:32]. Allows 64-bit addressing but the system might need less address bits defined by ADDR_WIDTH. The not implemented bits remain reserved. RESET:0x0"
          
group.long  0x1120++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_XSIZE, Channel X Dimension Size Register, Lower Bits [15:0]  This register defines the number of data units copied during the DMA command up to 16 bits in the X dimension. The source and destination size of the command may be different for some transfer types. When read during the execution of the DMA command, the register shows the remaining number of units in both read and write directions.  The content of this register can be updated during command linking by setting bit[8] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_XSIZE_SRCXSIZE ,Source Number of Transfers in the X Dimension lower bits [15:0]. This register along with SRCXSIZEHI defines the source data block size of the DMA operation for any 1D operation, and defines the X dimension of the 2D source block for 2D operation. RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_XSIZE_DESXSIZE ,Destination Number of Transfers in the X Dimension lower bits [15:0]. This register along with DESXSIZEHI defines the destination data block size of the DMA operation for or any 1D operation, and defines the X dimension of the 2D destination block for a 2D operation. HAS_WRAP or HAS_STREAM configuration needs to be set to allow writes to this register, otherwise it is read-only and writing to SRCXSIZE will also update the value of this register. RESET:0x0"
          
group.long  0x1124++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_XSIZEHI, Channel X Dimension Size Register, High Bits [31:16]  This register defines the number of data units copied during the DMA command up to 32 bits in the X dimension. The source and destination size of the command may be different for some transfer types. When read during the execution of the DMA command, the register shows the higher bits of the remaining number of units in both read and write directions.  The content of this register can be updated during command linking by setting bit[9] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_XSIZEHI_SRCXSIZEHI ,Source Number of Transfers in the X Dimension high bits [31:16]. This register along with SRCXSIZE defines the source data block size of the DMA operation for any 1D operation, and defines the X dimension of the 2D source block for 2D operation. RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_XSIZEHI_DESXSIZEHI ,Destination Number of Transfers in the X Dimension high bits [31:16]. This register along with DESXSIZE defines the destination data block size of the DMA operation for or any 1D operation, and defines the X dimension of the 2D destination block for a 2D operation. HAS_WRAP or HAS_STREAM configuration needs to be set to allow writes to this register, otherwise it is read-only and writing to SRCXSIZEHI will also update the value of this register. RESET:0x0"
          
group.long  0x1128++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTRANSCFG, Channel Source Transfer Configuration Register  This register provides transfer attribute settings in the read direction of the DMA command.  The content of this register can be updated during command linking by setting bit[10] in the command link header. RESET:0xf0400"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTRANSCFG_SRCMEMATTRLO ,Source Transfer Memory Attribute field [3:0]. When SRCMEMATTRHI is Device type (0000) then this field means:  - 0000: Device-nGnRnE  - 0100: Device-nGnRE  - 1000: Device-nGRE  - 1100: Device-GRE  - Others: Invalid resulting in UNPREDICTABLE behavior When SRCMEMATTRHI is Normal memory type (other than 0000) then this field means:  - 0000: Reserved  - 0001: Normal memory, Inner Write allocate, Inner Write-through transient  - 0010: Normal memory, Inner Read allocate, Inner Write-through transient  - 0011: Normal memory, Inner Read/Write allocate, Inner Write-through transient  - 0100: Normal memory, Inner non-cacheable  - 0101: Normal memory, Inner Write allocate, Inner Write-back transient  - 0110: Normal memory, Inner Read allocate, Inner Write-back transient  - 0111: Normal memory, Inner Read/Write allocate, Inner Write-back transient  - 1000: Normal memory, Inner Write-through non-transient  - 1001: Normal memory, Inner Write allocate, Inner Write-through non-transient  - 1010: Normal memory, Inner Read allocate, Inner Write-through non-transient  - 1011: Normal memory, Inner Read/Write allocate, Inner Write-through non-transient  - 1100: Normal memory, Inner Write-back non-transient  - 1101: Normal memory, Inner Write allocate, Inner Write-back non-transient  - 1110: Normal memory, Inner Read allocate, Inner Write-back non-transient  - 1111: Normal memory, Inner Read/Write allocate, Inner Write-back non-transient RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTRANSCFG_SRCMEMATTRHI ,Source Transfer Memory Attribute field [7:4]. - 0000: Device memory - 0001: Normal memory, Outer Write allocate, Outer Write-through transient - 0010: Normal memory, Outer Read allocate, Outer Write-through transient - 0011: Normal memory, Outer Read/Write allocate, Outer Write-through transient - 0100: Normal memory, Outer non-cacheable - 0101: Normal memory, Outer Write allocate, Outer Write-back transient - 0110: Normal memory, Outer Read allocate, Outer Write-back transient - 0111: Normal memory, Outer Read/Write allocate, Outer Write-back transient - 1000: Normal memory, Outer Write-through non-transient - 1001: Normal memory, Outer Write allocate, Outer Write-through non-transient - 1010: Normal memory, Outer Read allocate, Outer Write-through non-transient - 1011: Normal memory, Outer Read/Write allocate, Outer Write-through non-transient - 1100: Normal memory, Outer Write-back non-transient - 1101: Normal memory, Outer Write allocate, Outer Write-back non-transient - 1110: Normal memory, Outer Read allocate, Outer Write-back non-transient - 1111: Normal memory, Outer Read/Write allocate, Outer Write-back non-transient RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTRANSCFG_SRCSHAREATTR ,Source Transfer Shareability Attribute. - 00: Non-shareable - 01: Reserved - 10: Outer shareable - 11: Inner shareable RESET:0x0"
          
         bitfld.long 0x00 10. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTRANSCFG_SRCNONSECATTR ,Source Transfer Non-secure Attribute. - 0: Secure - 1: Non-secure When a channel is Non-secure this bit is tied to 1. RESET:0x1"
          
         bitfld.long 0x00 11. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTRANSCFG_SRCPRIVATTR ,Source Transfer Privilege Attribute. - 0: Unprivileged - 1: Privileged When a channel is unprivileged this bit is tied to 0. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTRANSCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTRANSCFG_SRCMAXBURSTLEN ,Source Max Burst Length. Hint for the DMA on what is the maximum allowed burst size it can use for read transfers. The maximum number of beats sent by the DMA for a read burst is equal to SRCMAXBURSTLEN + 1. Default value is 16 beats, which allows the DMA to set all burst sizes. Note: Limited by the DATA_BUFF_SIZE so larger settings may not always result in larger bursts. RESET:0xf"
          
         hexmask.long 0x00 20.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTRANSCFG_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x112c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTRANSCFG, Channel Destination Transfer Configuration Register  This register provides transfer attribute settings in the write direction of the DMA command.  The content of this register can be updated during command linking by setting bit[11] in the command link header. RESET:0xf0400"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTRANSCFG_DESMEMATTRLO ,Destination Transfer Memory Attribute field [3:0]. When DESMEMATTRHI is Device type (0000) then this field means:  - 0000: Device-nGnRnE  - 0100: Device-nGnRE  - 1000: Device-nGRE  - 1100: Device-GRE  - Others: Invalid resulting in UNPREDICTABLE behavior When DESMEMATTRHI is Normal Memory type (other than 0000) then this field means:  - 0000: Reserved  - 0001: Normal memory, Inner Write allocate, Inner Write-through transient  - 0010: Normal memory, Inner Read allocate, Inner Write-through transient  - 0011: Normal memory, Inner Read/Write allocate, Inner Write-through transient  - 0100: Normal memory, Inner non-cacheable  - 0101: Normal memory, Inner Write allocate, Inner Write-back transient  - 0110: Normal memory, Inner Read allocate, Inner Write-back transient  - 0111: Normal memory, Inner Read/Write allocate, Inner Write-back transient  - 1000: Normal memory, Inner Write-through non-transient  - 1001: Normal memory, Inner Write allocate, Inner Write-through non-transient  - 1010: Normal memory, Inner Read allocate, Inner Write-through non-transient  - 1011: Normal memory, Inner Read/Write allocate, Inner Write-through non-transient  - 1100: Normal memory, Inner Write-back non-transient  - 1101: Normal memory, Inner Write allocate, Inner Write-back non-transient  - 1110: Normal memory, Inner Read allocate, Inner Write-back non-transient  - 1111: Normal memory, Inner Read/Write allocate, Inner Write-back non-transient RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTRANSCFG_DESMEMATTRHI ,Destination Transfer Memory Attribute field [7:4]. - 0000: Device memory - 0001: Normal memory, Outer Write allocate, Outer Write-through transient - 0010: Normal memory, Outer Read allocate, Outer Write-through transient - 0011: Normal memory, Outer Read/Write allocate, Outer Write-through transient - 0100: Normal memory, Outer non-cacheable - 0101: Normal memory, Outer Write allocate, Outer Write-back transient - 0110: Normal memory, Outer Read allocate, Outer Write-back transient - 0111: Normal memory, Outer Read/Write allocate, Outer Write-back transient - 1000: Normal memory, Outer Write-through non-transient - 1001: Normal memory, Outer Write allocate, Outer Write-through non-transient - 1010: Normal memory, Outer Read allocate, Outer Write-through non-transient - 1011: Normal memory, Outer Read/Write allocate, Outer Write-through non-transient - 1100: Normal memory, Outer Write-back non-transient - 1101: Normal memory, Outer Write allocate, Outer Write-back non-transient - 1110: Normal memory, Outer Read allocate, Outer Write-back non-transient - 1111: Normal memory, Outer Read/Write allocate, Outer Write-back non-transient RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTRANSCFG_DESSHAREATTR ,Destination Transfer Shareability Attribute. - 00: Non-shareable - 01: Reserved - 10: Outer shareable - 11: Inner shareable RESET:0x0"
          
         bitfld.long 0x00 10. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTRANSCFG_DESNONSECATTR ,Destination Transfer Non-secure Attribute. - 0: Secure - 1: Non-secure When a channel is Non-secure this bit is tied to 1. RESET:0x1"
          
         bitfld.long 0x00 11. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTRANSCFG_DESPRIVATTR ,Destination Transfer Privilege Attribute. - 0: Unprivileged - 1: Privileged When a channel is unprivileged this bit is tied to 0. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTRANSCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTRANSCFG_DESMAXBURSTLEN ,Destination Max Burst Length. Hint for the DMA on what is the maximum allowed burst size it can use for write transfers. The maximum number of beats sent by the DMA for a write burst is equal to DESMAXBURSTLEN + 1. Default value is 16 beats, which allows the DMA to set all burst sizes. Note: Limited by the DATA_BUFF_SIZE so larger settings may not always result in larger bursts. RESET:0xf"
          
         hexmask.long 0x00 20.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTRANSCFG_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1130++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_XADDRINC, Channel X Dimension Address Increment Register  This register sets the increment values used to update the source and destination addresses after each transferred data unit.  The content of this register can be updated during command linking by setting bit[12] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_XADDRINC_SRCXADDRINC ,Source X dimension Address Increment. This value is used as the increment between each TRANSIZE transfer. When a single bit is used then only 0 and 1 can be set. For wider increment registers, two's complement used with a range between -32768 to 32767 when the counter is 16-bits wide. The width of the register is indicated by the INC_WIDTH parameter. SRCADDR_next = SRCADDR + 2^TRANSIZE * SRCXADDRINC RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_XADDRINC_DESXADDRINC ,Destination X dimension Address Increment. This value is used as the increment between each TRANSIZE transfer. When a single bit is used then only 0 and 1 can be set. For wider increment registers, two's complement used with a range between -32768 to 32767 when the counter is 16-bits wide. The width of the register is indicated by the INC_WIDTH parameter. DESADDR_next = DESADDR + 2^TRANSIZE * DESXADDRINC RESET:0x0"
          
group.long  0x1134++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_YADDRSTRIDE, Channel Y Dimension Address Stride Register  This register sets the increment values used to update the source and destination line base addresses after each line is transferred.  The content of this register can be updated during command linking by setting bit[13] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_YADDRSTRIDE_SRCYADDRSTRIDE ,Source Address Stride between lines. Calculated in TRANSIZE aligned steps. This value is used to increment the SRCADDR after completing the transfer of a source line. SRCADDR_next_line_base = SRCADDR_line_base + 2^TRANSIZE * SRCYADDRSTRIDE. Two's complement used with a range between -32768 to 32767. When set to 0 the SRCADDR is not incremented after completing one line. Not present when HAS_2D is 0. RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_YADDRSTRIDE_DESYADDRSTRIDE ,Destination Address Stride between lines. Calculated in TRANSIZE aligned steps. This value is used to increment the DESADDR after completing the transfer of a destination line. DESADDR_next_line_base = DESADDR_line_base + 2^TRANSIZE * DESYADDRSTRIDE. Two's complement used with a range between -32768 to 32767. When set to 0 the DESADDR is not incremented after completing one line. Not present when HAS_2D is 0. RESET:0x0"
          
group.long  0x1138++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_FILLVAL, Channel Fill Pattern Value Register  This register provides a predefined value to be used to fill the remaining part of the destination memory area when the source side of the command is finished.  The content of this register can be updated during command linking by setting bit[14] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_FILLVAL_FILLVAL ,Fill pattern value. When XTYPE or YTYPE is set to fill mode, then this register value is used on the write data bus when the command starts to fill the memory area. The TRANSIZE defines the width of the FILLVAL used for the command. For byte transfers the FILLVAL[7:0] is used, other bits are ignored. For halfword transfers the FILLVAL[15:0] is used, other bits are ignored. For 64-bit and wider transfers the FILLVAL[31:0] pattern is repeated on the full width of the data bus. Not present when HAS_WRAP is 0. RESET:0x0"
          
group.long  0x113c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_YSIZE, Channel Y Dimensions Size Register  This register defines the number of lines copied during the DMA command up to 16 bits in the Y dimension. The read and write size of the command may be different for some transfer types. When read during the execution of the DMA command, the register shows the remaining number of lines in both read and write directions.  The content of this register can be updated during command linking by setting bit[15] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_YSIZE_SRCYSIZE ,Source Y dimension or number of lines. Not present when HAS_2D is 0. RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_YSIZE_DESYSIZE ,Destination Y dimension or number of lines. Not present when HAS_2D is 0. HAS_WRAP or HAS_STREAM configuration needs to be set to allow writes to this register, otherwise it is read-only. RESET:0x0"
          
group.long  0x1140++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_TMPLTCFG, Channel Template Configuration Register  This register provides configuration settings when using template pattern based copy operations.  The content of this register can be updated during command linking by setting bit[16] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_TMPLTCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 8.--12. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_TMPLTCFG_SRCTMPLTSIZE ,Source Template Size in number of transfers plus one. - 0: Source template is disabled. - 1 to 31: Bits SRCTMPLT[SRCTMPLTSIZE:0] is used as the source template. Not present when HAS_TMPLT is 0. RESET:0x0"
          
         hexmask.long 0x00 13.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_TMPLTCFG_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 16.--20. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_TMPLTCFG_DESTMPLTSIZE ,Destination Template Size in number of transfers plus one. - 0: Destination template is disabled. - 1 to 31: DESTMPLT[DESTMPLTSIZE:0] is used as the destination template. Not present when HAS_TMPLT is 0. RESET:0x0"
          
         hexmask.long 0x00 21.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_TMPLTCFG_RAZWI_2 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1144++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTMPLT, Channel Source Template Pattern Register  This register sets the template pattern used for reading the source memory area.  The content of this register can be updated during command linking by setting bit[17] in the command link header. RESET:0x1"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTMPLT_SRCTMPLTLSB ,Source Packing Template Least Significant Bit. This bit of the template is read only and always set to 1 as template patterns can only start from the base address of the transfer. Not present when HAS_TMPLT is 0. RESET:0x1"
          
         hexmask.long 0x00 1.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTMPLT_SRCTMPLT ,Source Packing Template. Bit[0] is read only and always set to 1 as template patterns can only start from the base address of the transfer. Not present when HAS_TMPLT is 0. RESET:0x0"
          
group.long  0x1148++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTMPLT, Channel Destination Template Pattern Register  This register sets the template pattern used for writing the destination memory area.  The content of this register can be updated during command linking by setting bit[18] in the command link header. RESET:0x1"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTMPLT_DESTMPLTLSB ,Destination Packing Template Least Significant Bit. This bit of the template is read only and always set to 1 as template patterns can only start from the base address of the transfer. Not present when HAS_TMPLT is 0. RESET:0x1"
          
         hexmask.long 0x00 1.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTMPLT_DESTMPLT ,Destination Packing Template.  Bit[0] is read only and always set to 1 as template patterns can only start from the base address of the transfer. Not present when HAS_TMPLT is 0. RESET:0x0"
          
group.long  0x114c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTRIGINCFG, Channel Source Trigger In Configuration Register  This register provides configuration settings when using source side trigger input for the current DMA command.  The content of this register can be updated during command linking by setting bit[19] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTRIGINCFG_SRCTRIGINSEL ,Source Trigger Input Select RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTRIGINCFG_SRCTRIGINTYPE ,Source Trigger Input Type:  - 00: Software only Trigger Request. SRCTRIGINSEL is ignored.  - 01: Reserved  - 10: HW Trigger Request. Only allowed when HAS_TRIGIN is enabled. SRCTRIGINSEL selects between external trigger inputs if HAS_TRIGSEL is enabled.  - 11: Internal Trigger Request. Only allowed when HAS_TRIGSEL is enabled and the DMAC has multiple channels, otherwise treated as HW Trigger Request. SRCTRIGINSEL selects between DMA channels. Note: SW triggers are also available when HW or Internal types are selected, but is is not recommended and caution must be taken when the these modes are combined. RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTRIGINCFG_SRCTRIGINMODE ,Source Trigger Input Mode:  - 00: Command  - 01: Reserved  - 10: DMA driven Flow control. Only allowed when HAS_TRIGIN is enabled.  - 11: Peripheral driven Flow control. Only allowed when HAS_TRIGIN is enabled. Note: This field is ignored for Internal triggers as they only support Command triggers. RESET:0x0"
          
         hexmask.long 0x00 12.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_SRCTRIGINCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1150++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTRIGINCFG, Channel Destination Trigger In Configuration Register  This register provides configuration settings when using destination side trigger input for the current DMA command.  The content of this register can be updated during command linking by setting bit[20] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTRIGINCFG_DESTRIGINSEL ,Destination Trigger Input Select RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTRIGINCFG_DESTRIGINTYPE ,Destination Trigger Input Type:  - 00: Software only Trigger Request. DESTRIGINSEL is ignored.  - 01: Reserved  - 10: HW Trigger Request. Only allowed when HAS_TRIGIN is enabled. DESTRIGINSEL selects between external trigger inputs if HAS_TRIGSEL is enabled.  - 11: Internal Trigger Request. Only allowed when HAS_TRIGSEL is enabled and the DMAC has multiple channels, otherwise treated as HW Trigger Request. DESTRIGINSEL selects between DMA channels. Note: SW triggers are also available when HW or Internal types are selected, but is is not recommended and caution must be taken when the these modes are combined. RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTRIGINCFG_DESTRIGINMODE ,Destination Trigger Input Mode:  - 00: Command  - 01: Reserved  - 10: DMA driven Flow control. Only allowed when HAS_TRIGIN is enabled.  - 11: Peripheral driven Flow control. Only allowed when HAS_TRIGIN is enabled. Note: This field is ignored for Internal triggers as they only support Command triggers. RESET:0x0"
          
         hexmask.long 0x00 12.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_DESTRIGINCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1154++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_TRIGOUTCFG, Channel Trigger Out Configuration Register  This register provides configuration settings when using trigger output for the current DMA command.  The content of this register can be updated during command linking by setting bit[21] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_TRIGOUTCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_TRIGOUTCFG_TRIGOUTTYPE ,Trigger Output Type - 00: Software only Trigger Acknowledgement. - 01: Reserved - 10: HW Trigger Acknowledgement. Only allowed when HAS_TRIGOUT is enabled. - 11: Internal Trigger Acknowledgement. Only allowed when HAS_TRIGSEL is enabled and the DMAC has multiple channels, otherwise treated as HW Trigger Acknowledgement. RESET:0x0"
          
         hexmask.long 0x00 10.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_TRIGOUTCFG_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1170++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_LINKATTR, Channel Link Address Memory Attributes Register  This register provides transfer attribute settings for the command link related read transfers. The security and privilege attributes cannot be adjusted, they match the attributes of the channel.  The content of this register can be updated during command linking by setting bit[28] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_LINKATTR_LINKMEMATTRLO ,Link Address Read Transfer Memory Attribute field [3:0]. When LINKMEMATTRHI is Device type (0000) then this field means:  - 0000: Device-nGnRnE  - 0100: Device-nGnRE  - 1000: Device-nGRE  - 1100: Device-GRE  - Others: Invalid resulting in UNPREDICTABLE behavior When LINKMEMATTRHI is Normal memory type (other than 0000) then this field means:  - 0000: Reserved  - 0001: Normal memory, Inner Write allocate, Inner Write-through transient  - 0010: Normal memory, Inner Read allocate, Inner Write-through transient  - 0011: Normal memory, Inner Read/Write allocate, Inner Write-through transient  - 0100: Normal memory, Inner non-cacheable  - 0101: Normal memory, Inner Write allocate, Inner Write-back transient  - 0110: Normal memory, Inner Read allocate, Inner Write-back transient  - 0111: Normal memory, Inner Read/Write allocate, Inner Write-back transient  - 1000: Normal memory, Inner Write-through non-transient  - 1001: Normal memory, Inner Write allocate, Inner Write-through non-transient  - 1010: Normal memory, Inner Read allocate, Inner Write-through non-transient  - 1011: Normal memory, Inner Read/Write allocate, Inner Write-through non-transient  - 1100: Normal memory, Inner Write-back non-transient  - 1101: Normal memory, Inner Write allocate, Inner Write-back non-transient  - 1110: Normal memory, Inner Read allocate, Inner Write-back non-transient  - 1111: Normal memory, Inner Read/Write allocate, Inner Write-back non-transient RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_LINKATTR_LINKMEMATTRHI ,Link Address Read Transfer Memory Attribute field [7:4]. - 0000: Device memory - 0001: Normal memory, Outer Write allocate, Outer Write-through transient - 0010: Normal memory, Outer Read allocate, Outer Write-through transient - 0011: Normal memory, Outer Read/Write allocate, Outer Write-through transient - 0100: Normal memory, Outer non-cacheable - 0101: Normal memory, Outer Write allocate, Outer Write-back transient - 0110: Normal memory, Outer Read allocate, Outer Write-back transient - 0111: Normal memory, Outer Read/Write allocate, Outer Write-back transient - 1000: Normal memory, Outer Write-through non-transient - 1001: Normal memory, Outer Write allocate, Outer Write-through non-transient - 1010: Normal memory, Outer Read allocate, Outer Write-through non-transient - 1011: Normal memory, Outer Read/Write allocate, Outer Write-through non-transient - 1100: Normal memory, Outer Write-back non-transient - 1101: Normal memory, Outer Write allocate, Outer Write-back non-transient - 1110: Normal memory, Outer Read allocate, Outer Write-back non-transient - 1111: Normal memory, Outer Read/Write allocate, Outer Write-back non-transient RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_LINKATTR_LINKSHAREATTR ,Link Address Transfer Shareability Attribute. - 00: Non-shareable - 01: Reserved - 10: Outer shareable - 11: Inner shareable RESET:0x0"
          
         hexmask.long 0x00 10.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_LINKATTR_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1174++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_AUTOCFG, Channel Automatic Command Restart Configuration Register  This register configures the automatic restart behavior of the currently running command.  The content of this register can be updated during command linking by setting bit[29] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_AUTOCFG_CMDRESTARTCNT ,Automatic Command Restart Counter. Defines the number of times automatic restarting will occur at end of DMA command. Auto restarting will occur after the command is completed, including output triggering if enabled and autoreloading the registers, but it will only perfrom a link to the next command when CMDRESTARTCNT == 0. When CMDRESTARTCNT and CMDRESTARTINF are both set to '0', autorestart is disabled. RESET:0x0"
          
         bitfld.long 0x00 16. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_AUTOCFG_CMDRESTARTINFEN ,Enable Infinite Automatic Command Restart. When set, CMDRESTARTCNT is ignored and the command is always restarted after it is completed, including output triggering if enabled and autoreloading the registers but it will not perform a link to the next command. This means that the infinite loop of automatic restarts can only be broken by DISABLECMD or STOPCMD. When CMDRESTARTINFEN is set to '0', then the autorestarting of a command depends on CMDRESTARTCNT and when that counter is set to 0 the autorestarting is finished. In this case the next linked command is read or the command is complete. RESET:0x0"
          
         hexmask.long 0x00 17.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_AUTOCFG_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x1178++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_LINKADDR, Channel Link Address Register  This register sets the 32-bit address of the next element in a command link. When the command execution is finished and this register is set then the DMA channel starts loading the next command from this address.  The content of this register can be updated during command linking by setting bit[30] in the command link header. RESET:0x0"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_LINKADDR_LINKADDREN ,Enable Link Address. When set to '1', the DMAC fetches the next command defined by LINKADDR. When set to '0' the DMAC will return to idle at the end of the current command.  NOTE: the linked command fetched by the DMAC needs to clear this field to mark the end of the command chain. Otherwise it may result in an infinite loop of the same command. RESET:0x0"
          
         bitfld.long 0x00 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_LINKADDR_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_LINKADDR_LINKADDR ,Link Address Pointer [31:2]. The DMAC fetches the next command from this address if LINKADDREN is set. NOTE: Commands are fetched with the security and privilege attribute of the channel and cannot be adjusted for the command link reads. RESET:0x0"
          
group.long  0x117c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_LINKADDRHI, Channel Link Address Register, High Bits [63:32]  This register sets the upper address bits of the next element in a command link.  The content of this register can be updated during command linking by setting bit[31] in the command link header. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_LINKADDRHI_LINKADDRHI ,Link Address Pointer [63:32]. Allows 64-bit addressing but the system might need less address bits. Limited by ADDR_WIDTH and the not implemented bits remain reserved. RESET:0x0"
          
group.long  0x1188++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_WRKREGPTR, Channel Working Register Pointer Register  This register can be used to select an internal work register of the DMA channel that will be visible in the CH_WRKREGVAL register. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_WRKREGPTR_WRKREGPTR ,Internal Working Register Pointer. These pointer refers to the following:  - 0: Reserved  - 1: SRCADDR_INITIAL  - 2: SRCADDRHI_INITIAL  - 3: DESADDR_INITIAL  - 4: DESADDRHI_INITIAL  - 5: SRCXSIZEHI_INITIAL, SRCXSIZE_INITIAL  - 6: DESXSIZEHI_INITIAL, DESXSIZE_INITIAL  - 7: SRCADDR_LINEINITIAL  - 8: SRCADDRHI_LINEINITIAL  - 9: DESADDR_LINEINITIAL  - 10: DESADDRHI_LINEINITIAL  - 11: SRCYSIZE_INITIAL (HAS_2D only)  - 12: DESYSIZE_INITIAL (HAS_2D only)  - Others: Reserved. NOTE: When the selected register is not supported by the DMA then it is read as 0 in the CH_WRKREGVAL register. For 1D modes the INITIAL and LINEINITIAL registers contain the same values. RESET:0x0"
          
         hexmask.long 0x00 4.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_WRKREGPTR_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0x118c++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_WRKREGVAL, Channel - Working Register Value Register  This register shows the internal value of a work register of the DMA channel selected by the CH_WRKREGPTR register. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_WRKREGVAL_WRKREGVAL ,Internal Working Register Values. WRKREGPTR points to the register that is visible here. The values are only guaranteed to be stable for the current command when STAT_PAUSED is asserted, otherwise they depend on the current status of the channel which makes them UNPREDICTABLE. RESET:0x0"
          
rgroup.long 0x1190++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_ERRINFO, Channel Error Information Register  This register provides information about internal errors encountered during command exectuion by the DMA channel. RESET:0x0"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_ERRINFO_BUSERR ,Bus Error Flag. Set when the DMA encounters a bus error during data or command read transfers. RESET:0x0"
          
         bitfld.long 0x00 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_ERRINFO_CFGERR ,Configuration Error Flag. Set when the DMA command is enabled or a linked command is read but it is configured in a mode that is not supported by the implementation. RESET:0x0"
          
         bitfld.long 0x00 2. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_ERRINFO_SRCTRIGINSELERR ,Source Trigger Input Selection Error Flag. Set when the command selects a source trigger input that is not allowed for this channel. RESET:0x0"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_ERRINFO_DESTRIGINSELERR ,Destination Trigger Input Selection Error Flag. Set when the command selects a destination trigger input that is not allowed for this channel. RESET:0x0"
          
         bitfld.long 0x00 4. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_ERRINFO_TRIGOUTSELERR ,Trigger Output Selection Error Flag. Set when the command selects a trigger output that is not allowed for this channel. RESET:0x0"
          
         hexmask.long 0x00 5.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_ERRINFO_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_ERRINFO_ERRINFO ,Error information Register. Additional information for the error that is encountered by the DMA. The meaning of the bits are detailed in the Error Handling section. RESET:0x0"
          
rgroup.long 0x11c8++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_IIDR, Channel Implementation Identification Register  This register provides information about the revision of the product implementing the DMA channel. RESET:0x3a00043b"
         hexmask.long 0x00 0.--11. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_IIDR_IMPLEMENTER ,Contains the JEP106 code of the company that implemented the IP:  - [11:8]: JEP106 continuation code of implementer.  - [7]: Always 0.  - [6:0]: JEP106 identity code of implementer. For Arm this field reads as 0x43B. RESET:0x43b"
          
         hexmask.long 0x00 12.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_IIDR_REVISION ,Indicates the minor revision of the product rxpy identifier RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_IIDR_VARIANT ,Indicates the major revision, or variant, of the product rxpy identifier RESET:0x0"
          
         hexmask.long 0x00 20.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_IIDR_PRODUCTID ,Indicates the product ID RESET:0x3a0"
          
rgroup.long 0x11cc++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_AIDR, Channel Architecture Identification Register  This register provides information about the architecture version supported by the DMA channel. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_AIDR_ARCH_MINOR_REV ,Architecture Minor Revision. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_AIDR_ARCH_MAJOR_REV ,Architecture Major Revision. RESET:0x0"
          
         hexmask.long 0x00 8.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_AIDR_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
group.long  0x11e8++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_ISSUECAP, Used for setting issuing capability threshold. RESET:0x7"
         hexmask.long 0x00 0.--2. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_ISSUECAP_ISSUECAP ,ISSUECAP can be used by software to place a constraint on allowed issuing capability in both read and write direction. RESET:0x7"
          
         hexmask.long 0x00 3.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_ISSUECAP_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0x11f8++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG0, Channel Build Configuration and Capability Register 0  This register contains the configuration parameters can capabilities of the DMA channel. RESET:0x3d27000f"
         hexmask.long 0x00 0.--7. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG0_DATA_BUFF_SIZE ,Data Buffer Size in entries - 1. Total Size = ((DATA_BUFF_SIZE + 1) * DATA_WIDTH /8) bytes. RESET:0xf"
          
         hexmask.long 0x00 8.--15. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG0_CMD_BUFF_SIZE ,Command Buffer Size in command words - 1. Total Size = (CMD_BUFF_SIZE + 1) * 4 bytes. RESET:0x0"
          
         hexmask.long 0x00 16.--21. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG0_ADDR_WIDTH ,Address Width in bits = ADDR_WIDTH + 1 RESET:0x27"
          
         hexmask.long 0x00 22.--24. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG0_DATA_WIDTH ,Data Width. - 000: 8-bit - 001: 16-bit - 010: 32-bit - 011: 64-bit - 100: 128-bit - 101: 256-bit - 110: 512-bit - 111: 1024-bit RESET:0x4"
          
         bitfld.long 0x00 25. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG0_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         hexmask.long 0x00 26.--29. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG0_INC_WIDTH ,Width of the increment register = INC_WIDTH + 1. When set to 0, then only 0 and 1 can be set as an increment. When larger values are used, then negative increments can be set using 2's complement: INC_WIDTH = 0: 0..1 INC_WIDTH = 1: -2..1 INC_WIDTH = 2: -4..3 INC_WIDTH = 3: -8..7 … INC_WIDTH = 15: -32768..32767 RESET:0xf"
          
         hexmask.long 0x00 30.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG0_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
rgroup.long 0x11fc++0x3
    line.long 0x00 "DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1, Channel Build Configuration and Capability Register 1  This register contains the configuration parameters can capabilities of the DMA channel. RESET:0x79f"
         bitfld.long 0x00 0. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_HAS_XSIZEHI ,Has 32-bit XSIZE counters. RESET:0x1"
          
         bitfld.long 0x00 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_HAS_WRAP ,Has wrap capability. RESET:0x1"
          
         bitfld.long 0x00 2. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_HAS_2D ,Has 2D capability. RESET:0x1"
          
         bitfld.long 0x00 3. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_HAS_TMPLT ,Has template based pack and unpack capability. RESET:0x1"
          
         bitfld.long 0x00 4. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_HAS_TRIG ,Has trigger capability. RESET:0x1"
          
         bitfld.long 0x00 5. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_HAS_TRIGIN ,Has hardware trigger input ports. RESET:0x0"
          
         bitfld.long 0x00 6. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_HAS_TRIGOUT ,Has hardware trigger output port. RESET:0x0"
          
         bitfld.long 0x00 7. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_HAS_TRIGSEL ,Has selectable triggers. RESET:0x1"
          
         bitfld.long 0x00 8. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_HAS_CMDLINK ,Has command link list capability. RESET:0x1"
          
         bitfld.long 0x00 9. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_HAS_AUTO ,Has automatic reload and restart capability. RESET:0x1"
          
         bitfld.long 0x00 10. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_HAS_WRKREG ,Has internal register view capability. RESET:0x1"
          
         bitfld.long 0x00 11. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_HAS_STREAM ,Has stream interface support. RESET:0x0"
          
         bitfld.long 0x00 12. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_HAS_STREAMSEL ,Has selectable stream interfaces. RESET:0x0"
          
         hexmask.long 0x00 13.--17. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_RAZWI_0 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
         bitfld.long 0x00 18. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_HAS_GPOSEL ,Has shared GPO ports between channels. RESET:0x0"
          
         hexmask.long 0x00 19.--31. 1. " DMA350_APB4SLVADDRESSBLOCK_DMACH1_CH_BUILDCFG1_RAZWI_1 ,Read-As-Zero, Writes Ignored. RESET:0x0"
          
tree.end

tree "DCU_DSW"
base e:0x40064000
width 80.
tree.end
    

tree "DCU_DSW__GLOBAL"
base e:0x40064000
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_VERSION, HW Version Register RESET:0xde570101"
         hexmask.long 0x00 0.--7. 1. " DCU_DSW_GLOBAL_VERSION_MINOR_VERSION ,Minor version RESET:0x1"
          
         hexmask.long 0x00 8.--15. 1. " DCU_DSW_GLOBAL_VERSION_MAJOR_VERSION ,Major version RESET:0x1"
          
         hexmask.long 0x00 16.--31. 1. " DCU_DSW_GLOBAL_VERSION_IDENTIFICATION ,Identification RESET:0xde57"
          
group.long  0x4++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_MODE, Operating mode RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " DCU_DSW_GLOBAL_MODE_OPERATING_MODE ,Operating mode RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_FB_ADDRESS, Framebuffer address RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_DSW_GLOBAL_FB_ADDRESS_ADDRESS ,Address RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_FB_DIMENSIONS, Framebuffer dimensions RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " DCU_DSW_GLOBAL_FB_DIMENSIONS_X_DIM ,x-dimension in pixels RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " DCU_DSW_GLOBAL_FB_DIMENSIONS_Y_DIM ,y-dimension in lines RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_FB_PITCH_BPP, Framebuffer pitch and byte-per-pixel RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " DCU_DSW_GLOBAL_FB_PITCH_BPP_PITCH ,Pitch in bytes RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " DCU_DSW_GLOBAL_FB_PITCH_BPP_BPP ,Bytes per pixel. Only '4' allowed. '0' defaults to 4 bpp RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_IRQ_ENABLE, Interrupt enable RESET:0x0"
         bitfld.long 0x00 0. " DCU_DSW_GLOBAL_IRQ_ENABLE_MASK ,Frame done interrupt mask RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_IRQ_STATUS_BUSY, Interrupt status and clear RESET:0x0"
         bitfld.long 0x00 0. " DCU_DSW_GLOBAL_IRQ_STATUS_BUSY_IRQ ,Frame done interrupt read status/write clear RESET:0x0"
          
         bitfld.long 0x00 1. " DCU_DSW_GLOBAL_IRQ_STATUS_BUSY_BUSY ,Busy indication of the DSW. Read only. RESET:0x0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_COUNT_BUS_WORDS, Counter for current bus words RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_DSW_GLOBAL_COUNT_BUS_WORDS_CNT_READ ,Count read buswords RESET:0x0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_COUNT_STREAM_WORDS, Counter for current stream words RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_DSW_GLOBAL_COUNT_STREAM_WORDS_CNT_STREAM_WORDS ,Counter for current stream words RESET:0x0"
          
rgroup.long 0x24++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_COUNT_FIFO_ERROR, Counter for FIFO errors RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_DSW_GLOBAL_COUNT_FIFO_ERROR_CNT_FIFO ,Count FIFO errors (overrun, underrun) RESET:0x0"
          
rgroup.long 0x28++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_COUNT_START, Counter frame start triggers RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_DSW_GLOBAL_COUNT_START_CNT_START ,Count start triggers RESET:0x0"
          
rgroup.long 0x2c++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_COUNT_RESTART, Counter frame re-start triggers RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_DSW_GLOBAL_COUNT_RESTART_CNT_RESTART ,Count re-start triggers. This should be avoided. RESET:0x0"
          
rgroup.long 0x30++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_COUNT_EOF, Counter for (stream) EOFs RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_DSW_GLOBAL_COUNT_EOF_CNT_EOF ,Count stream EOFs RESET:0x0"
          
rgroup.long 0x34++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_COUNT_LAST_BUS_WORDS, Counter last frames bus words RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_DSW_GLOBAL_COUNT_LAST_BUS_WORDS_CNT_LAST_BUS_WORDS ,Stores last frames bus words RESET:0x0"
          
rgroup.long 0x38++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_COUNT_LAST_STREAM_WORDS, Counter last frames stream words RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_DSW_GLOBAL_COUNT_LAST_STREAM_WORDS_CNT_LAST_STREAM_WORDS ,Stores the last frames stream words RESET:0x0"
          
rgroup.long 0x3c++0x3
    line.long 0x00 "DCU_DSW_GLOBAL_COUNT_SIZE_ERROR, Counter for size error RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " DCU_DSW_GLOBAL_COUNT_SIZE_ERROR_CNT_SIZE_ERROR ,Increments if streamed words and bus words differ for a frame RESET:0x0"
          
tree.end
    

tree "EMMC_REG"
base e:0x40065000
width 80.
tree.end
    

tree "EMMC_REG__BLOCK"
base e:0x40065000
width 80.
group.long  0x0++0x3
    line.long 0x00 "EMMC_REG_BLOCK_SDMASA_R, This register is used to configure a 32-bit Block Count or an SDMA System Address based on the Host Version 4 Enable bit in the Host Control 2 register. This register is applicable for both SD and eMMC modes. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_BLOCK_SDMASA_R_BLOCKCNT_SDMASA ,32-bit Block Count (SDMA System Address)  - SDMA System Address (Host Version 4 Enable = 0): This register contains the system memory address for an SDMA transfer in the 32-bit addressing mode. When the Host Controller stops an SDMA    transfer, this register points to the system address of the next contiguous data position. It can be accessed only if no transaction is executing. Reading this register during data transfers may return an invalid value.  - 32-bit Block Count (Host Version 4 Enable = 1): From the Host Controller Version 4.10 specification, this register is redefined as 32-bit Block Count. The Host Controller decrements the block count of this register for every block transfer and the data transfer stops when the count reaches zero. This register must be accessed when no transaction is executing. Reading this register during data transfers may return invalid value. Following are the values for BLOCKCNT_SDMASA:  - 0xFFFF_FFFF: 4G - 1 Block  - ...  - 0x0000_0002: 2 Blocks  - 0x0000_0001: 1 Block  - 0x0000_0000: Stop Count Note:  - For Host Version 4 Enable = 0, the Host driver does not program the system address in this register while operating in ADMA mode. The system address must be programmed in the ADMA System Address register.  - For Host Version 4 Enable = 0, the Host driver programs a non-zero 32-bit block count value in this register when Auto CMD23 is enabled for non-DMA and ADMA modes. Auto CMD23 cannot be used with SDMA.  - This register must be programmed with a non-zero value for data transfer if the 32-bit Block count register is used instead of the 16-bit Block count register. RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "EMMC_REG_BLOCK_BLOCKSIZE_R, This register is used to configure an SDMA buffer boundary and the number of bytes in a data block. This register is applicable for both SD and eMMC modes. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " EMMC_REG_BLOCK_BLOCKSIZE_R_XFER_BLOCK_SIZE ,Transfer Block Size  These bits specify the block size of data transfers. In case of memory, it is set to 512 bytes. It can be accessed only if no transaction is executing. Read operations during transfers may return an invalid value, and write operations are ignored. Following are the values for XFER_BLOCK_SIZE:  - 0x1: 1 byte  - 0x2: 2 bytes  - 0x3: 3 bytes  - ......  - 0x1FF: 511 byte  - 0x200: 512 bytes  - ......  - 0x800: 2048 bytes Note: This register must be programmed with a non-zero value for data transfer. RESET:0x0"
          
         bitfld.long 0x00 12.--14. " EMMC_REG_BLOCK_BLOCKSIZE_R_SDMA_BUF_BDARY ,SDMA Buffer Boundary  These bits specify the size of contiguous buffer in system memory. The SDMA transfer waits at every boundary specified by these fields and the Host Controller generates the DMA interrupt to request the Host Driver to update the SDMA System Address register. RESET:0x0" "BYTES_128K-5,BYTES_16K-2,BYTES_256K-6,BYTES_32K-3,BYTES_4K-0,BYTES_512K-7,BYTES_64K-4,BYTES_8K-1"
          
         bitfld.long 0x00 15. " EMMC_REG_BLOCK_BLOCKSIZE_R_RSVD_BLOCKSIZE15 ,This bit of the BLOCKSIZE_R register is reserved. It always returns 0. RESET:0x0"
          
group.long  0x6++0x3
    line.long 0x00 "EMMC_REG_BLOCK_BLOCKCOUNT_R, This register is used to configure the number of data blocks. This register is applicable for both SD and eMMC modes. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " EMMC_REG_BLOCK_BLOCKCOUNT_R_BLOCK_CNT ,16-bit Block Count  - If the Host Version 4 Enable bit is set 0 or the 16-bit Block Count register is set to non-zero, the 16-bit Block Count register is selected.  - If the Host Version 4 Enable bit is set 1 and the 16-bit Block Count register is set to zero, the 32-bit Block Count register is selected. Following are the values for BLOCK_CNT:  - 0x0: Stop Count  - 0x1: 1 Block  - 0x2: 2 Blocks  - ... - ...  - 0xFFFF: 65535 Blocks Note: For Host Version 4 Enable = 0, this register must be set to 0000h before programming the 32-bit block count register when Auto CMD23 is enabled for non-DMA and ADMA modes. RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "EMMC_REG_BLOCK_ARGUMENT_R, This register is used to configure the SD/eMMC command argument. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_BLOCK_ARGUMENT_R_ARGUMENT ,Command Argument  These bits specify the SD/eMMC command argument that is specified in bits 39-8 of the Command format. RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "EMMC_REG_BLOCK_XFER_MODE_R, This register is used to control the operation of data transfers for an SD/eMMC mode. The Host driver sets this register before issuing a command that transfers data. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_XFER_MODE_R_DMA_ENABLE ,DMA Enable  This bit enables the DMA functionality. If this bit is set to 1, a DMA operation begins when the Host Driver writes to the Command register. You can select one of the DMA modes by using DMA Select in the Host Control 1 register. RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_XFER_MODE_R_BLOCK_COUNT_ENABLE ,Block Count Enable  This bit is used to enable the Block Count register, which is relevant for multiple block transfers. If this bit is set to 0, the Block Count register is disabled, which is useful in executing an infinite transfer. RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 2.--3. " EMMC_REG_BLOCK_XFER_MODE_R_AUTO_CMD_ENABLE ,Auto Command Enable  This field determines use of Auto Command functions.  Note: In SDIO, this field must be set as 00b (Auto Command Disabled). RESET:0x0" "AUTO_CMD12_ENABLED-1,AUTO_CMD23_ENABLED-2,AUTO_CMD_AUTO_SEL-3,AUTO_CMD_DISABLED-0"
          
         bitfld.long 0x00 4. " EMMC_REG_BLOCK_XFER_MODE_R_DATA_XFER_DIR ,Data Transfer Direction Select  This bit defines the direction of DAT line data transfers. This bit is set to 1 by the Host Driver to transfer data from the SD/eMMC card to the Host Controller and it is set to 0 for all other commands. RESET:0x0" "READ-1,WRITE-0"
          
         bitfld.long 0x00 5. " EMMC_REG_BLOCK_XFER_MODE_R_MULTI_BLK_SEL ,Multi/Single Block Select  This bit is set when issuing multiple-block transfer commands using the DAT line. If this bit is set to 0, it is not necessary to set the Block Count register. RESET:0x0" "MULTI-1,SINGLE-0"
          
         bitfld.long 0x00 6. " EMMC_REG_BLOCK_XFER_MODE_R_RESP_TYPE ,Response Type R1/R5  This bit selects either R1 or R5 as a response type when the Response Error Check is selected.  Error statuses checked in R1:  - OUT_OF_RANGE  - ADDRESS_ERROR  - BLOCK_LEN_ERROR  - WP_VIOLATION  - CARD_IS_LOCKED  - COM_CRC_ERROR  - CARD_ECC_FAILED  - CC_ERROR  - ERROR Response Flags checked in R5:  - COM_CRC_ERROR  - ERROR  - FUNCTION_NUMBER  - OUT_OF_RANGE RESET:0x0" "RESP_R1-0,RESP_R5-1"
          
         bitfld.long 0x00 7. " EMMC_REG_BLOCK_XFER_MODE_R_RESP_ERR_CHK_ENABLE ,Response Error Check Enable  The Host Controller supports response check function to avoid overhead of response error check by Host driver. Response types of only R1 and R5 can be checked by the Controller. If the Host Controller checks the response error, set this bit to 1 and set Response Interrupt Disable to 1. If an error is detected, the Response Error interrupt is generated in the Error Interrupt Status register.  Note:  - Response error check must not be enabled for any response type other than R1 and R5.  - Response check must not be enabled for the tuning command. RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 8. " EMMC_REG_BLOCK_XFER_MODE_R_RESP_INT_DISABLE ,Response Interrupt Disable  The Host Controller supports response check function to avoid overhead of response error check by the Host driver. Response types of only R1 and R5 can be checked by the Controller. If Host Driver checks the response error, set this bit to 0 and wait for Command Complete Interrupt and then check the response register. If the Host Controller checks the response error, set this bit to 1 and set the Response Error Check Enable bit to 1. The Command Complete Interrupt is disabled by this bit regardless of the Command Complete Signal Enable.  Note: During tuning (when the Execute Tuning bit in the Host Control2 register is set), the Command Complete Interrupt is not generated irrespective of the Response Interrupt Disable setting. RESET:0x0" "DISABLED-1,ENABLED-0"
          
         hexmask.long 0x00 9.--15. 1. " EMMC_REG_BLOCK_XFER_MODE_R_RSVD ,These bits of the XFER_MODE_R register are reserved. They always return 0. RESET:0x0"
          
group.long  0xe++0x3
    line.long 0x00 "EMMC_REG_BLOCK_CMD_R, This register is used to provide the information related to a command and a response packet. This register is applicable for an SD/eMMC mode. RESET:0x0"
         bitfld.long 0x00 0.--1. " EMMC_REG_BLOCK_CMD_R_RESP_TYPE_SELECT ,Response Type Select  This bit indicates the type of response expected from the card. RESET:0x0" "NO_RESP-0,RESP_LEN_136-1,RESP_LEN_48-2,RESP_LEN_48B-3"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_CMD_R_SUB_CMD_FLAG ,Sub Command Flag  This bit distinguishes between a main command and a sub command. RESET:0x0" "MAIN-0,SUB-1"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_CMD_R_CMD_CRC_CHK_ENABLE ,Command CRC Check Enable  This bit enables the Host Controller to check the CRC field in the response. If an error is detected, it is reported as a Command CRC error.  Note:  - CRC Check enable must be set to 0 for the command with no response, R3 response, and R4 response.  - For the tuning command, this bit must always be set to 1 to enable the CRC check. RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 4. " EMMC_REG_BLOCK_CMD_R_CMD_IDX_CHK_ENABLE ,Command Index Check Enable  This bit enables the Host Controller to check the index field in the response to verify if it has the same value as the command index. If the value is not the same, it is reported as a Command Index error.  Note:  - Index Check enable must be set to 0 for the command with no response, R2 response, R3 response and R4 response.  - For the tuning command, this bit must always be set to enable the index check. RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 5. " EMMC_REG_BLOCK_CMD_R_DATA_PRESENT_SEL ,Data Present Select  This bit is set to 1 to indicate that data is present and that the data is transferred using the DAT line. This bit is set to 0 in the following instances:  - Command using the CMD line  - Command with no data transfer but using busy signal on the DAT[0] line  - Resume Command RESET:0x0" "DATA-1,NO_DATA-0"
          
         bitfld.long 0x00 6.--7. " EMMC_REG_BLOCK_CMD_R_CMD_TYPE ,Command Type  These bits indicate the command type.  Note: While issuing Abort CMD using CMD12/CMD52 or reset CMD using CMD0/CMD52, CMD_TYPE field shall be set to 0x3. In case CMD0 is used for initialization set as 0x0 RESET:0x0" "ABORT_CMD-3,NORMAL_CMD-0,RESUME_CMD-2,SUSPEND_CMD-1"
          
         hexmask.long 0x00 8.--13. 1. " EMMC_REG_BLOCK_CMD_R_CMD_INDEX ,Command Index  These bits are set to the command number that is specified in bits 45-40 of the Command Format. RESET:0x0"
          
         hexmask.long 0x00 14.--15. 1. " EMMC_REG_BLOCK_CMD_R_RSVD ,These bits of the CMD_R register are reserved. They always return 0. RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "EMMC_REG_BLOCK_RESP01_R, This register stores 39-08 bits of the Response Field for an SD/eMMC mode.  The response for an SD/eMMC command can be a maximum of 128 bits. These 128 bits are segregated into four 32-bit registers: RESP01_R, RESP23_R, RESP45_R and RESP67_R. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_BLOCK_RESP01_R_RESP01 ,Command Response  These bits reflect 39-8 bits of SD/eMMC Response Field.  Note: For Auto CMD, the 32-bit response (bits 39-8 of the Response Field) is updated in the RESP67_R register. RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "EMMC_REG_BLOCK_RESP23_R, This register stores 71-40 bits of the Response Field for an SD/eMMC mode. This register is used to store the response from the cards. The response can be a maximum of 128 bits. These 128 bits are segregated into four 32-bit registers: RESP01_R, RESP23_R, RESP45_R and RESP67_R. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_BLOCK_RESP23_R_RESP23 ,Command Response  These bits reflect 71-40 bits of the SD/eMMC Response Field. RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "EMMC_REG_BLOCK_RESP45_R, This register stores 103-72 bits of the Response Field for an SD/eMMC mode.  The response for SD/eMMC command can be a maximum of 128 bits. These 128 bits are segregated into four 32-bit registers: RESP01_R, RESP23_R, RESP45_R and RESP67_R. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_BLOCK_RESP45_R_RESP45 ,Command Response  These bits reflect 103-72 bits of the Response Field. RESET:0x0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "EMMC_REG_BLOCK_RESP67_R, This register stores 135-104 bits of the Response Field for an SD/eMMC mode.    The SD/eMMC response can be a maximum of 128 bits. These 128 bits are segregated into four 32-bit registers: RESP01_R, RESP23_R, RESP45_R and RESP67_R. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_BLOCK_RESP67_R_RESP67 ,Command Response   These bits reflect bits 135-104 of SD/EMMC Response Field.  Note: For Auto CMD, this register also reflects the 32-bit response (bits 39-8 of the Response Field). RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "EMMC_REG_BLOCK_BUF_DATA_R, This register is used to access the packet buffer. This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_BLOCK_BUF_DATA_R_BUF_DATA ,Buffer Data  These bits enable access to the Host Controller packet buffer. RESET:0x0"
          
rgroup.long 0x24++0x3
    line.long 0x00 "EMMC_REG_BLOCK_PSTATE_REG, This register indicates the present status of the Host Controller. This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_PSTATE_REG_CMD_INHIBIT ,Command Inhibit (CMD)  This bit indicates the following :   - SD/eMMC mode: If this bit is set to 0, it indicates that the CMD line is not in use and the Host controller can issue an SD/eMMC command using the CMD line. This bit is set when the command register is written. This bit is cleared when the command response is received. This bit is not cleared by the response of auto CMD12/23 but cleared by the response of read/write command. RESET:0x0" "NOT_READY-1,READY-0"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_PSTATE_REG_CMD_INHIBIT_DAT ,Command Inhibit (DAT)   This bit is applicable for SD/eMMC mode and is generated if either DAT line active or Read transfer active is set to 1. If this bit is set to 0, it indicates that the Host Controller can issue subsequent SD/eMMC commands. RESET:0x0" "NOT_READY-1,READY-0"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_PSTATE_REG_DAT_LINE_ACTIVE ,DAT Line Active (SD/eMMC Mode only)  This bit indicates whether one of the DAT lines on the SD/eMMC bus is in use.   In the case of read transactions, this bit indicates whether a read transfer is executing on the SD/eMMC bus.  In the case of write transactions, this bit indicates whether a write transfer is executing on the SD/eMMC bus.  For a command with busy, this status indicates whether the command executing busy is executing on an SD or eMMC bus. RESET:0x0" "ACTIVE-1,INACTIVE-0"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_PSTATE_REG_RE_TUNE_REQ ,Re-Tuning Request  DWC_mshc does not generate retuning request. The software must maintain the Retuning timer. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " EMMC_REG_BLOCK_PSTATE_REG_DAT_7_4 ,DAT[7:4] Line Signal Level  This bit is used to check the DAT line level to recover from errors and for debugging. These bits reflect the value of the sd_dat_in (upper nibble) signal. RESET:0x0"
          
         bitfld.long 0x00 8. " EMMC_REG_BLOCK_PSTATE_REG_WR_XFER_ACTIVE ,Write Transfer Active  This status indicates whether a write transfer is active  for SD/eMMC mode. RESET:0x0" "ACTIVE-1,INACTIVE-0"
          
         bitfld.long 0x00 9. " EMMC_REG_BLOCK_PSTATE_REG_RD_XFER_ACTIVE ,Read Transfer Active  This bit indicates whether a read transfer is active for SD/eMMC mode. RESET:0x0" "ACTIVE-1,INACTIVE-0"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_PSTATE_REG_BUF_WR_ENABLE ,Buffer Write Enable  This bit is used for non-DMA transfers. This bit is set if space is available for writing data. RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 11. " EMMC_REG_BLOCK_PSTATE_REG_BUF_RD_ENABLE ,Buffer Read Enable  This bit is used for non-DMA transfers. This bit is set if valid data exists in the Host buffer. RESET:0x0" "DISABLED-0,ENABLED-1"
          
         hexmask.long 0x00 12.--15. 1. " EMMC_REG_BLOCK_PSTATE_REG_RSVD_15_12 ,These bits of the PRESENT_STAT_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 16. " EMMC_REG_BLOCK_PSTATE_REG_CARD_INSERTED ,Card Inserted  This bit indicates whether a card has been inserted. The Host Controller debounces this signal so that Host Driver need not wait for it to stabilize. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 17. " EMMC_REG_BLOCK_PSTATE_REG_CARD_STABLE ,Card Stable  This bit indicates the stability of the Card Detect Pin Level. A card is not detected if this bit is set to 1 and the value of the CARD_INSERTED bit is 0. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 18. " EMMC_REG_BLOCK_PSTATE_REG_CARD_DETECT_PIN_LEVEL ,Card Detect Pin Level  This bit reflects the inverse synchronized value of the card_detect_n signal. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 19. " EMMC_REG_BLOCK_PSTATE_REG_WR_PROTECT_SW_LVL ,Write Protect Switch Pin Level  This bit is supported only for memory and combo cards. This bit reflects the synchronized value of the card_write_prot signal. RESET:0x0" "FALSE-0,TRUE-1"
          
         hexmask.long 0x00 20.--23. 1. " EMMC_REG_BLOCK_PSTATE_REG_DAT_3_0 ,DAT[3:0] Line Signal Level  This bit is used to check the DAT line level to recover from errors and for debugging. These bits reflect the value of the sd_dat_in (lower nibble) signal. RESET:0x0"
          
         bitfld.long 0x00 24. " EMMC_REG_BLOCK_PSTATE_REG_CMD_LINE_LVL ,Command-Line Signal Level  This bit is used to check the CMD line level to recover from errors and for debugging. These bits reflect the value of the sd_cmd_in signal. RESET:0x0"
          
         bitfld.long 0x00 25. " EMMC_REG_BLOCK_PSTATE_REG_HOST_REG_VOL ,Host Regulator Voltage Stable  This bit is used to check whether the host regulator voltage is stable for switching the voltage of UHS-I mode. This bit reflects the synchronized value of the host_reg_vol_stable signal. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 26. " EMMC_REG_BLOCK_PSTATE_REG_RSVD_26 ,This bit of the PRESENT_ST_R register is reserved bits. It always returns 0. RESET:0x0"
          
         bitfld.long 0x00 27. " EMMC_REG_BLOCK_PSTATE_REG_CMD_ISSUE_ERR ,Command Not Issued by Error  This bit is set if a command cannot be issued after setting the command register due to an error except the Auto CMD12 error. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 28. " EMMC_REG_BLOCK_PSTATE_REG_SUB_CMD_STAT ,Sub Command Status  This bit is used to distinguish between a main command and a sub command status. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 29. " EMMC_REG_BLOCK_PSTATE_REG_IN_DORMANT_ST ,In Dormant Status  For SD/eMMC mode, this bit always returns 0. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 30. " EMMC_REG_BLOCK_PSTATE_REG_LANE_SYNC ,Lane Synchronization  For SD/eMMC mode, this bit always returns 0. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 31. " EMMC_REG_BLOCK_PSTATE_REG_UHS2_IF_DETECT ,UHS-II Interface Detection  For SD/eMMC mode, this bit always returns 0. RESET:0x0" "FALSE-0,TRUE-1"
          
group.long  0x28++0x3
    line.long 0x00 "EMMC_REG_BLOCK_HOST_CTRL1_R, This register is used to control the operation of the Host Controller. This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_HOST_CTRL1_R_LED_CTRL ,LED Control  This bit is used to caution the user not to remove the card while the SD card is being accessed. The value is reflected on the led_control signal. RESET:0x0" "OFF-0,ON-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_HOST_CTRL1_R_DAT_XFER_WIDTH ,Data Transfer Width  For SD/eMMC mode,this bit selects the data transfer width of the Host Controller. The Host Driver sets it to match the data width of the SD/eMMC card. RESET:0x0" "FOUR_BIT-1,ONE_BIT-0"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_HOST_CTRL1_R_HIGH_SPEED_EN ,High Speed Enable (SD/eMMC Mode only)   In SD/eMMC mode, this bit is used to determine the selection of preset value for High Speed mode. Before setting this bit, the Host Driver checks the High Speed Support in the Capabilities register.  Note: DWC_MSHC always outputs the sd_cmd_out and sd_dat_out lines at the rising edge of cclk_tx clock irrespective of this bit.Please refer the section Connecting the Clock IO interface  in the Mobile Storage Host Controller user guide on clocking requirement for an SD/eMMC card. RESET:0x0" "HIGH_SPEED-1,NORMAL_SPEED-0"
          
         bitfld.long 0x00 3.--4. " EMMC_REG_BLOCK_HOST_CTRL1_R_DMA_SEL ,DMA Select  This field is used to select the DMA type.  When Host Version 4 Enable is 1 in Host Control 2 register:  - 0x0 : SDMA is selected  - 0x1 : Reserved  - 0x2 : ADMA2 is selected  - 0x3 : ADMA2 or ADMA3 is selected  When Host Version 4 Enable is 0 in Host Control 2 register:  - 0x0 : SDMA is selected  - 0x1 : Reserved  - 0x2 : 32-bit Address ADMA2 is selected  - 0x3 : 64-bit Address ADMA2 is selected RESET:0x0" "ADMA2-2,ADMA2_3-3,RSVD_BIT-1,SDMA-0"
          
         bitfld.long 0x00 5. " EMMC_REG_BLOCK_HOST_CTRL1_R_EXT_DAT_XFER ,Extended Data Transfer Width  This bit controls 8-bit bus width mode of embedded device. RESET:0x0" "DEFAULT-0,EIGHT_BIT-1"
          
         bitfld.long 0x00 6. " EMMC_REG_BLOCK_HOST_CTRL1_R_CARD_DETECT_TEST_LVL ,Card Detect Test Level  This bit is enabled while the Card Detect Signal Selection is set to 1 and it indicates whether a card inserted or not. RESET:0x0" "CARD_INSERTED-1,NO_CARD-0"
          
         bitfld.long 0x00 7. " EMMC_REG_BLOCK_HOST_CTRL1_R_CARD_DETECT_SIG_SEL ,Card Detect Signal Selection  This bit selects a source for card detection. When the source for the card detection is switched, the interrupt must be disabled during the switching period. RESET:0x0" "CARD_DT_TEST_LEVEL-1,SDCD_PIN-0"
          
group.long  0x29++0x3
    line.long 0x00 "EMMC_REG_BLOCK_PWR_CTRL_R, This register is used to control the bus power for the Card. This register is applicable for an SD, eMMC, and UHS-II modes. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_PWR_CTRL_R_SD_BUS_PWR_VDD1 ,SD Bus Power for VDD1  This bit enables VDD1 power of the card. This setting is available on the sd_vdd1_on output of DWC_mshc so that it can be used to control the VDD1 power supply of the card. Before setting this bit, the SD Host Driver sets the SD Bus Voltage Select bit. If the Host Controller detects a No Card state, this bit is cleared.  In SD mode, if this bit is cleared, the Host Controller stops the SD Clock by clearing the SD_CLK_IN bit in the CLK_CTRL_R register. RESET:0x0" "OFF-0,ON-1"
          
         bitfld.long 0x00 1.--3. " EMMC_REG_BLOCK_PWR_CTRL_R_SD_BUS_VOL_VDD1 ,SD Bus Voltage Select for VDD1/eMMC Bus Voltage Select for VDD  These bits enable the Host Driver to select the voltage level for an SD/eMMC card. Before setting this register, the Host Driver checks the Voltage Support bits in the Capabilities register. If an unsupported voltage is selected, the Host System does not supply the SD Bus voltage. The value set in this field is available on the DWC_mshc output signal (sd_vdd1_sel), which is used by the voltage switching circuitry.  SD Bus Voltage Select options:  - 0x7 : 3.3V(Typical)  - 0x6 : 3.0V(Typical)  - 0x5 : 1.8V(Typical) for Embedded  - 0x4 : 0x0   - Reserved  eMMC Bus Voltage Select options:  - 0x7 : 3.3V(Typical)  - 0x6 : 1.8V(Typical)  - 0x5 : 1.2V(Typical)  - 0x4 : 0x0   - Reserved RESET:0x0" "RSVD0-0,RSVD1-1,RSVD2-2,RSVD3-3,RSVD4-4,V_1_8-5,V_3_0-6,V_3_3-7"
          
         bitfld.long 0x00 4. " EMMC_REG_BLOCK_PWR_CTRL_R_SD_BUS_PWR_VDD2 ,SD Bus Power for VDD2. This is irrelevant for SD/eMMC card. RESET:0x0" "OFF-0,ON-1"
          
         bitfld.long 0x00 5.--7. " EMMC_REG_BLOCK_PWR_CTRL_R_SD_BUS_VOL_VDD2 ,SD Bus Voltage Select for VDD2. This is irrelevant for SD/eMMC card. RESET:0x0" "NOT_USED6-6,NOT_USED7-7,NO_VDD2-0,RSVD1-1,RSVD2-2,RSVD3-3,V_1_2-4,V_1_8-5"
          
group.long  0x2a++0x3
    line.long 0x00 "EMMC_REG_BLOCK_BGAP_CTRL_R, This register is used by the host driver to control any operation related to Block Gap. This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_BGAP_CTRL_R_STOP_BG_REQ ,Stop At Block Gap Request  This bit is used to stop executing read and write transactions at the next block gap for non-DMA, SDMA, and ADMA transfers. RESET:0x0" "STOP-1,XFER-0"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_BGAP_CTRL_R_CONTINUE_REQ ,Continue Request  This bit is used to restart the transaction, which was stopped using the Stop At Block Gap Request. The Host Controller automatically clears this bit when the transaction restarts. If stop at block gap request is set to 1, any write to this bit is ignored. RESET:0x0" "NO_AFFECT-0,RESTART-1"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_BGAP_CTRL_R_RD_WAIT_CTRL ,Read Wait Control  This bit is used to enable the read wait protocol to stop read data using DAT[2] line if the card supports read wait. Otherwise, the Host Controller has to stop the card clock to hold the read data. RESET:0x0" "DISABLE-0,ENABLE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_BGAP_CTRL_R_INT_AT_BGAP ,Interrupt At Block Gap  This bit is valid only in the 4-bit mode of an SDIO card and is used to select a sample point in the interrupt cycle. Setting to 1 enables interrupt detection at the block gap for a multiple block transfer. RESET:0x0" "DISABLE-0,ENABLE-1"
          
         hexmask.long 0x00 4.--7. 1. " EMMC_REG_BLOCK_BGAP_CTRL_R_RSVD_7_4 ,These bits of the Block Gap Control register are reserved. They always return 0. RESET:0x0"
          
group.long  0x2b++0x3
    line.long 0x00 "EMMC_REG_BLOCK_WUP_CTRL_R, This register is mandatory for the Host Controller, but the wakeup functionality depends on the Host Controller system hardware and software. The Host Driver maintains voltage on the SD Bus by setting the SD Bus Power to 1 in the Power Control Register, while a wakeup event through the Card Interrupt is desired. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_WUP_CTRL_R_CARD_INT ,Wakeup Event Enable on Card Interrupt  This bit enables wakeup event through a Card Interrupt assertion in the Normal Interrupt Status register. This bit can be set to 1 if FN_WUS (Wake Up Support) in CIS is set to 1. RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_WUP_CTRL_R_CARD_INSERT ,Wakeup Event Enable on SD Card Insertion  This bit enables wakeup event through Card Insertion assertion in the Normal Interrupt Status register. FN_WUS (Wake Up Support) in CIS does not affect this bit. RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_WUP_CTRL_R_CARD_REMOVAL ,Wakeup Event Enable on SD Card Removal  This bit enables wakeup event through Card Removal assertion in the Normal Interrupt Status register. For the SDIO card, Wake Up Support (FN_WUS) in the Card Information Structure (CIS) register does not affect this bit. RESET:0x0" "DISABLED-0,ENABLED-1"
          
         hexmask.long 0x00 3.--7. 1. " EMMC_REG_BLOCK_WUP_CTRL_R_RSVD_7_3 ,These bits of Wakeup Control register are reserved. They always return 0. RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "EMMC_REG_BLOCK_CLK_CTRL_R, This register controls SDCLK (card clock) in an SD/eMMC mode and RCLK in the UHS-II mode. This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_CLK_CTRL_R_INTERNAL_CLK_EN ,Internal Clock Enable  This bit is set to 0 when the Host Driver is not using the Host Controller or the Host Controller awaits a wakeup interrupt. The Host Controller must stop its internal clock to enter a very low power state. However, registers can still be read and written to. The value is reflected on the intclk_en signal.  Note: If this bit is not used to control the internal clock (base clock and manager clock), it is recommended to set this bit to '1' . RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_CLK_CTRL_R_INTERNAL_CLK_STABLE ,Internal Clock Stable  This bit enables the Host Driver to check the clock stability twice after the Internal Clock Enable bit is set and after the PLL Enable bit is set. This bit reflects the synchronized value of the intclk_stable signal after the Internal Clock Enable bit is set to 1 and also reflects the synchronized value of the card_clk_stable signal after the PLL Enable bit is set to 1. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_CLK_CTRL_R_SD_CLK_EN ,SD/eMMC Clock Enable  This bit stops the SDCLK or RCLK when set to 0. The SDCLK/RCLK Frequency Select bit can be changed when this bit is set to 0. The value is reflected on the clk2card_on pin. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_CLK_CTRL_R_PLL_ENABLE ,PLL Enable  This bit is used to activate the PLL (applicable when Host Version 4 Enable = 1). When Host Version 4 Enable = 0, INTERNAL_CLK_EN bit may be used to activate PLL. The value is reflected on the card_clk_en signal.  Note: If this bit is not used to to active the PLL when Host Version 4 Enable = 1, it is recommended to set this bit to '1' . RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 4. " EMMC_REG_BLOCK_CLK_CTRL_R_RSVD_4 ,This bit of the CLK_CTRL_R register is reserved. It always returns 0. RESET:0x0"
          
         bitfld.long 0x00 5. " EMMC_REG_BLOCK_CLK_CTRL_R_CLK_GEN_SELECT ,Clock Generator Select  This bit is used to select the clock generator mode in SDCLK/RCLK Frequency Select. If Preset Value Enable = 0, this bit is set by the Host Driver. If Preset Value Enable = 1, this bit is automatically set to a value specified in one of the Preset Value registers. The value is reflected on the card_clk_gen_sel signal. RESET:0x0" "FALSE-0,TRUE-1"
          
         hexmask.long 0x00 6.--7. 1. " EMMC_REG_BLOCK_CLK_CTRL_R_UPPER_FREQ_SEL ,These bits specify the upper 2 bits of 10-bit SDCLK/RCLK Frequency Select control. The value is reflected on the upper 2 bits of the card_clk_freq_sel signal. RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " EMMC_REG_BLOCK_CLK_CTRL_R_FREQ_SEL ,SDCLK/RCLK Frequency Select  These bits are used to select the frequency of the SDCLK signal. These bits depend on setting of Preset Value Enable in the Host Control 2 register. If Preset Value Enable = 0, these bits are set by the Host Driver. If Preset Value Enable = 1, these bits are automatically set to a value specified in one of the Preset Value register. The value is reflected on the lower 8-bit of the card_clk_freq_sel signal.    10-bit Divided Clock Mode:  - 0x3FF : 1/2046 Divided clock  - ..........  - N    : 1/2N Divided Clock  - ..........  - 0x002  : 1/4 Divided Clock  - 0x001 : 1/2 Divided Clock  - 0x000 : Base clock (10MHz - 255 MHz)    Programmable Clock Mode : Enables the Host System to select a fine grain SD clock frequency:  - 0x3FF : Base clock  * M /1024  - ..........  - N-1  : Base clock  * M /N  - ..........  - 0x002  : Base clock  * M /3  - 0x001 : Base clock  * M /2  - 0x000 : Base clock  * M RESET:0x0"
          
group.long  0x2e++0x3
    line.long 0x00 "EMMC_REG_BLOCK_TOUT_CTRL_R, This register is used to set the Data Timeout Counter value for an SD/eMMC mode according to the timer clock defined by the Capabilities register, while initializig the Host Controller. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " EMMC_REG_BLOCK_TOUT_CTRL_R_TOUT_CNT ,Data Timeout Counter Value.  This value determines the interval by which DAT line timeouts are detected. The Timeout clock frequency is generated by dividing the base clock TMCLK value by this value. When setting this register, prevent inadvertent timeout events by clearing the Data Timeout Error Status Enable (in the Error Interrupt Status Enable register). The values for these bits are:  - 0xF :  Reserved  - 0xE : TMCLK x 2^27  - .........  - 0x1 : TMCLK x 2^14  - 0x0 : TMCLK x 2^13  Note: During a boot operating in an eMMC mode, an application must configure the boot data timeout value (approximately 1 sec) in this bit. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " EMMC_REG_BLOCK_TOUT_CTRL_R_RSVD_7_4 ,These bits of the Timeout Control register are reserved. They always return 0. RESET:0x0"
          
group.long  0x2f++0x3
    line.long 0x00 "EMMC_REG_BLOCK_SW_RST_R, This register is used to generate a reset pulse by writing 1 to each bit of this register. After completing the reset, the Host Controller clears each bit. As it takes some time to complete a software reset, the Host Driver confirms that these bits are 0. This register is applicable for an SD/eMMC/UHS-II mode.  Note: Refer Software Reset section in the DWC_mshc Databook for additional details. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_SW_RST_R_SW_RST_ALL ,Software Reset For All This reset affects the entire Host Controller except for the card detection circuit. During its initialization, the Host Driver sets this bit to 1 to reset the Host Controller. All registers are reset except the capabilities register. If this bit is set to 1, the Host Driver must issue reset command and reinitialize the card. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_SW_RST_R_SW_RST_CMD ,Software Reset For CMD line  This bit resets only a part of the command circuit to be able to issue a command.  This reset is effective only for a command issuing circuit (including response error statuses related to Command Inhibit (CMD) control) and does not affect the data transfer circuit. Host Controller can continue data transfer even after this reset is executed while handling subcommand-response errors.  The following registers and bits are cleared by this bit:  - Present State register : Command Inhibit (CMD) bit  - Normal Interrupt Status register : Command Complete bit  - Error Interrupt Status : Response error statuses related to Command Inhibit (CMD) bit RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_SW_RST_R_SW_RST_DAT ,Software Reset For DAT line   This bit is used in SD/eMMC mode and it resets only a part of the data circuit and the DMA circuit is also reset.  The following registers and bits are cleared by this bit:  - Buffer Data Port register  -- Buffer is cleared and initialized.  - Present state register  -- Buffer Read Enable  -- Buffer Write Enable  -- Read Transfer Active  -- Write Transfer Active  -- DAT Line Active  -- Command Inhibit (DAT)  - Block Gap Control register  -- Continue Request  -- Stop At Block Gap Request  - Normal Interrupt status register  -- Buffer Read Ready  -- Buffer Write Ready  -- DMA Interrupt  -- Block Gap Event  -- Transfer Complete RESET:0x0" "FALSE-0,TRUE-1"
          
         hexmask.long 0x00 3.--7. 1. " EMMC_REG_BLOCK_SW_RST_R_RSVD_7_3 ,These bits of the SW_RST_R register are reserved. They always return 0. RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "EMMC_REG_BLOCK_NORMAL_INT_STAT_R, This register reflects the status of the Normal Interrupt. This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_CMD_COMPLETE ,Command Complete   In an SD/eMMC Mode, this bit is set when the end bit of a response except for Auto CMD12 and Auto CMD23.  This interrupt is not generated when the Response Interrupt Disable in Transfer Mode Register is set to 1. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_XFER_COMPLETE ,Transfer Complete  This bit is set when a read/write transfer and a command with status busy is completed. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_BGAP_EVENT ,Block Gap Event  This bit is set when both read/write transaction is stopped at block gap due to a Stop at Block Gap Request. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_DMA_INTERRUPT ,DMA Interrupt  This bit is set if the Host Controller detects the SDMA Buffer Boundary during transfer. In case of ADMA, by setting the Int field in the descriptor table, the Host controller generates this interrupt. This interrupt is not generated after a Transfer Complete. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 4. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_BUF_WR_READY ,Buffer Write Ready  This bit is set if the Buffer Write Enable changes from 0 to 1. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 5. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_BUF_RD_READY ,Buffer Read Ready  This bit is set if the Buffer Read Enable changes from 0 to 1. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 6. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_CARD_INSERTION ,Card Insertion  This bit is set if the Card Inserted in the Present State register changes from 0 to 1. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 7. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_CARD_REMOVAL ,Card Removal  This bit is set if the Card Inserted in the Present State register changes from 1 to 0. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 8. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_CARD_INTERRUPT ,Card Interrupt  This bit reflects the synchronized value of:  - DAT[1] Interrupt Input for SD Mode  - DAT[2] Interrupt Input for UHS-II Mode RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 9. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_INT_A ,INT_A (Embedded)  This bit is set if INT_A is enabled and if INT_A# pin is in low level. The INT_A# pin is not supported. RESET:0x0"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_INT_B ,INT_B (Embedded)  This bit is set if INT_B is enabled and if INT_B# pin is in low level. The INT_B# pin is not supported. RESET:0x0"
          
         bitfld.long 0x00 11. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_INT_C ,INT_C (Embedded)  This bit is set if INT_C is enabled and if INT_C# pin is in low level. The INT_C# pin is not supported. RESET:0x0"
          
         bitfld.long 0x00 12. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_RE_TUNE_EVENT ,Re-tuning Event  This bit is set if the Re-Tuning Request changes from 0 to 1. Re-Tuning request is not supported. RESET:0x0"
          
         bitfld.long 0x00 13. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_FX_EVENT ,FX Event  This status is set when R[14] of response register is set to 1 and Response Type R1/R5 is set to 0 in Transfer Mode register. This interrupt is used with response check function. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 14. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_CQE_EVENT ,Command Queuing Event  This status is set if Command Queuing/Crypto related event has occurred in eMMC/SD mode. Read CQHCI's CQIS/CRNQIS register for more details. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 15. " EMMC_REG_BLOCK_NORMAL_INT_STAT_R_ERR_INTERRUPT ,Error Interrupt  If any of the bits in the Error Interrupt Status register are set, then this bit is set. RESET:0x0" "FALSE-0,TRUE-1"
          
group.long  0x32++0x3
    line.long 0x00 "EMMC_REG_BLOCK_ERROR_INT_STAT_R, This register enables an interrupt when the Error Interrupt Status Enable is enabled and at least one of the statuses is set to 1. Writing to 1 clears the bit and writing to 0 retains the bit unchanged. Signals defined in this register can be enabled by the Error Interrupt Status Enable register, but not by the Error Interrupt Signal Enable register. More than one status can be cleared with a single register write. This register is applicable for an SD/eMMC mode. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_CMD_TOUT_ERR ,Command Timeout Error  In SD/eMMC Mode,this bit is set only if no response is returned within 64 SD clock cycles from the end bit of the command. If the Host Controller detects a CMD line conflict, along with Command CRC Error bit, this bit is set to 1, without waiting for 64 SD/eMMC card clock cycles. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_CMD_CRC_ERR ,Command CRC Error  Command CRC Error is generated in SD/eMMC mode for following two cases.  - If a response is returned and the Command Timeout Error is set to 0 (indicating no timeout), this bit is set to 1 when detecting a CRC error in the command response.  - The Host Controller detects a CMD line conflict by monitoring the CMD line when a command is issued. If the Host Controller drives the CMD line to 1 level, but detects 0 level on the CMD line at the next SD clock edge, then the Host Controller terminates the command (stop driving CMD line) and set this bit to 1. The Command Timeout Error is also set to 1 to distinguish a CMD line conflict. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_CMD_END_BIT_ERR ,Command End Bit Error  This bit is set when detecting that the end bit of a command response is 0 in SD/eMMC mode. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_CMD_IDX_ERR ,Command Index Error  This bit is set if a Command Index error occurs in the command respons in SD/eMMC mode. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 4. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_DATA_TOUT_ERR ,Data Timeout Error  This bit is set in SD/eMMC mode when detecting one of the following timeout conditions:  - Busy timeout for R1b, R5b type  - Busy timeout after Write CRC status  - Write CRC Status timeout  - Read Data timeout RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 5. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_DATA_CRC_ERR ,Data CRC Error  This error occurs in SD/eMMC mode when detecting CRC error when transferring read data which uses the DAT line, when detecting the Write CRC status having a value of other than 010 or when write CRC status timeout. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 6. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_DATA_END_BIT_ERR ,Data End Bit Error  This error occurs in SD/eMMC mode either when detecting 0 at the end bit position of read data that uses the DAT line or at the end bit position of the CRC status. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 7. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_CUR_LMT_ERR ,Current Limit Error  By setting the SD Bus Power bit in the Power Control register, the Host Controller is requested to supply power for the SD Bus. If the Host Controller supports the Current Limit function, it can be protected from an illegal card by stopping power supply to the card in which case this bit indicates a failure status. A reading of 1 for this bit means that the Host Controller is not supplying power to the SD card due to some failure. A reading of 0 for this bit means that the Host Controller is supplying power and no error has occurred. The Host Controller may require some sampling time to detect the current limit. DWC_mshc Host Controller does not support this function, this bit is always set to 0. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 8. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_AUTO_CMD_ERR ,Auto CMD Error  This error status is used by Auto CMD12 and Auto CMD23 in SD/eMMC mode. This bit is set when detecting that any of the bits D00 to D05 in Auto CMD Error Status register has changed from 0 to 1. D07 is effective in case of Auto CMD12. Auto CMD Error Status register is valid while this bit is set to 1 and may be cleared by clearing of this bit. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 9. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_ADMA_ERR ,ADMA Error  This bit is set when the Host Controller detects error during ADMA-based data transfer. The error could be due to following reasons:  - Error response received from System bus (Manager I/F)  - ADMA3,ADMA2 Descriptors invalid  - CQE Task or Transfer descriptors invalid When the error occurs, the state of the ADMA is saved in the ADMA Error Status register.  In eMMC CQE mode:  The Host Controller generates this Interrupt when it detects an invalid descriptor data (Valid=0) at the ST_FDS state. ADMA Error State in the ADMA Error Status indicates that an error has occurred in ST_FDS state. The Host Driver may find that Valid bit is not set at the error descriptor. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_TUNING_ERR ,Tuning Error  This bit is set when an unrecoverable error is detected in a tuning circuit except during the tuning procedure (occurrence of an error during tuning procedure is indicated by Sampling Clock Select in the Host Control 2 register). By detecting Tuning Error, Host Driver needs to terminate a command executing and perform tuning. To reset tuning circuit, Sampling Clock Select is set to 0 before executing tuning procedure. The Tuning Error is higher priority than the other error interrupts generated during data transfer. By detecting Tuning Error, the Host Driver must discard data transferred by a current read/write command and retry data transfer after the Host Controller retrieved from the tuning circuit error. This is applicable in SD/eMMC mode. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 11. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_RESP_ERR ,Response Error  Host Controller Version 4.00 supports response error check function to avoid overhead of response error check by Host Driver during DMA execution. If Response Error Check Enable is set to 1 in the Transfer Mode register, Host Controller Checks R1 or R5 response. If an error is detected in a response, this bit is set to 1.This is applicable in SD/eMMC mode. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 12. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_BOOT_ACK_ERR ,Boot Acknowledgement Error  This bit is set when there is a timeout for boot acknowledgement or when detecting boot ack status having a value other than 010. This is applicable only when boot acknowledgement is expected in eMMC mode. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 13. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_VENDOR_ERR1 ,This bit (VENDOR_ERR1) of the ERROR_INT_STAT_R register is reserved. It always returns 0. RESET:0x0"
          
         bitfld.long 0x00 14. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_VENDOR_ERR2 ,This bit (VENDOR_ERR2) of the ERROR_INT_STAT_R register is reserved. It always returns 0. RESET:0x0"
          
         bitfld.long 0x00 15. " EMMC_REG_BLOCK_ERROR_INT_STAT_R_VENDOR_ERR3 ,This bit (VENDOR_ERR3) of the ERROR_INT_STAT_R register is reserved. It always returns 0. RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R, This register enables the Interrupt Status for Normal Interrupt Status register (NORMAL_INT_STAT_R) when NORMAL_INT_STAT_R is set to 1. This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_CMD_COMPLETE_STAT_EN ,Command Complete Status Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_XFER_COMPLETE_STAT_EN ,Transfer Complete Status Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_BGAP_EVENT_STAT_EN ,Block Gap Event Status Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_DMA_INTERRUPT_STAT_EN ,DMA Interrupt Status Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 4. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_BUF_WR_READY_STAT_EN ,Buffer Write Ready Status Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 5. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_BUF_RD_READY_STAT_EN ,Buffer Read Ready Status Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 6. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_CARD_INSERTION_STAT_EN ,Card Insertion Status Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 7. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_CARD_REMOVAL_STAT_EN ,Card Removal Status Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 8. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_CARD_INTERRUPT_STAT_EN ,Card Interrupt Status Enable  If this bit is set to 0, the Host Controller clears the interrupt request to the System. The Card Interrupt detection is stopped when this bit is cleared and restarted when this bit is set to 1. The Host Driver may clear the Card Interrupt Status Enable before servicing the Card Interrupt and may set this bit again after all interrupt requests from the card are cleared to prevent inadvertent interrupts.  By setting this bit to 0, interrupt input must be masked by implementation so that the interrupt input is not affected by external signal in any state (for example, floating). RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 9. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_INT_A_STAT_EN ,INT_A (Embedded) Status Enable  If this bit is set to 0, the Host Controller clears the interrupt request to the System. The Host Driver may clear this bit before servicing the INT_A and may set this bit again after all interrupt requests to INT_A pin are cleared to prevent inadvertent interrupts. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_INT_B_STAT_EN ,INT_B (Embedded) Status Enable  If this bit is set to 0, the Host Controller clears the interrupt request to the System. The Host Driver may clear this bit before servicing the INT_B and may set this bit again after all interrupt requests to INT_B pin are cleared to prevent inadvertent interrupts. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 11. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_INT_C_STAT_EN ,INT_C (Embedded) Status Enable  If this bit is set to 0, the Host Controller clears the interrupt request to the System. The Host Driver may clear this bit before servicing the INT_C and may set this bit again after all interrupt requests to INT_C pin are cleared to prevent inadvertent interrupts. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 12. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_RE_TUNE_EVENT_STAT_EN ,Re-Tuning Event (UHS-I only) Status Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 13. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_FX_EVENT_STAT_EN ,FX Event Status Enable  This bit is added from Version 4.10. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 14. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_CQE_EVENT_STAT_EN ,CQE Event Status Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 15. " EMMC_REG_BLOCK_NORMAL_INT_STAT_EN_R_RSVD_15 ,This bit of the NORMAL_INT_STAT_EN_R register is reserved. It always returns 0. RESET:0x0"
          
group.long  0x36++0x3
    line.long 0x00 "EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R, This register sets the Interrupt Status for Error Interrupt Status register (ERROR_INT_STAT_R), when ERROR_INT_STAT_EN_R is set to 1. This register is applicable for an SD/eMMC mode. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_CMD_TOUT_ERR_STAT_EN ,Command Timeout Error Status Enable (SD/eMMC Mode only). RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_CMD_CRC_ERR_STAT_EN ,Command CRC Error Status Enable (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_CMD_END_BIT_ERR_STAT_EN ,Command End Bit Error Status Enable (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_CMD_IDX_ERR_STAT_EN ,Command Index Error Status Enable (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 4. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_DATA_TOUT_ERR_STAT_EN ,Data Timeout Error Status Enable (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 5. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_DATA_CRC_ERR_STAT_EN ,Data CRC Error Status Enable (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 6. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_DATA_END_BIT_ERR_STAT_EN ,Data End Bit Error Status Enable (SD/eMMC Mode only). RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 7. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_CUR_LMT_ERR_STAT_EN ,Current Limit Error Status Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 8. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_AUTO_CMD_ERR_STAT_EN ,Auto CMD Error Status Enable (SD/eMMC Mode only). RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 9. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_ADMA_ERR_STAT_EN ,ADMA Error Status Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_TUNING_ERR_STAT_EN ,Tuning Error Status Enable (UHS-I Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 11. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_RESP_ERR_STAT_EN ,Response Error Status Enable (SD Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 12. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_BOOT_ACK_ERR_STAT_EN ,Boot Acknowledgment Error (eMMC Mode only)  Setting this bit to 1 enables setting of Boot Acknowledgment Error in Error Interrupt Status register (ERROR_INT_STAT_R). RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 13. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_VENDOR_ERR_STAT_EN1 ,The 13th bit of Error Interrupt Status Enable register is reserved. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 14. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_VENDOR_ERR_STAT_EN2 ,The 14th bit of Error Interrupt Status Enable register is reserved. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 15. " EMMC_REG_BLOCK_ERROR_INT_STAT_EN_R_VENDOR_ERR_STAT_EN3 ,The 15th bit of Error Interrupt Status Enable register is reserved. RESET:0x0" "FALSE-0,TRUE-1"
          
group.long  0x38++0x3
    line.long 0x00 "EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R, This register is used to select the interrupt status that is indicated to the Host System as the interrupt. All these status bits share the same 1-bit interrupt line. Setting any of these bits to 1, enables interrupt generation. This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_CMD_COMPLETE_SIGNAL_EN ,Command Complete Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_XFER_COMPLETE_SIGNAL_EN ,Transfer Complete Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_BGAP_EVENT_SIGNAL_EN ,Block Gap Event Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_DMA_INTERRUPT_SIGNAL_EN ,DMA Interrupt Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 4. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_BUF_WR_READY_SIGNAL_EN ,Buffer Write Ready Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 5. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_BUF_RD_READY_SIGNAL_EN ,Buffer Read Ready Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 6. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_CARD_INSERTION_SIGNAL_EN ,Card Insertion Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 7. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_CARD_REMOVAL_SIGNAL_EN ,Card Removal Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 8. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_CARD_INTERRUPT_SIGNAL_EN ,Card Interrupt Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 9. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_INT_A_SIGNAL_EN ,INT_A (Embedded) Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_INT_B_SIGNAL_EN ,INT_B (Embedded) Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 11. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_INT_C_SIGNAL_EN ,INT_C (Embedded) Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 12. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_RE_TUNE_EVENT_SIGNAL_EN ,Re-Tuning Event (UHS-I only) Signal Enable. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 13. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_FX_EVENT_SIGNAL_EN ,FX Event Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 14. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_CQE_EVENT_SIGNAL_EN ,Command Queuing Engine Event Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 15. " EMMC_REG_BLOCK_NORMAL_INT_SIGNAL_EN_R_RSVD_15 ,This bit of the NORMAL_INT_STAT_R register is reserved. It always returns 0. RESET:0x0"
          
group.long  0x3a++0x3
    line.long 0x00 "EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R, This register is used to select the interrupt status that is notified to the Host System as an interrupt. All these status bits share the same 1-bit interrupt line. Setting any of these bits to 1 enables interrupt generation. This register is applicable for an SD/eMMC mode. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_CMD_TOUT_ERR_SIGNAL_EN ,Command Timeout Error Signal Enable (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_CMD_CRC_ERR_SIGNAL_EN ,Command CRC Error Signal Enable (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_CMD_END_BIT_ERR_SIGNAL_EN ,Command End Bit Error Signal Enable (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_CMD_IDX_ERR_SIGNAL_EN ,Command Index Error Signal Enable (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 4. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_DATA_TOUT_ERR_SIGNAL_EN ,Data Timeout Error Signal Enable (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 5. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_DATA_CRC_ERR_SIGNAL_EN ,Data CRC Error Signal Enable (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 6. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_DATA_END_BIT_ERR_SIGNAL_EN ,Data End Bit Error Signal Enable (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 7. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_CUR_LMT_ERR_SIGNAL_EN ,Current Limit Error Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 8. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_AUTO_CMD_ERR_SIGNAL_EN ,Auto CMD Error Signal Enable (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 9. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_ADMA_ERR_SIGNAL_EN ,ADMA Error Signal Enable RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_TUNING_ERR_SIGNAL_EN ,Tuning Error Signal Enable (UHS-I Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 11. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_RESP_ERR_SIGNAL_EN ,Response Error Signal Enable (SD Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 12. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_BOOT_ACK_ERR_SIGNAL_EN ,Boot Acknowledgment Error (eMMC Mode only).  Setting this bit to 1 enables generating interrupt signal when Boot Acknowledgement Error in Error Interrupt Status register is set. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 13. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_VENDOR_ERR_SIGNAL_EN1 ,The 14th bit of Error Interrupt Signal Enable is reserved. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 14. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_VENDOR_ERR_SIGNAL_EN2 ,The 15th bit of Error Interrupt Signal Enable is reserved. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 15. " EMMC_REG_BLOCK_ERROR_INT_SIGNAL_EN_R_VENDOR_ERR_SIGNAL_EN3 ,The 16th bit of Error Interrupt Signal Enable is reserved. RESET:0x0" "FALSE-0,TRUE-1"
          
rgroup.long 0x3c++0x3
    line.long 0x00 "EMMC_REG_BLOCK_AUTO_CMD_STAT_R, This register is used to indicate the CMD12 response error of Auto CMD12, and the CMD23 response error of Auto CMD23. The Host driver can determine the kind of Auto CMD12/CMD23 errors that can occur in this register. Auto CMD23 errors are indicated in bit 04-01. This register is valid only when Auto CMD Error is set. This register is applicable for an SD/eMMC mode. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_AUTO_CMD_STAT_R_AUTO_CMD12_NOT_EXEC ,Auto CMD12 Not Executed  If multiple memory block data transfer is not started due to a command error, this bit is not set because it is not necessary to issue an Auto CMD12. Setting this bit to 1 means that the Host Controller cannot issue Auto CMD12 to stop multiple memory block data transfer, due to some error. If this bit is set to 1, error status bits (D04-D01) is meaningless.  This bit is set to 0 when Auto CMD Error is generated by Auto CMD23. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_AUTO_CMD_STAT_R_AUTO_CMD_TOUT_ERR ,Auto CMD Timeout Error  This bit is set if no response is returned with 64 SDCLK cycles from the end bit of the command.  If this bit is set to 1, error status bits (D04-D01) are meaningless. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_AUTO_CMD_STAT_R_AUTO_CMD_CRC_ERR ,Auto CMD CRC Error  This bit is set when detecting a CRC error in the command response. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_AUTO_CMD_STAT_R_AUTO_CMD_EBIT_ERR ,Auto CMD End Bit Error  This bit is set when detecting that the end bit of command response is 0. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 4. " EMMC_REG_BLOCK_AUTO_CMD_STAT_R_AUTO_CMD_IDX_ERR ,Auto CMD Index Error  This bit is set if the command index error occurs in response to a command. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 5. " EMMC_REG_BLOCK_AUTO_CMD_STAT_R_AUTO_CMD_RESP_ERR ,Auto CMD Response Error  This bit is set when Response Error Check Enable in the Transfer Mode register is set to 1 and an error is detected in R1 response of either Auto CMD12 or CMD13. This status is ignored if any bit between D00 to D04 is set to 1. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 6. " EMMC_REG_BLOCK_AUTO_CMD_STAT_R_RSVD_6 ,This bit of the AUTO_CMD_STAR_R register is reserved. It always returns 0. RESET:0x0"
          
         bitfld.long 0x00 7. " EMMC_REG_BLOCK_AUTO_CMD_STAT_R_CMD_NOT_ISSUED_AUTO_CMD12 ,Command Not Issued By Auto CMD12 Error  If this bit is set to 1, CMD_wo_DAT is not executed due to an Auto CMD12 Error (D04-D01) in this register.  This bit is set to 0 when Auto CMD Error is generated by Auto CMD23. RESET:0x0" "FALSE-0,TRUE-1"
          
         hexmask.long 0x00 8.--15. 1. " EMMC_REG_BLOCK_AUTO_CMD_STAT_R_RSVD_15_8 ,These bits of the AUTO_CMD_STAT_R register are reserved bits. They always return 0. RESET:0x0"
          
group.long  0x3e++0x3
    line.long 0x00 "EMMC_REG_BLOCK_HOST_CTRL2_R, This register is used to control how the Host Controller operates. This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         bitfld.long 0x00 0.--2. " EMMC_REG_BLOCK_HOST_CTRL2_R_UHS_MODE_SEL ,UHS Mode/eMMC Speed Mode Select  These bits are used to select UHS mode in the SD mode of operation. In eMMC mode, these bits are used to select eMMC Speed mode.   UHS Mode (SD/UHS-II mode only):  - 0x0: SDR12  - 0x1: SDR25  - 0x2: SDR50  - 0x3: SDR104  - 0x4: DDR50  - 0x5: Reserved  - 0x6: Reserved  - 0x7: UHS-II  eMMC Speed Mode (eMMC mode only):  - 0x0: Legacy  - 0x1: High Speed SDR  - 0x2: Reserved  - 0x3: HS200  - 0x4: High Speed DDR  - 0x5: Reserved  - 0x6: Reserved  - 0x7: HS400 RESET:0x0" "DDR50-4,RSVD5-5,RSVD6-6,SDR104-3,SDR12-0,SDR25-1,SDR50-2,UHS2-7"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_HOST_CTRL2_R_SIGNALING_EN ,1.8V Signaling Enable  This bit controls voltage regulator for I/O cell in UHS-I/eMMC speed modes. Setting this bit from 0 to 1 starts changing the signal voltage from 3.3V to 1.8V. Host Controller clears this bit if switching to 1.8 signaling fails. The value is reflected on the uhs1_swvolt_en pin.  Note: This bit must be set for all UHS-I speed modes (SDR12/SDR25/SDR50/SDR104/DDR50). RESET:0x0" "V_1_8-1,V_3_3-0"
          
         bitfld.long 0x00 4.--5. " EMMC_REG_BLOCK_HOST_CTRL2_R_DRV_STRENGTH_SEL ,Driver Strength Select  This bit is used to select the Host Controller output driver in 1.8V signaling UHS-I/eMMC speed modes. The bit depends on setting of Preset Value Enable. The value is reflected on the uhs1_drv_sth pin. RESET:0x0" "TYPEA-1,TYPEB-0,TYPEC-2,TYPED-3"
          
         bitfld.long 0x00 6. " EMMC_REG_BLOCK_HOST_CTRL2_R_EXEC_TUNING ,Execute Tuning  This bit is set to 1 to start the tuning procedure in UHS-I/eMMC speed modes and this bit is automatically cleared when tuning procedure is completed. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 7. " EMMC_REG_BLOCK_HOST_CTRL2_R_SAMPLE_CLK_SEL ,Sampling Clock Select  This bit is used by the Host Controller to select the sampling clock in SD/eMMC mode to receive CMD and DAT. This bit is set by the tuning procedure and is valid after the completion of tuning (when Execute Tuning is cleared). Setting this bit to 1 means that tuning is completed successfully and setting this bit to 0 means that tuning has failed. The value is reflected on the sample_cclk_sel pin. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 8. " EMMC_REG_BLOCK_HOST_CTRL2_R_UHS2_IF_ENABLE ,UHS-II Interface Enable  This bit is used to enable the UHS-II Interface. The value is reflected on the uhs2_if_en pin. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 9. " EMMC_REG_BLOCK_HOST_CTRL2_R_RSVD_9 ,This bit of the HOST_CTRL2_R register is reserved. It always returns 0. RESET:0x0"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_HOST_CTRL2_R_ADMA2_LEN_MODE ,ADMA2 Length Mode  This bit selects ADMA2 Length mode to be either 16-bit or 26-bit. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 11. " EMMC_REG_BLOCK_HOST_CTRL2_R_CMD23_ENABLE ,CMD23 Enable  If the card supports CMD23, this bit is set to 1. This bit is used to select Auto CMD23 or Auto CMD12 for ADMA3 data transfer. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 12. " EMMC_REG_BLOCK_HOST_CTRL2_R_HOST_VER4_ENABLE ,Host Version 4 Enable  This bit selects either Version 3.00 compatible mode or Version 4 mode.  Functions of following fields are modified for Host Version 4 mode:  - SDMA Address: SDMA uses ADMA System Address (05Fh-058h) instead of SDMA System Address register (003h-000h)  - ADMA2/ADMA3 selection: ADMA3 is selected by DMA select in Host Control 1 register  - 64-bit ADMA Descriptor Size: 128-bit descriptor is used instead of 96-bit descriptor when 64-bit Addressing is set to 1  - Selection of 32-bit/64-bit System Addressing: Either 32-bit or 64-bit system addressing is selected by 64-bit Addressing bit in this register  - 32-bit Block Count: SDMA System Address register (003h-000h) is modified to 32-bit Block Count register  Note: It is recommended not to program ADMA3 Integrated Descriptor Address registers, UHS-II registers and Command Queuing registers (if applicable) while operating in Host version less than 4 mode (Host Version 4 Enable = 0). RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 13. " EMMC_REG_BLOCK_HOST_CTRL2_R_ADDRESSING ,64-bit Addressing  This bit is effective when Host Version 4 Enable is set to 1. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 14. " EMMC_REG_BLOCK_HOST_CTRL2_R_ASYNC_INT_ENABLE ,Asynchronous Interrupt Enable  This bit can be set if a card supports asynchronous interrupts and Asynchronous Interrupt Support is set to 1 in the Capabilities register. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 15. " EMMC_REG_BLOCK_HOST_CTRL2_R_PRESET_VAL_ENABLE ,Preset Value Enable  This bit enables automatic selection of SDCLK frequency and Driver strength Preset Value registers. When Preset Value Enable is set, SDCLK frequency generation (Frequency Select and Clock Generator Select) and the driver strength selection are performed by the controller. These values are selected from set of Preset Value registers based on selected speed mode.  Note: For more information, see the FAQ on Preset Register in the DWC_mshc Databook. RESET:0x0" "FALSE-0,TRUE-1"
          
rgroup.long 0x40++0x3
    line.long 0x00 "EMMC_REG_BLOCK_CAPABILITIES1_R, This register provides the Host Driver with information specific to the Host Controller implementation. The host controller may implement these values as fixed or loaded from the flash memory during power on initialization. Capabilities register is segregated into two 32-bit registers: CAPABILITIES1_R and CAPABILITIES2_R. The CAPABILITIES1_R register is the lower part of Capabilities register. RESET:0x3c6ec820"
         hexmask.long 0x00 0.--5. 1. " EMMC_REG_BLOCK_CAPABILITIES1_R_TOUT_CLK_FREQ ,Timeout Clock Frequency  This bit shows the base clock frequency used to detect Data Timeout Error. The Timeout Clock unit defines the unit of timeout clock frequency. It can be KHz or MHz.  - 0x00 : Get information through another method  - 0x01 :  1KHz /  1MHz  - 0x02 :  2KHz /  2MHz  - 0x03 :  3KHz /  3MHz  -  ...........  - 0x3F : 63KHz / 63MHz RESET:0x20"
          
         bitfld.long 0x00 6. " EMMC_REG_BLOCK_CAPABILITIES1_R_RSVD_6 ,This bit of the CAPABILITIES1_R register is reserved. It always returns 0. RESET:0x0"
          
         bitfld.long 0x00 7. " EMMC_REG_BLOCK_CAPABILITIES1_R_TOUT_CLK_UNIT ,Timeout Clock Unit  This bit shows the unit of base clock frequency used to detect Data TImeout Error. RESET:0x0" "KHZ-0,MHZ-1"
          
         hexmask.long 0x00 8.--15. 1. " EMMC_REG_BLOCK_CAPABILITIES1_R_BASE_CLK_FREQ ,Base Clock Frequency for SD clock  These bits indicate the base (maximum) clock frequency for the SD Clock. The definition of these bits depend on the Host Controller Version.  - 6-Bit Base Clock Frequency: This mode is supported by the Host Controller version 1.00 and 2.00. The upper 2 bits are not effective and are always 0. The unit values are 1 MHz. The supported clock range is 10 MHz to 63 MHz.  -- 0x00 : Get information through another method  -- 0x01 : 1 MHz  -- 0x02 : 2 MHz  -- .............  -- 0x3F : 63 MHz  -- 0x40-0xFF : Not Supported  - 8-Bit Base Clock Frequency: This mode is supported by the Host Controller version 3.00. The unit values are 1 MHz. The supported clock range is 10 MHz to 255 MHz.  -- 0x00 : Get information through another method  -- 0x01 : 1 MHz  -- 0x02 : 2 MHz  -- ............  -- 0xFF : 255 MHz If the frequency is 16.5 MHz, the larger value is set to 0001001b (17 MHz) because the Host Driver uses this value to calculate the clock divider value and it does not exceed the upper limit of the SD Clock frequency. If these bits are all 0, the Host system has to get information using a different method. RESET:0xc8"
          
         bitfld.long 0x00 16.--17. " EMMC_REG_BLOCK_CAPABILITIES1_R_MAX_BLK_LEN ,Maximum Block Length  This bit indicates the maximum block size that the Host driver can read and write to the buffer in the Host Controller. The buffer transfers this block size without wait cycles. The transfer block length is always 512 bytes for the SD Memory irrespective of this bit RESET:0x2" "ONE-1,THREE-3,TWO-2,ZERO-0"
          
         bitfld.long 0x00 18. " EMMC_REG_BLOCK_CAPABILITIES1_R_EMBEDDED_8_BIT ,8-bit Support for Embedded Device  This bit indicates whether the Host Controller is capable of using an 8-bit bus width mode. This bit is not effective when the Slot Type is set to 10b. RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 19. " EMMC_REG_BLOCK_CAPABILITIES1_R_ADMA2_SUPPORT ,ADMA2 Support  This bit indicates whether the Host Controller is capable of using ADMA2. RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 20. " EMMC_REG_BLOCK_CAPABILITIES1_R_RSVD_20 ,This bit of the CAPABILITIES1_R is a reserved. It always returns 0. RESET:0x0"
          
         bitfld.long 0x00 21. " EMMC_REG_BLOCK_CAPABILITIES1_R_HIGH_SPEED_SUPPORT ,High Speed Support  This bit indicates whether the Host Controller and the Host System supports High Speed mode and they can supply the SD Clock frequency from 25 MHz to 50 MHz. RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 22. " EMMC_REG_BLOCK_CAPABILITIES1_R_SDMA_SUPPORT ,SDMA Support  This bit indicates whether the Host Controller is capable of using SDMA to transfer data between the system memory and the Host Controller directly. RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 23. " EMMC_REG_BLOCK_CAPABILITIES1_R_SUS_RES_SUPPORT ,Suspense/Resume Support  This bit indicates whether the Host Controller supports Suspend/Resume functionality. If this bit is 0, the Host Driver does not issue either Suspend or Resume commands because the Suspend and Resume mechanism is not supported. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 24. " EMMC_REG_BLOCK_CAPABILITIES1_R_VOLT_33 ,Voltage Support for 3.3V RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 25. " EMMC_REG_BLOCK_CAPABILITIES1_R_VOLT_30 ,Voltage Support for SD 3.0V or Embedded 1.2V RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 26. " EMMC_REG_BLOCK_CAPABILITIES1_R_VOLT_18 ,Voltage Support for 1.8V RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 27. " EMMC_REG_BLOCK_CAPABILITIES1_R_SYS_ADDR_64_V4 ,64-bit System Address Support for V4  This bit sets the Host Controller to support 64-bit System Addressing of V4 mode. When this bit is set to 1, full or part of 64-bit address must be used to decode the Host Controller Registers so that Host Controller Registers can be placed above system memory area. 64-bit address decode of Host Controller registers is effective regardless of setting to 64-bit Addressing in Host Control 2.  If this bit is set to 1, 64-bit DMA Addressing for version 4 is enabled by setting Host Version 4 Enable (HOST_VER4_ENABLE = 1) and by setting 64-bit Addressing (ADDRESSING =1) in the Host Control 2 register. SDMA can be used and ADMA2 uses 128-bit Descriptor. RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 28. " EMMC_REG_BLOCK_CAPABILITIES1_R_SYS_ADDR_64_V3 ,64-bit System Address Support for V3  This bit sets the Host controller to support 64-bit System Addressing of V3 mode.  SDMA cannot be used in 64-bit Addressing in Version 3 Mode.  If this bit is set to 1, 64-bit ADMA2 with using 96-bit Descriptor can be enabled by setting Host Version 4 Enable (HOST_VER4_ENABLE = 0) and DMA select (DMA_SEL = 11b). RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 29. " EMMC_REG_BLOCK_CAPABILITIES1_R_ASYNC_INT_SUPPORT ,Asynchronous Interrupt Support (SD Mode only) RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 30.--31. " EMMC_REG_BLOCK_CAPABILITIES1_R_SLOT_TYPE_R ,Slot Type  These bits indicate usage of a slot by a specific Host System. RESET:0x0" "EMBEDDED_SLOT-1,REMOVABLE_SLOT-0,SHARED_SLOT-2,UHS2_EMBEDDED_SLOT-3"
          
rgroup.long 0x44++0x3
    line.long 0x00 "EMMC_REG_BLOCK_CAPABILITIES2_R, This register provides the Host Driver with information specific to the Host Controller implementation. The host controller may implement these values as fixed or as loaded from flash memory during power on initialization. Capabilities register is segregated into two 32-bit registers, namely CAPABILITIES1_R and CAPABILITIES2_R. The CAPABILITIES2_R register is upper part of Capabilities register. RESET:0x8008777"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_CAPABILITIES2_R_SDR50_SUPPORT ,SDR50 Support (UHS-I only)  Thsi bit indicates that SDR50 is supported. The bit 13 (USE_TUNING_SDR50) indicates whether SDR50 requires tuning or not. RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_CAPABILITIES2_R_SDR104_SUPPORT ,SDR104 Support (UHS-I only)  This bit mentions that SDR104 requires tuning. RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_CAPABILITIES2_R_DDR50_SUPPORT ,DDR50 Support (UHS-I only) RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_CAPABILITIES2_R_UHS2_SUPPORT ,UHS-II Support (UHS-II only)  This bit indicates whether Host Controller supports UHS-II. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 4. " EMMC_REG_BLOCK_CAPABILITIES2_R_DRV_TYPEA ,Driver Type A Support (UHS-I only)  This bit indicates support of Driver Type A for 1.8 Signaling. RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 5. " EMMC_REG_BLOCK_CAPABILITIES2_R_DRV_TYPEC ,Driver Type C Support (UHS-I only)  This bit indicates support of Driver Type C for 1.8 Signaling. RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 6. " EMMC_REG_BLOCK_CAPABILITIES2_R_DRV_TYPED ,Driver Type D Support (UHS-I only)  This bit indicates support of Driver Type D for 1.8 Signaling. RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 7. " EMMC_REG_BLOCK_CAPABILITIES2_R_RSVD_39 ,This bit (RSVD_39) of the CAPABILITIES2_R register is reserved. It always returns 0. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " EMMC_REG_BLOCK_CAPABILITIES2_R_RETUNE_CNT ,Timer Count for Re-Tuning (UHS-I only) - 0x0: Re-Tuning Timer disabled - 0x1: 1 seconds - 0x2: 2 seconds - 0x3: 4 seconds -  ........ - 0xB: 1024 seconds - 0xC: Reserved - 0xD: Reserved - 0xE: Reserved - 0xF: Get information from other source RESET:0x7"
          
         bitfld.long 0x00 12. " EMMC_REG_BLOCK_CAPABILITIES2_R_RSVD_44 ,This bit (RSVD_44) of the CAPABILITIES2_R register is reserved. It always returns 0. RESET:0x0"
          
         bitfld.long 0x00 13. " EMMC_REG_BLOCK_CAPABILITIES2_R_USE_TUNING_SDR50 ,Use Tuning for SDR50 (UHS-I only) RESET:0x0" "ONE-1,ZERO-0"
          
         bitfld.long 0x00 14.--15. " EMMC_REG_BLOCK_CAPABILITIES2_R_RE_TUNING_MODES ,Re-Tuning Modes (UHS-I only)  These bits select the re-tuning method and limit the maximum data length. RESET:0x2" "MODE1-0,MODE2-1,MODE3-2,RSVD_MODE-3"
          
         hexmask.long 0x00 16.--23. 1. " EMMC_REG_BLOCK_CAPABILITIES2_R_CLK_MUL ,Clock Multiplier  These bits indicate the clock multiplier of the programmable clock generator. Setting these bits to 0 means that the Host Controller does not support a programmable clock generator.  - 0x0: Clock Multiplier is not Supported  - 0x1: Clock Multiplier M = 2  - 0x2: Clock Multiplier M = 3  -   .........  - 0xFF: Clock Multiplier M = 256 RESET:0x0"
          
         hexmask.long 0x00 24.--26. 1. " EMMC_REG_BLOCK_CAPABILITIES2_R_RSVD_56_58 ,These bits (RSVD_56_58) of the CAPABILITIES2_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 27. " EMMC_REG_BLOCK_CAPABILITIES2_R_ADMA3_SUPPORT ,ADMA3 Support  This bit indicates whether the Host Controller is capable of using ADMA3. RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 28. " EMMC_REG_BLOCK_CAPABILITIES2_R_VDD2_18V_SUPPORT ,1.8V VDD2 Support  This bit indicates support of VDD2 for the Host System. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 29. " EMMC_REG_BLOCK_CAPABILITIES2_R_RSVD_61 ,This bit (RSVD_61) of the CAPABILITIES2_R register is reserved. It always returns 0. RESET:0x0"
          
         hexmask.long 0x00 30.--31. 1. " EMMC_REG_BLOCK_CAPABILITIES2_R_RSVD_62_63 ,These bits (RSVD_62_63) of the CAPABILITIES2_R register are reserved bits. They always return 0. RESET:0x0"
          
rgroup.long 0x48++0x3
    line.long 0x00 "EMMC_REG_BLOCK_CURR_CAPABILITIES1_R, This register indicate the maximum current capability for each voltage, for VDD1. The value is meaningful if the Voltage Support is set in the Capabilities register. If this information is supplied by the Host System through another method, all the Maximum Current Capabilities registers are set to 0. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EMMC_REG_BLOCK_CURR_CAPABILITIES1_R_MAX_CUR_33V ,Maximum Current for 3.3V This bit specifies the Maximum Current for 3.3V VDD1 power supply for the card.  - 0: Get information through another method  - 1: 4mA  - 2: 8mA  - 3: 13mA  - .......  - 255: 1020mA RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " EMMC_REG_BLOCK_CURR_CAPABILITIES1_R_MAX_CUR_30V ,Maximum Current for 3.0V This bit specifies the Maximum Current for 3.0V VDD1 power supply for the card.  - 0: Get information through another method  - 1: 4mA  - 2: 8mA  - 3: 13mA  - .......  - 255: 1020mA RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " EMMC_REG_BLOCK_CURR_CAPABILITIES1_R_MAX_CUR_18V ,Maximum Current for 1.8V This bit specifies the Maximum Current for 1.8V VDD1 power supply for the card.  - 0: Get information through another method  - 1: 4mA  - 2: 8mA  - 3: 13mA  - .......  - 255: 1020mA RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " EMMC_REG_BLOCK_CURR_CAPABILITIES1_R_RSVD_31_24 ,These bits of the CURR_CAPABILITIES1_R register are reserved. They always return 0. RESET:0x0"
          
rgroup.long 0x4c++0x3
    line.long 0x00 "EMMC_REG_BLOCK_CURR_CAPABILITIES2_R, This register indicates the maximum current capability for each voltage (for VDD2). The value is meaningful if Voltage Support is set in the Capabilities register. If this information is supplied by the Host System through another method, all the Maximum Current Capabilities registers are set to 0. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EMMC_REG_BLOCK_CURR_CAPABILITIES2_R_MAX_CUR_VDD2_18V ,Maximum Current for 1.8V VDD2 This bit specifies the Maximum Current for 1.8V VDD2 power supply for the UHS-II card.  - 0: Get information through another method  - 1: 4mA  - 2: 8mA  - 3: 13mA  - .......  - 255: 1020mA RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "EMMC_REG_BLOCK_FORCE_AUTO_CMD_STAT_R, The register is not a physically implemented but is an address at which the Auto CMD Error Status register can be written.This register is applicable for an SD/eMMC mode. - 1 : Sets each bit of the Auto CMD Error Status register - 0 : No effect RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_FORCE_AUTO_CMD_STAT_R_FORCE_AUTO_CMD12_NOT_EXEC ,Force Event for Auto CMD12 Not Executed RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_FORCE_AUTO_CMD_STAT_R_FORCE_AUTO_CMD_TOUT_ERR ,Force Event for Auto CMD Timeout Error RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_FORCE_AUTO_CMD_STAT_R_FORCE_AUTO_CMD_CRC_ERR ,Force Event for Auto CMD CRC Error RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_FORCE_AUTO_CMD_STAT_R_FORCE_AUTO_CMD_EBIT_ERR ,Force Event for Auto CMD End Bit Error RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 4. " EMMC_REG_BLOCK_FORCE_AUTO_CMD_STAT_R_FORCE_AUTO_CMD_IDX_ERR ,Force Event for Auto CMD Index Error RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 5. " EMMC_REG_BLOCK_FORCE_AUTO_CMD_STAT_R_FORCE_AUTO_CMD_RESP_ERR ,Force Event for Auto CMD Response Error RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 6. " EMMC_REG_BLOCK_FORCE_AUTO_CMD_STAT_R_RSVD_6 ,This bit of the FORCE_AUTO_CMD_STAT_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 7. " EMMC_REG_BLOCK_FORCE_AUTO_CMD_STAT_R_FORCE_CMD_NOT_ISSUED_AUTO_CMD12 ,Force Event for Command Not Issued By Auto CMD12 Error RESET:0x0" "FALSE-0,TRUE-1"
          
         hexmask.long 0x00 8.--15. 1. " EMMC_REG_BLOCK_FORCE_AUTO_CMD_STAT_R_RSVD_15_8 ,These bits of the FORCE_AUTO_CMD_STAT_R register are reserved. They always return 0. RESET:0x0"
          
wgroup.long 0x52++0x3
    line.long 0x00 "EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R, This register is not physically implemented but is an address at which the Error Interrupt Status register can be written. The effect of a write to this address is reflected in the Error Interrupt Status register if the corresponding bit of the Error Interrupt Status Enable register is set. This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_CMD_TOUT_ERR ,Force Event for Command Timeout Error (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_CMD_CRC_ERR ,Force Event for Command CRC Error (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_CMD_END_BIT_ERR ,Force Event for Command End Bit Error (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_CMD_IDX_ERR ,Force Event for Command Index Error (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 4. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_DATA_TOUT_ERR ,Force Event for Data Timeout Error (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 5. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_DATA_CRC_ERR ,Force Event for Data CRC Error (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 6. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_DATA_END_BIT_ERR ,Force Event for Data End Bit Error (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 7. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_CUR_LMT_ERR ,Force Event for Current Limit Error RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 8. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_AUTO_CMD_ERR ,Force Event for Auto CMD Error (SD/eMMC Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 9. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_ADMA_ERR ,Force Event for ADMA Error RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_TUNING_ERR ,Force Event for Tuning Error (UHS-I Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 11. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_RESP_ERR ,Force Event for Response Error (SD Mode only) RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 12. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_BOOT_ACK_ERR ,Force Event for Boot Ack error RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 13. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_VENDOR_ERR1 ,This bit (FORCE_VENDOR_ERR1) of the FORCE_ERROR_INT_STAT_R register is reserved. It always returns 0. RESET:0x0"
          
         bitfld.long 0x00 14. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_VENDOR_ERR2 ,This bit (FORCE_VENDOR_ERR2) of the FORCE_ERROR_INT_STAT_R register is reserved. It always returns 0. RESET:0x0"
          
         bitfld.long 0x00 15. " EMMC_REG_BLOCK_FORCE_ERROR_INT_STAT_R_FORCE_VENDOR_ERR3 ,This bit (FORCE_VENDOR_ERR3) of the FORCE_ERROR_INT_STAT_R register is reserved. It always returns 0. RESET:0x0"
          
rgroup.long 0x54++0x3
    line.long 0x00 "EMMC_REG_BLOCK_ADMA_ERR_STAT_R, This register stores the ADMA state during an ADMA error. This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         bitfld.long 0x00 0.--1. " EMMC_REG_BLOCK_ADMA_ERR_STAT_R_ADMA_ERR_STATES ,ADMA Error States  These bits indicate the state of ADMA when an error occurs during ADMA data transfer. RESET:0x0" "ST_FDS-1,ST_STOP-0,ST_TFR-3,UNUSED-2"
          
         bitfld.long 0x00 2. " EMMC_REG_BLOCK_ADMA_ERR_STAT_R_ADMA_LEN_ERR ,ADMA Length Mismatch Error States  This error occurs in the following instances:  - While the Block Count Enable is being set, the total data length specified by the Descriptor table is different from that specified by the Block Count and Block Length  - When the total data length cannot be divided by the block length RESET:0x0" "ERROR-1,NO_ERR-0"
          
         hexmask.long 0x00 3.--7. 1. " EMMC_REG_BLOCK_ADMA_ERR_STAT_R_RSVD_7_3 ,These bits of the ADMA_ERR_STAT_R register are reserved. They always return 0. RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "EMMC_REG_BLOCK_ADMA_SA_LOW_R, This register holds the lower 32-bit system address for DMA transfer. This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_BLOCK_ADMA_SA_LOW_R_ADMA_SA_LOW ,ADMA System Address  These bits indicate the lower 32 bits of the ADMA system address.  - SDMA: If Host Version 4 Enable is set to 1, this register stores the system address of the data location  - ADMA2: This register stores the byte address of the executing command of the descriptor table  - ADMA3: This register is set by ADMA3. ADMA2 increments the address of this register that points to the next line, every time a Descriptor line is fetched. RESET:0x0"
          
group.long  0x5c++0x3
    line.long 0x00 "EMMC_REG_BLOCK_ADMA_SA_HIGH_R, This register holds the upper 32-bit system address for the DMA transfer. This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_BLOCK_ADMA_SA_HIGH_R_ADMA_SA_HIGH ,ADMA System Address  These bits indicate the higher 32-bit of the ADMA system address. RESET:0x0"
          
rgroup.long 0x60++0x3
    line.long 0x00 "EMMC_REG_BLOCK_PRESET_INIT_R, This register defines Preset Value for Initialization in SD/eMMC mode. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " EMMC_REG_BLOCK_PRESET_INIT_R_FREQ_SEL_VAL ,SDCLK/RCLK Frequency Select Value  10-bit preset value to be set in SDCLK/RCLK Frequency Select field of the Clock Control register described by a Host System. RESET:0x0"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_PRESET_INIT_R_CLK_GEN_SEL_VAL ,Clock Generator Select Value  This bit is effective when the Host Controller supports a programmable clock generator. RESET:0x0" "FALSE-0,PROG-1"
          
         hexmask.long 0x00 11.--13. 1. " EMMC_REG_BLOCK_PRESET_INIT_R_RSVD_13_11 ,These bits of the PRESET_INIT_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 14.--15. " EMMC_REG_BLOCK_PRESET_INIT_R_DRV_SEL_VAL ,Driver Strength Select Value  These bits indicate that the Driver strength is supported by 1.8V signaling bus speed modes. These bits are meaningless for 3.3V signaling. RESET:0x0" "TYPEA-1,TYPEB-0,TYPEC-2,TYPED-3"
          
rgroup.long 0x62++0x3
    line.long 0x00 "EMMC_REG_BLOCK_PRESET_DS_R, This register defines Preset Value for Default Speed mode in SD mode. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " EMMC_REG_BLOCK_PRESET_DS_R_FREQ_SEL_VAL ,SDCLK/RCLK Frequency Select Value  10-bit preset value to be set in SDCLK/RCLK Frequency Select field of the Clock Control register described by a Host System. RESET:0x0"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_PRESET_DS_R_CLK_GEN_SEL_VAL ,Clock Generator Select Value  This bit is effective when Host Controller supports programmable clock generator. RESET:0x0" "FALSE-0,PROG-1"
          
         hexmask.long 0x00 11.--13. 1. " EMMC_REG_BLOCK_PRESET_DS_R_RSVD_13_11 ,These bits of the PRESET_DS_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 14.--15. " EMMC_REG_BLOCK_PRESET_DS_R_DRV_SEL_VAL ,Driver Strength Select Value  These bits indicate the Driver strength value supported by 1.8V signaling bus speed modes. This field is meaningless for the Default speed mode as it uses 3.3V signaling. RESET:0x0" "TYPEA-1,TYPEB-0,TYPEC-2,TYPED-3"
          
rgroup.long 0x64++0x3
    line.long 0x00 "EMMC_REG_BLOCK_PRESET_HS_R, This register defines Preset Value for High Speed mode in SD mode. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " EMMC_REG_BLOCK_PRESET_HS_R_FREQ_SEL_VAL ,SDCLK/RCLK Frequency Select Value  10-bit preset value to be set in SDCLK/RCLK Frequency Select field of the Clock Control register described by a Host System. RESET:0x0"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_PRESET_HS_R_CLK_GEN_SEL_VAL ,Clock Generator Select Value  This bit is effective when Host Controller supports programmable clock generator. RESET:0x0" "FALSE-0,PROG-1"
          
         hexmask.long 0x00 11.--13. 1. " EMMC_REG_BLOCK_PRESET_HS_R_RSVD_13_11 ,These bits of the PRESET_HS_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 14.--15. " EMMC_REG_BLOCK_PRESET_HS_R_DRV_SEL_VAL ,Driver Strength Select Value  These bits indicate the Driver strength value supported by 1.8V signaling bus speed modes. This field is meaningless for High speed mode as it uses 3.3V signaling. RESET:0x0" "TYPEA-1,TYPEB-0,TYPEC-2,TYPED-3"
          
rgroup.long 0x66++0x3
    line.long 0x00 "EMMC_REG_BLOCK_PRESET_SDR12_R, This register defines Preset Value for SDR12 and Legacy speed mode in SD and eMMC mode respectively. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " EMMC_REG_BLOCK_PRESET_SDR12_R_FREQ_SEL_VAL ,SDCLK/RCLK Frequency Select Value  10-bit preset value to be set in SDCLK/RCLK Frequency Select field of the Clock Control register described by a Host System. RESET:0x0"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_PRESET_SDR12_R_CLK_GEN_SEL_VAL ,Clock Generator Select Value  This bit is effective when Host Controller supports programmable clock generator RESET:0x0" "FALSE-0,PROG-1"
          
         hexmask.long 0x00 11.--13. 1. " EMMC_REG_BLOCK_PRESET_SDR12_R_RSVD_13_11 ,These bits of the PRESET_SDR12_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 14.--15. " EMMC_REG_BLOCK_PRESET_SDR12_R_DRV_SEL_VAL ,Driver Strength Select Value  These bits indicate the Driver strength value supported for the SDR12 bus speed mode. These bits are meaningless for 3.3V signaling. RESET:0x0" "TYPEA-1,TYPEB-0,TYPEC-2,TYPED-3"
          
rgroup.long 0x68++0x3
    line.long 0x00 "EMMC_REG_BLOCK_PRESET_SDR25_R, This register defines Preset Value for SDR25 and High Speed SDR speed mode in SD and eMMC mode respectively. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " EMMC_REG_BLOCK_PRESET_SDR25_R_FREQ_SEL_VAL ,SDCLK/RCLK Frequency Select Value  10-bit preset value to be set in SDCLK/RCLK Frequency Select field of the Clock Control register described by a Host System. RESET:0x0"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_PRESET_SDR25_R_CLK_GEN_SEL_VAL ,Clock Generator Select Value  This bit is effective when Host Controller supports programmable clock generator. RESET:0x0" "FALSE-0,PROG-1"
          
         hexmask.long 0x00 11.--13. 1. " EMMC_REG_BLOCK_PRESET_SDR25_R_RSVD_13_11 ,These bits of the PRESET_SDR25_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 14.--15. " EMMC_REG_BLOCK_PRESET_SDR25_R_DRV_SEL_VAL ,Driver Strength Select Value  These bits indicate the Driver strength value supported for the SDR25 bus speed mode. These bits are meaningless for 3.3V signaling. RESET:0x0" "TYPEA-1,TYPEB-0,TYPEC-2,TYPED-3"
          
rgroup.long 0x6a++0x3
    line.long 0x00 "EMMC_REG_BLOCK_PRESET_SDR50_R, This register defines Preset Value for SDR50 speed mode in SD mode. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " EMMC_REG_BLOCK_PRESET_SDR50_R_FREQ_SEL_VAL ,SDCLK/RCLK Frequency Select Value  10-bit preset value to be set in SDCLK/RCLK Frequency Select field of the Clock Control register described by a Host System. RESET:0x0"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_PRESET_SDR50_R_CLK_GEN_SEL_VAL ,Clock Generator Select Value  This bit is effective when Host Controller supports programmable clock generator. RESET:0x0" "FALSE-0,PROG-1"
          
         hexmask.long 0x00 11.--13. 1. " EMMC_REG_BLOCK_PRESET_SDR50_R_RSVD_13_11 ,These bits of the PRESET_SDR50_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 14.--15. " EMMC_REG_BLOCK_PRESET_SDR50_R_DRV_SEL_VAL ,Driver Strength Select Value  These bits indicate Driver strength value supported for SDR50 bus speed mode. These bits are meaningless for 3.3V signaling. RESET:0x0" "TYPEA-1,TYPEB-0,TYPEC-2,TYPED-3"
          
rgroup.long 0x6c++0x3
    line.long 0x00 "EMMC_REG_BLOCK_PRESET_SDR104_R, This register defines Preset Value for SDR104 and HS200 speed modes in the SD and eMMC modes, respectively. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " EMMC_REG_BLOCK_PRESET_SDR104_R_FREQ_SEL_VAL ,SDCLK/RCLK Frequency Select Value  These bits specify a 10-bit preset value that must be set in the SDCLK/RCLK Frequency Select field of the Clock Control register described by a Host System. RESET:0x0"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_PRESET_SDR104_R_CLK_GEN_SEL_VAL ,Clock Generator Select Value  This bit is effective when Host Controller supports programmable clock generator. RESET:0x0" "FALSE-0,PROG-1"
          
         hexmask.long 0x00 11.--13. 1. " EMMC_REG_BLOCK_PRESET_SDR104_R_RSVD_13_11 ,These bits of the PRESET_SDR104_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 14.--15. " EMMC_REG_BLOCK_PRESET_SDR104_R_DRV_SEL_VAL ,Driver Strength Select Value  These bits indicate Driver strength value supported for SDR104 bus speed mode. These bits are meaningless for 3.3V signaling. RESET:0x0" "TYPEA-1,TYPEB-0,TYPEC-2,TYPED-3"
          
rgroup.long 0x6e++0x3
    line.long 0x00 "EMMC_REG_BLOCK_PRESET_DDR50_R, This register defines the Preset Value for DDR50 and High Speed DDR speed modes in the SD and eMMC modes, respectively. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " EMMC_REG_BLOCK_PRESET_DDR50_R_FREQ_SEL_VAL ,SDCLK/RCLK Frequency Select Value  These bits specify a 10-bit preset value that must be set in the SDCLK/RCLK Frequency Select field of the Clock Control register, as described by a Host System. RESET:0x0"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_PRESET_DDR50_R_CLK_GEN_SEL_VAL ,Clock Generator Select Value  This bit is effective when Host Controller supports programmable clock generator. RESET:0x0" "FALSE-0,PROG-1"
          
         hexmask.long 0x00 11.--13. 1. " EMMC_REG_BLOCK_PRESET_DDR50_R_RSVD_13_11 ,These bits of the PRESET_DDR50_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 14.--15. " EMMC_REG_BLOCK_PRESET_DDR50_R_DRV_SEL_VAL ,Driver Strength Select Value  These bits indicate Driver strength value supported for DDR50 bus speed mode. These bits are meaningless for 3.3V signaling. RESET:0x0" "TYPEA-1,TYPEB-0,TYPEC-2,TYPED-3"
          
rgroup.long 0x74++0x3
    line.long 0x00 "EMMC_REG_BLOCK_PRESET_UHS2_R, This register is used to hold the preset value for UHS-II and HS400 speed modes in the SD and eMMC modes, respectively. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " EMMC_REG_BLOCK_PRESET_UHS2_R_FREQ_SEL_VAL ,SDCLK/RCLK Frequency Select Value  These bits specify the 10-bit preset value that must be set in the SDCLK/RCLK Frequency Select field of the Clock Control register, as described by a Host System. RESET:0x0"
          
         bitfld.long 0x00 10. " EMMC_REG_BLOCK_PRESET_UHS2_R_CLK_GEN_SEL_VAL ,Clock Generator Select Value  This bit is effective when the Host Controller supports a programmable clock generator. RESET:0x0" "FALSE-0,PROG-1"
          
         hexmask.long 0x00 11.--13. 1. " EMMC_REG_BLOCK_PRESET_UHS2_R_RSVD_13_11 ,These bits of UHS-II Preset register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 14.--15. " EMMC_REG_BLOCK_PRESET_UHS2_R_DRV_SEL_VAL ,Driver Strength Select Value These bits indicate the Driver strength value supported by 1.8V signaling bus speed modes in the SD mode. This field is meaningless for UHS-II mode. In eMMC mode, these bits can be used for selecting the Drive strength value for HS400 mode. RESET:0x0" "TYPEA-1,TYPEB-0,TYPEC-2,TYPED-3"
          
group.long  0x78++0x3
    line.long 0x00 "EMMC_REG_BLOCK_ADMA_ID_LOW_R, This register holds the lower 32-bit Integrated Descriptor address.This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_BLOCK_ADMA_ID_LOW_R_ADMA_ID_LOW ,ADMA Integrated Descriptor Address  These bits indicate the lower 32-bit of the ADMA Integrated Descriptor address. The start address of Integrated Descriptor is set to these register bits. The ADMA3 fetches one Descriptor Address and increments these bits to indicate the next Descriptor address. RESET:0x0"
          
group.long  0x7c++0x3
    line.long 0x00 "EMMC_REG_BLOCK_ADMA_ID_HIGH_R, This register holds the upper 32-bit Integrated Descriptor address.This register is applicable for an SD/eMMC/UHS-II mode. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_BLOCK_ADMA_ID_HIGH_R_ADMA_ID_HIGH ,ADMA Integrated Descriptor Address  These bits indicate the higher 32 bit of the ADMA Integrated Descriptor address. RESET:0x0"
          
rgroup.long 0xe6++0x3
    line.long 0x00 "EMMC_REG_BLOCK_P_EMBEDDED_CNTRL, This register points to the location of UHS-II embedded control registers. RESET:0xf6c"
         hexmask.long 0x00 0.--11. 1. " EMMC_REG_BLOCK_P_EMBEDDED_CNTRL_REG_OFFSET_ADDR ,Offset Address of Embedded Control register. RESET:0xf6c"
          
          
rgroup.long 0xe8++0x3
    line.long 0x00 "EMMC_REG_BLOCK_P_VENDOR_SPECIFIC_AREA, This register used as a pointer for the Vendor Specific Area 1. RESET:0x500"
         hexmask.long 0x00 0.--11. 1. " EMMC_REG_BLOCK_P_VENDOR_SPECIFIC_AREA_REG_OFFSET_ADDR ,Base offset Address for Vendor-Specific registers. RESET:0x500"
          
          
rgroup.long 0xea++0x3
    line.long 0x00 "EMMC_REG_BLOCK_P_VENDOR2_SPECIFIC_AREA, This register is used as a pointer for the Vendor Specific Area 2. RESET:0x180"
         hexmask.long 0x00 0.--15. 1. " EMMC_REG_BLOCK_P_VENDOR2_SPECIFIC_AREA_REG_OFFSET_ADDR ,Base offset Address for Command Queuing registers. RESET:0x180"
          
rgroup.long 0xfc++0x3
    line.long 0x00 "EMMC_REG_BLOCK_SLOT_INTR_STATUS_R, This register indicates the Interrupt status of each slot. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EMMC_REG_BLOCK_SLOT_INTR_STATUS_R_INTR_SLOT ,Interrupt signal for each Slot  These status bits indicate the logical OR of Interrupt signal and Wakeup signal for each slot. A maximum of 8 slots can be defined. If one interrupt signal is associated with multiple slots, the Host Driver can identify the interrupt that is generated by reading these bits. By a power on reset or by setting Software Reset For All bit, the interrupt signals are de-asserted and this status reads 00h.  - Bit 00: Slot 1  - Bit 01: Slot 2  - Bit 02: Slot 3  - ..........  - ..........  - Bit 07: Slot 8   Note: MSHC Host Controller support single card slot. This register shall always return 0. RESET:0x0"
          
          
rgroup.long 0xfe++0x3
    line.long 0x00 "EMMC_REG_BLOCK_HOST_CNTRL_VERS_R, This register is used to indicate the Host Controller Version number. RESET:0xe05"
         bitfld.long 0x00 0.--7. " EMMC_REG_BLOCK_HOST_CNTRL_VERS_R_SPEC_VERSION_NUM ,Specification Version Number  These bits indicate the Host controller specification version. The upper and lower 4-bits indicate the version. Values 0x06-0xFF are reserved. RESET:0x5" "VER_1_00-0,VER_2_00-1,VER_3_00-2,VER_4_00-3,VER_4_10-4,VER_4_20-5"
          
         hexmask.long 0x00 8.--15. 1. " EMMC_REG_BLOCK_HOST_CNTRL_VERS_R_VENDOR_VERSION_NUM ,Vendor Version Number  This field is reserved for the vendor version number. Host Driver must not use this status. RESET:0xe"
          
tree.end
    

tree "EMMC_REG__VENDOR2_BLOCK"
base e:0x40065180
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQVER, This register provides information about the version of the eMMC Command Queueing standard, which is implemented by the CQE in BCD format. RESET:0x510"
         hexmask.long 0x00 0.--3. 1. " EMMC_REG_VENDOR2_BLOCK_CQVER_EMMC_VER_SUFFIX ,This bit indicates the eMMC version suffix (2nd digit right of decimal point) in BCD format. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " EMMC_REG_VENDOR2_BLOCK_CQVER_EMMC_VER_MINOR ,This bit indicates the eMMC minor version (1st digit right of decimal point) in BCD format. RESET:0x1"
          
         hexmask.long 0x00 8.--11. 1. " EMMC_REG_VENDOR2_BLOCK_CQVER_EMMC_VER_MAJOR ,This bit indicates the eMMC major version (1st digit left of decimal point) in BCD format. RESET:0x5"
          
         hexmask.long 0x00 12.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQVER_EMMMC_VER_RSVD ,These bits of the CQVER register are reserved. They always return 0. RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQCAP, This register indicates the capabilities of the command queuing engine. RESET:0x3020"
         hexmask.long 0x00 0.--9. 1. " EMMC_REG_VENDOR2_BLOCK_CQCAP_ITCFVAL ,Internal Timer Clock Frequency Value (ITCFVAL) This field scales the frequency of the timer clock provided by ITCFMUL. The Final clock frequency of actual timer clock is calculated as ITCFVAL* ITCFMUL. RESET:0x20"
          
         hexmask.long 0x00 10.--11. 1. " EMMC_REG_VENDOR2_BLOCK_CQCAP_CQCCAP_RSVD1 ,These bits of the CQCAP register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 12.--15. " EMMC_REG_VENDOR2_BLOCK_CQCAP_ITCFMUL ,Internal Timer Clock Frequency Multiplier (ITCFMUL) This field indicates the frequency of the clock used for interrupt coalescing timer and for determining the SQS polling period. See ITCFVAL definition for details. Values 0x5 to 0xF are reserved. RESET:0x3" "CLK_100KHZ-2,CLK_10KHZ-1,CLK_10MHZ-4,CLK_1KHZ-0,CLK_1MHZ-3"
          
         hexmask.long 0x00 16.--27. 1. " EMMC_REG_VENDOR2_BLOCK_CQCAP_CQCCAP_RSVD2 ,These bits [27:16] of the CQCAP register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 28. " EMMC_REG_VENDOR2_BLOCK_CQCAP_CRYPTO_SUPPORT ,Crypto Support  This bit indicates whether the Host Controller supports cryptographic operations. RESET:0x0" "FALSE-0,TRUE-1"
          
         hexmask.long 0x00 29.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQCAP_CQCCAP_RSVD3 ,These bits [31:29] of the CQCAP register are reserved. They always return 0. RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQCFG, This register controls CQE behavior affecting the general operation of command queuing engine. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_VENDOR2_BLOCK_CQCFG_CQ_EN ,Enable command queuing engine (CQE). When CQE is disable, the software controls the eMMC bus using the registers between the addresses 0x000 to 0x1FF. Before the software writes to this bit, the software verifies that the eMMC host controller is in idle state and there are no ongoing commands or data transfers. When software wants to exit command queuing mode, it clears all previous tasks (if any) before setting this bit to 0. RESET:0x0" "CQE_DISABLE-0,CQE_ENABLE-1"
          
         hexmask.long 0x00 2.--7. 1. " EMMC_REG_VENDOR2_BLOCK_CQCFG_CQCCFG_RSVD1 ,These bits (CQCCFG_RSVD1) of the CQCFG register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 8. " EMMC_REG_VENDOR2_BLOCK_CQCFG_TASK_DESC_SIZE ,Bit Value Description  This bit indicates the size of task descriptor used in host memory. This bit can only be configured when Command Queuing Enable bit is 0 (command queuing is disabled). RESET:0x0" "TASK_DESC_128B-1,TASK_DESC_64B-0"
          
         hexmask.long 0x00 9.--11. 1. " EMMC_REG_VENDOR2_BLOCK_CQCFG_CQCCFG_RSVD2 ,These bits (CQCCFG_RSVD2) of the CQCFG register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 12. " EMMC_REG_VENDOR2_BLOCK_CQCFG_DCMD_EN ,This bit indicates to the hardware whether the Task Descriptor in slot #31 of the TDL is a data transfer descriptor or a direct-command descriptor. CQE uses this bit when a task is issued in slot #31, to determine how to decode the Task Descriptor. RESET:0x0" "SLOT31_DCMD_DISABLE-0,SLOT31_DCMD_ENABLE-1"
          
         hexmask.long 0x00 13.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQCFG_CQCCFG_RSVD3 ,These bits (CQCCFG_RSVD3) of the CQCFG register are reserved. They always return 0. RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQCTL, This register controls CQE behavior affecting the general operation of command queuing module or simultaneous operation of multiple tasks. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_VENDOR2_BLOCK_CQCTL_HALT ,Halt request and resume RESET:0x0" "HALT_CQE-1,RESUME_CQE-0"
          
         hexmask.long 0x00 1.--7. 1. " EMMC_REG_VENDOR2_BLOCK_CQCTL_CQCTL_RSVD1 ,These bits (CQCTL_RSVD1) of the CQCTL register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 8. " EMMC_REG_VENDOR2_BLOCK_CQCTL_CLR_ALL_TASKS ,Clear all tasks  This bit can only be written when the controller is halted. This bit does not clear tasks in the device. The software has to use the CMDQ_TASK_MGMT command to clear device's queue. RESET:0x0" "CLEAR_ALL_TASKS-1,NO_EFFECT-0"
          
         hexmask.long 0x00 9.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQCTL_CQCTL_RSVD2 ,These bits (CQCTL_RSVD2) of the CQCTL register are reserved. They always return 0. RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQIS, This register indicates pending interrupts that require service. Each bit in this register is asserted in response to a specific event, only if the respective bit is set in the CQISE register. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_VENDOR2_BLOCK_CQIS_HAC ,Halt complete interrupt This status bit is asserted (only if CQISE.HAC_STE=1) when halt bit in the CQCTL register transitions from 0 to 1 indicating that the host controller has completed its current ongoing task and has entered halt state. A value of 1 clears this status bit. RESET:0x0" "NOTSET-0,SET-1"
          
         bitfld.long 0x00 1. " EMMC_REG_VENDOR2_BLOCK_CQIS_TCC ,Task complete interrupt This status bit is asserted (if CQISE.TCC_STE=1) when at least one of the following conditions are met:  - A task is completed and the INT bit is set in its Task Descriptor  - Interrupt caused by Interrupt Coalescing logic due to timeout  - Interrupt Coalescing logic reached the configured threshold A value of 1 clears this status bit RESET:0x0" "NOTSET-0,SET-1"
          
         bitfld.long 0x00 2. " EMMC_REG_VENDOR2_BLOCK_CQIS_RED ,Response error detected interrupt This status bit is asserted (if CQISE.RED_STE=1) when a response is received with an error bit set in the device status field. Configure the CQRMEM register to identify device status bit fields that may trigger an interrupt and that are masked. A value of 1 clears this status bit. RESET:0x0" "NOTSET-0,SET-1"
          
         bitfld.long 0x00 3. " EMMC_REG_VENDOR2_BLOCK_CQIS_TCL ,Task cleared interrupt This status bit is asserted (if CQISE.TCL_STE=1) when a task clear operation is completed by CQE. The completed task clear operation is either an individual task clear (by writing CQTCLR) or clearing of all tasks (by writing CQCTL). A value of 1 clears this status bit. RESET:0x0" "NOTSET-0,SET-1"
          
         hexmask.long 0x00 6.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQIS_CQIS_RSVD1 ,These bits of the CQIS register are reserved. They always return 0. RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQISE, This register enables and disables the reporting of the corresponding interrupt to host software in the CQIS register. When a bit is set (1) and the corresponding interrupt condition is active, then the bit in CQIS is asserted. Interrupt sources that are disabled (when '0') are not indicated in the CQIS register. This register is bit-index matched to the CQIS register. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_VENDOR2_BLOCK_CQISE_HAC_STE ,Halt complete interrupt status enable RESET:0x0" "INT_STS_DISABLE-0,INT_STS_ENABLE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_VENDOR2_BLOCK_CQISE_TCC_STE ,Task complete interrupt status enable RESET:0x0" "INT_STS_DISABLE-0,INT_STS_ENABLE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_VENDOR2_BLOCK_CQISE_RED_STE ,Response error detected interrupt status enable RESET:0x0" "INT_STS_DISABLE-0,INT_STS_ENABLE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_VENDOR2_BLOCK_CQISE_TCL_STE ,Task cleared interrupt status enable RESET:0x0" "INT_STS_DISABLE-0,INT_STS_ENABLE-1"
          
         hexmask.long 0x00 6.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQISE_CQISTE_RSVD1 ,These bits of the CQISE register are reserved. They always return 0. RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQISGE, This register enables and disables the generation of interrupts to host software. When a bit is set and the corresponding bit in CQIS is set, then an interrupt is generated. Interrupt sources that are disabled are still indicated in the CQIS register. This register is bit-index matched to the CQIS register. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_VENDOR2_BLOCK_CQISGE_HAC_SGE ,Halt complete interrupt signal enable RESET:0x0" "INT_SIG_DISABLE-0,INT_SIG_ENABLE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_VENDOR2_BLOCK_CQISGE_TCC_SGE ,Task complete interrupt signal enable RESET:0x0" "INT_SIG_DISABLE-0,INT_SIG_ENABLE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_VENDOR2_BLOCK_CQISGE_RED_SGE ,Response error detected interrupt signal enable RESET:0x0" "INT_SIG_DISABLE-0,INT_SIG_ENABLE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_VENDOR2_BLOCK_CQISGE_TCL_SGE ,Task cleared interrupt signal enable RESET:0x0" "INT_SIG_DISABLE-0,INT_SIG_ENABLE-1"
          
         hexmask.long 0x00 6.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQISGE_CQISGE_RSVD1 ,These bits of the CQISGE register are reserved. They always return 0. RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQIC, This register controls and configures interrupt coalescing feature. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " EMMC_REG_VENDOR2_BLOCK_CQIC_TOUT_VAL ,Interrupt Coalescing Timeout Value Software uses this field to configure the maximum time allowed between the completion of a task on the bus and the generation of an interrupt. Timer Operation: The timer is reset by software during the interrupt service routine. It starts running when the first data transfer task with INT=0 is completed, after the timer was reset. When the timer reaches the value configured in ICTOVAL field, it generates an interrupt and stops. The timer's unit is equal to 1024 clock periods of the clock whose frequency is specified in the Internal Timer Clock Frequency field CQCAP register.  - 0x0: Timer is disabled. Timeout-based interrupt is not generated  - 0x1: Timeout on 01x1024 cycles of timer clock frequency  - 0x2: Timeout on 02x1024 cycles of timer clock frequency  - ........  - 0x7f: Timeout on 127x1024 cycles of timer clock frequency In order to write to this field, the TOUT_VAL_WEN bit must be set at the same write operation. RESET:0x0"
          
         bitfld.long 0x00 7. " EMMC_REG_VENDOR2_BLOCK_CQIC_TOUT_VAL_WEN ,When software writes 1 to this bit, the value TOUT_VAL is updated with the contents written on the same cycle. RESET:0x0" "WEN_CLR-0,WEN_SET-1"
          
         hexmask.long 0x00 8.--12. 1. " EMMC_REG_VENDOR2_BLOCK_CQIC_INTC_TH ,Interrupt Coalescing Counter Threshold filed Software uses this field to configure the number of task completions (only tasks with INT=0 in the Task Descriptor), which are required in order to generate an interrupt. Counter Operation: As data transfer tasks with INT=0 complete, they are counted by CQE. The counter is reset by software during the interrupt service routine. The counter stops counting when it reaches the value configured in INTC_TH, and generates interrupt.  - 0x0: Interrupt coalescing feature disabled  - 0x1: Interrupt coalescing interrupt generated after 1 task when INT=0 completes  - 0x2: Interrupt coalescing interrupt generated after 2 tasks when INT=0 completes  - ........  - 0x1f: Interrupt coalescing interrupt generated after 31 tasks when INT=0 completes To write to this field, the INTC_TH_WEN bit must be set during the same write operation. RESET:0x0"
          
         hexmask.long 0x00 13.--14. 1. " EMMC_REG_VENDOR2_BLOCK_CQIC_CQIC_RSVD1 ,These bits (CQIC_RSVD1) of the CQIC register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 15. " EMMC_REG_VENDOR2_BLOCK_CQIC_INTC_TH_WEN ,Interrupt Coalescing Counter Threshold Write Enable When software writes 1 to this bit, the value INTC_TH is updated with the contents written on the same cycle. RESET:0x0" "WEN_CLR-0,WEN_SET-1"
          
         bitfld.long 0x00 16. " EMMC_REG_VENDOR2_BLOCK_CQIC_INTC_RST ,Counter and Timer Reset When host driver writes 1, the interrupt coalescing timer and counter are reset. RESET:0x0" "ASSERT_INTC_RESET-1,NO_EFFECT-0"
          
         hexmask.long 0x00 17.--19. 1. " EMMC_REG_VENDOR2_BLOCK_CQIC_CQIC_RSVD2 ,These bits (CQIC_RSVD2) of the CQIC register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 20. " EMMC_REG_VENDOR2_BLOCK_CQIC_INTC_STAT ,Interrupt Coalescing Status Bit This bit indicates to the software whether any tasks (with INT=0) have completed and counted towards interrupt coalescing (that is, this is set if and only if INTC counter > 0). RESET:0x0" "INTC_ATLEAST1_COMP-1,INTC_NO_TASK_COMP-0"
          
         hexmask.long 0x00 21.--30. 1. " EMMC_REG_VENDOR2_BLOCK_CQIC_CQIC_RSVD3 ,These bits (CQIC_RSVD3) of the CQIC register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 31. " EMMC_REG_VENDOR2_BLOCK_CQIC_INTC_EN ,Interrupt Coalescing Enable Bit RESET:0x0" "DISABLE_INT_COALESCING-0,ENABLE_INT_COALESCING-1"
          
group.long  0x20++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQTDLBA, This register is used for configuring the lower 32 bits of the byte address of the head of the Task Descriptor List in the host memory. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQTDLBA_TDLBA ,This register stores the LSB bits (31:0) of the byte address of the head of the Task Descriptor List in system memory. The size of the task descriptor list is 32 * (Task Descriptor size + Transfer Descriptor size) as configured by the host driver.  This address is set on 1 KB boundary. The lower 10 bits of this register are set to 0 by the software and are ignored by CQE. RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQTDLBAU, This register is used for configuring the upper 32 bits of the byte address of the head of the Task Descriptor List in the host memory. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQTDLBAU_TDLBAU ,This register stores the MSB bits (63:32) of the byte address of the head of the Task Descriptor List in system memory. The size of the task descriptor list is 32 * (Task Descriptor size + Transfer Descriptor size) as configured by Host driver. This address is set on 1 KB boundary. The lower 10 bits of this register are set to 0 by the software and are ignored by CQE. This register is reserved when using 32-bit addressing mode. RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQTDBR, Using this register, software triggers CQE to process a new task. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQTDBR_DBR ,The software configures TDLBA and TDLBAU, and enable CQE in CQCFG before using this register. Writing 1 to bit n of this register triggers CQE to start processing the task encoded in slot n of the TDL. Writing 0 by the software does not have any impact on the hardware, and does not change the value of the register bit. CQE always processes tasks according to the order submitted to the list by CQTDBR write transactions. CQE processes Data Transfer tasks by reading the Task Descriptor and sending QUEUED_TASK_PARAMS (CMD44) and QUEUED_TASK_ADDRESS (CMD45) commands to the device. CQE processes DCMD tasks (in slot #31, when enabled) by reading the Task Descriptor, and generating the command encoded by its index and argument. The corresponding bit is cleared to 0 by CQE in one of the following events:  - A task execution is completed (with success or error).  - The task is cleared using CQTCLR register.  - All tasks are cleared using CQCTL register.  - CQE is disabled using CQCFG register. Software may initiate multiple tasks at the same time (batch submission) by writing 1 to multiple bits of this register in the same transaction. In the case of batch submission, CQE processes the tasks in order of the task index, starting with the lowest index. If one or more tasks in the batch are marked with QBR, the ordering of execution is based on said processing order. RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQTCN, This register is used by CQE to notify software about completed tasks. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQTCN_TCN ,Task Completion Notification Each of the 32 bits are bit mapped to the 32 tasks.  - Bit-N(1): Task-N has completed execution (with success or errors)  - Bit-N(0): Task-N has not completed, could be pending or not submitted. On task completion, software may read this register to know tasks that have completed. After reading this register, software may clear the relevant bit fields by writing 1 to the corresponding bits. RESET:0x0"
          
rgroup.long 0x30++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQDQS, This register stores the most recent value of the device's queue status. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQDQS_DQS ,Device Queue Status Each of the 32 bits are bit mapped to the 32 tasks.  - Bit-N(1): Device has marked task N as ready for execution  - Bit-N(0): Task-N is not ready for execution. This task could be pending in device or not submitted. Host controller updates this register with response of the Device Queue Status command. RESET:0x0"
          
rgroup.long 0x34++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQDPT, This register maintains the list of tasks that are queued into device and are awaiting execution completion. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQDPT_DPT ,Device-Pending Tasks Each of the 32 bits are bit mapped to the 32 tasks.  - Bit-N(1): Task-N has been successfully queued into the device and is awaiting execution  - Bit-N(0): Task-N is not yet queued. Bit n of this register is set if and only if QUEUED_TASK_PARAMS (CMD44) and QUEUED_TASK_ADDRESS (CMD45) were sent for this specific task and if this task has not been executed. The controller sets this bit after receiving a successful response for CMD45. CQE clears this bit after the task has completed execution. Software reads this register in the task-discard procedure to determine if the task is queued in the device. RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQTCLR, This register is used for removing an outstanding task in the CQE. The register must be used only when CQE is in Halt state. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQTCLR_TCLR ,Writing 1 to bit n of this register orders CQE to clear a task that the software has previously issued. This bit can only be written when CQE is in Halt state as indicated in CQCFG register Halt bit. When software writes 1 to a bit in this register, CQE updates the value to 1, and starts clearing the data structures related to the task. CQE clears the bit fields (sets a value of 0) in CQTCLR and in CQTDBR once the clear operation is complete. Software must poll on the CQTCLR until it is cleared to verify that a clear operation was done. RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQSSC1, This register is used for removing an outstanding task in the CQE. The register controls when SEND_QUEUE_STATUS commands are sent. RESET:0x11000"
         hexmask.long 0x00 0.--15. 1. " EMMC_REG_VENDOR2_BLOCK_CQSSC1_SQSCMD_IDLE_TMR ,This field configures the polling period to be used when using periodic SEND_QUEUE_STATUS (CMD13) polling. Periodic polling is used when tasks are pending in the device, but no data transfer is in progress. When a SEND_QUEUE_STATUS response indicates that no task is ready for execution, CQE counts the configured time until it issues the next SEND_QUEUE_STATUS. Timer units are clock periods of the clock whose frequency is specified in the Internal Timer Clock Frequency field CQCAP register. The minimum value is 0001h (1 clock period) and the maximum value is FFFFh (65535 clock periods). For example, a CQCAP field value of 0 indicates a 19.2 MHz clock frequency (period = 52.08 ns). If the setting in CQSSC1.CIT is 1000h, the calculated polling period is 4096*52.08 ns= 213.33 ns.  Should be programmed only when CQCFG.CQ_EN is '0'. RESET:0x1000"
          
         hexmask.long 0x00 16.--19. 1. " EMMC_REG_VENDOR2_BLOCK_CQSSC1_SQSCMD_BLK_CNT ,This field indicates when SQS CMD is sent while data transfer is in progress. A value of 'n' indicates that CQE sends status command on the CMD line, during the transfer of data block BLOCK_CNT-n, on the data lines, where BLOCK_CNT is the number of blocks in the current transaction.  - 0x0: SEND_QUEUE_STATUS (CMD13) command is not sent during the transaction. Instead, it is sent only when the data lines are idle.  - 0x1: SEND_QUEUE_STATUS command is to be sent during the last block of the transaction.  - 0x2: SEND_QUEUE_STATUS command when last 2 blocks are pending.  - 0x3: SEND_QUEUE_STATUS command when last 3 blocks are pending.  - ........  - 0xf: SEND_QUEUE_STATUS command when last 15 blocks are pending.   Should be programmed only when CQCFG.CQ_EN is '0' RESET:0x1"
          
         hexmask.long 0x00 20.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQSSC1_RSVD_20_31 ,These bits of the CQSSC1 register are reserved. They always return 0. RESET:0x0"
          
group.long  0x44++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQSSC2, The register is used for configuring the RCA field in SEND_QUEUE_STATUS command argument. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " EMMC_REG_VENDOR2_BLOCK_CQSSC2_SQSCMD_RCA ,This field provides CQE with the contents of the 16-bit RCA field in SEND_QUEUE_STATUS (CMD13) command argument. CQE copies this field to bits 31:16 of the argument when transmitting SEND_ QUEUE_STATUS (CMD13) command. RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQSSC2_RSVD_16_31 ,These bits of the CQSSC2 register are reserved. They always return 0. RESET:0x0"
          
rgroup.long 0x48++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQCRDCT, This register stores the response of last executed DCMD. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQCRDCT_DCMD_RESP ,This register contains the response of the command generated by the last direct command (DCMD) task that was sent. Contents of this register are valid only after bit 31 of CQTDBR register is cleared by the controller. RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQRMEM, This register controls the generation of response error detect (RED) interrupt. Only the bits enabled here can contribute to RED. RESET:0xfdf9a080"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQRMEM_RESP_ERR_MASK ,The bits of this field are bit mapped to the device response. This bit is used as an interrupt mask on the device status filed that is received in R1/R1b responses.  - 1: When a R1/R1b response is received, with a bit i in the device status set, a RED interrupt is generated.  - 0: When a R1/R1b response is received, bit i in the device status is ignored. The reset value of this register is set to trigger an interrupt on all 'Error' type bits in the device status.  Note: Responses to CMD13 (SQS) encode the QSR so that they are ignored by this logic. RESET:0xfdf9a080"
          
rgroup.long 0x54++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQTERRI, This register is updated by CQE when an error occurs on data or command related to a task activity. When such an error is detected by CQE or indicated by the eMMC controller, CQE stores the following in the CQTERRI register: task IDs and indices of commands that were executed on the command line and data lines when the error occurred. Software must use this information in the error recovery procedure. RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " EMMC_REG_VENDOR2_BLOCK_CQTERRI_RESP_ERR_CMD_INDX ,This field captures the index of the command that was executed on the command line when the error occurred. RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " EMMC_REG_VENDOR2_BLOCK_CQTERRI_RSVD_6_7 ,These bits (RSVD_6_7) of the CQTERRI register are reserved. They always return 0. RESET:0x0"
          
         hexmask.long 0x00 8.--12. 1. " EMMC_REG_VENDOR2_BLOCK_CQTERRI_RESP_ERR_TASKID ,This field captures the ID of the task which was executed on the command line when the error occurred. RESET:0x0"
          
         hexmask.long 0x00 13.--14. 1. " EMMC_REG_VENDOR2_BLOCK_CQTERRI_RSVD_13_14 ,These bits (RSVD_13_14) of the CQTERRI register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 15. " EMMC_REG_VENDOR2_BLOCK_CQTERRI_RESP_ERR_FIELDS_VALID ,This bit is updated when an error is detected while a command transaction was in progress. RESET:0x0" "NOT_SET-0,SET-1"
          
         hexmask.long 0x00 16.--21. 1. " EMMC_REG_VENDOR2_BLOCK_CQTERRI_TRANS_ERR_CMD_INDX ,This field captures the index of the command that was executed and whose data transfer has errors. RESET:0x0"
          
         hexmask.long 0x00 22.--23. 1. " EMMC_REG_VENDOR2_BLOCK_CQTERRI_RSVD_23_22 ,These bits (RSVD_23_22) of the CQTERRI register are reserved. They always return 0. RESET:0x0"
          
         hexmask.long 0x00 24.--28. 1. " EMMC_REG_VENDOR2_BLOCK_CQTERRI_TRANS_ERR_TASKID ,This field captures the ID of the task that was executed and whose data transfer has errors. RESET:0x0"
          
         hexmask.long 0x00 29.--30. 1. " EMMC_REG_VENDOR2_BLOCK_CQTERRI_RSVD_30_29 ,These bits (RSVD_30_29) of the CQTERRI register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 31. " EMMC_REG_VENDOR2_BLOCK_CQTERRI_TRANS_ERR_FIELDS_VALID ,This bit is updated when an error is detected while a data transfer transaction was in progress. RESET:0x0" "NOT_SET-0,SET-1"
          
rgroup.long 0x58++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQCRI, This register stores the index of the last received command response. RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " EMMC_REG_VENDOR2_BLOCK_CQCRI_CMD_RESP_INDX ,Last Command Response index This field stores the index of the last received command response. Controller updates the value every time a command response is received. RESET:0x0"
          
         hexmask.long 0x00 6.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQCRI_RSVD_31_6 ,These bits of the CQCRI register are reserved. They always return 0. RESET:0x0"
          
rgroup.long 0x5c++0x3
    line.long 0x00 "EMMC_REG_VENDOR2_BLOCK_CQCRA, This register stores the argument of the last received command response. RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_VENDOR2_BLOCK_CQCRA_CMD_RESP_ARG ,Last Command Response argument This field stores the argument of the last received command response. Controller updates the value every time a command response is received. RESET:0x0"
          
tree.end
    

tree "EMMC_REG__PHY_BLOCK"
base e:0x40065300
width 80.
group.long  0x0++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_PHY_CNFG, SD/eMMC PHY general configuration register RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_PHY_BLOCK_PHY_CNFG_PHY_RSTN ,Active-Low reset control for PHY, write '0' to reset PHY, Write '1' to deassert reset. RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_REG_PHY_BLOCK_PHY_CNFG_PHY_PWRGOOD ,Phy's Power Good status is captured here. Ensure this is '1' before stating transactions. RESET:0x0"
          
         hexmask.long 0x00 16.--19. 1. " EMMC_REG_PHY_BLOCK_PHY_CNFG_PAD_SP ,PMOS TX drive strength control. Common config for all for SD/eMMC Pads. RESET:0x0"
          
         hexmask.long 0x00 20.--23. 1. " EMMC_REG_PHY_BLOCK_PHY_CNFG_PAD_SN ,NMOS TX drive strength control. Common config for all for SD/eMMC Pads. RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_CMDPAD_CNFG, SD/eMMC PHY's Command/Response PAD settings are controlled here RESET:0x440"
         hexmask.long 0x00 0.--2. 1. " EMMC_REG_PHY_BLOCK_CMDPAD_CNFG_RXSEL ,Reciver type select for PAD. Controls the RXSEL value of SD/eMMC PHY CMD PAD RESET:0x0"
          
         bitfld.long 0x00 3.--4. " EMMC_REG_PHY_BLOCK_CMDPAD_CNFG_WEAKPULL_EN ,Pull-up/Pul-down enable control for CMD PAD RESET:0x0" "DISABLED-0,ILLEGAL-3,PULLDOWN-2,PULLUP-1"
          
         hexmask.long 0x00 5.--8. 1. " EMMC_REG_PHY_BLOCK_CMDPAD_CNFG_TXSLEW_CTRL_P ,Slew control for P-Type CMD Pad's TX RESET:0x2"
          
         hexmask.long 0x00 9.--12. 1. " EMMC_REG_PHY_BLOCK_CMDPAD_CNFG_TXSLEW_CTRL_N ,Slew control for N-Type CMD Pad's TX RESET:0x2"
          
group.long  0x6++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_DATPAD_CNFG, SD/eMMC PHY's Data PAD settings are controlled here. common settings for all data pads RESET:0x440"
         hexmask.long 0x00 0.--2. 1. " EMMC_REG_PHY_BLOCK_DATPAD_CNFG_RXSEL ,Reciver type select for PAD. Controls the RXSEL value of SD/eMMC PHY DATA PADs RESET:0x0"
          
         bitfld.long 0x00 3.--4. " EMMC_REG_PHY_BLOCK_DATPAD_CNFG_WEAKPULL_EN ,Pull-up/Pull-down enable control for DATA PADs RESET:0x0" "DISABLED-0,ILLEGAL-3,PULLDOWN-2,PULLUP-1"
          
         hexmask.long 0x00 5.--8. 1. " EMMC_REG_PHY_BLOCK_DATPAD_CNFG_TXSLEW_CTRL_P ,Slew control for P-Type DATA Pad's TX RESET:0x2"
          
         hexmask.long 0x00 9.--12. 1. " EMMC_REG_PHY_BLOCK_DATPAD_CNFG_TXSLEW_CTRL_N ,Slew control for N-Type DATA Pad's TX RESET:0x2"
          
group.long  0x8++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_CLKPAD_CNFG, SD/eMMC PHY's CLK PAD settings are controlled here. RESET:0x440"
         hexmask.long 0x00 0.--2. 1. " EMMC_REG_PHY_BLOCK_CLKPAD_CNFG_RXSEL ,Reciver type select for PAD. Controls the RXSEL value of SD/eMMC PHY CLK PAD RESET:0x0"
          
         bitfld.long 0x00 3.--4. " EMMC_REG_PHY_BLOCK_CLKPAD_CNFG_WEAKPULL_EN ,Pull-up/Pul-down enable control for CLK PAD RESET:0x0" "DISABLED-0,ILLEGAL-3,PULLDOWN-2,PULLUP-1"
          
         hexmask.long 0x00 5.--8. 1. " EMMC_REG_PHY_BLOCK_CLKPAD_CNFG_TXSLEW_CTRL_P ,Slew control for P-Type CLK Pad's TX RESET:0x2"
          
         hexmask.long 0x00 9.--12. 1. " EMMC_REG_PHY_BLOCK_CLKPAD_CNFG_TXSLEW_CTRL_N ,Slew control for N-Type CLK Pad's TX RESET:0x2"
          
group.long  0xa++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_STBPAD_CNFG, SD/eMMC PHY's Strobe PAD settings are controlled here. RESET:0x440"
         hexmask.long 0x00 0.--2. 1. " EMMC_REG_PHY_BLOCK_STBPAD_CNFG_RXSEL ,Reciver type select for PAD. Controls the RXSEL value of SD/eMMC PHY STROBE PAD RESET:0x0"
          
         bitfld.long 0x00 3.--4. " EMMC_REG_PHY_BLOCK_STBPAD_CNFG_WEAKPULL_EN ,Pull-up/Pul-down enable control for STROBE PAD RESET:0x0" "DISABLED-0,ILLEGAL-3,PULLDOWN-2,PULLUP-1"
          
         hexmask.long 0x00 5.--8. 1. " EMMC_REG_PHY_BLOCK_STBPAD_CNFG_TXSLEW_CTRL_P ,Slew control for P-Type Strobe Pad's TX RESET:0x2"
          
         hexmask.long 0x00 9.--12. 1. " EMMC_REG_PHY_BLOCK_STBPAD_CNFG_TXSLEW_CTRL_N ,Slew control for N-Type Strobe Pad's TX RESET:0x2"
          
group.long  0xc++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_RSTNPAD_CNFG, SD/eMMC PHY's RSTN PAD settings are controlled here. RESET:0x440"
         hexmask.long 0x00 0.--2. 1. " EMMC_REG_PHY_BLOCK_RSTNPAD_CNFG_RXSEL ,Reciver type select for PAD. Controls the RXSEL value of SD/eMMC PHY RST_N PAD(s) RESET:0x0"
          
         bitfld.long 0x00 3.--4. " EMMC_REG_PHY_BLOCK_RSTNPAD_CNFG_WEAKPULL_EN ,Pull-up/Pul-down enable control for RST_N PAD(s) RESET:0x0" "DISABLED-0,ILLEGAL-3,PULLDOWN-2,PULLUP-1"
          
         hexmask.long 0x00 5.--8. 1. " EMMC_REG_PHY_BLOCK_RSTNPAD_CNFG_TXSLEW_CTRL_P ,Slew control for P-Type RST_N Pad's TX RESET:0x2"
          
         hexmask.long 0x00 9.--12. 1. " EMMC_REG_PHY_BLOCK_RSTNPAD_CNFG_TXSLEW_CTRL_N ,Slew control for N-Type RST_N Pad's TX RESET:0x2"
          
group.long  0xe++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_PADTEST_CNFG, PAD TEST Path and direction control RESET:0x4"
         bitfld.long 0x00 0. " EMMC_REG_PHY_BLOCK_PADTEST_CNFG_TESTMODE_EN ,enables test mode interface for all PADS. Functional interface is disabled. RESET:0x0" "PAD_FUNCMODE-0,PAD_TESTMODE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_PHY_BLOCK_PADTEST_CNFG_TEST_DLY_LINE_EN ,Test enable for delay line testing This signal enables the testing of delay lines with the test clock. RESET:0x0" "TEST_DLY_LINE_DIS-0,TEST_DLY_LINE_EN-1"
          
         bitfld.long 0x00 2. " EMMC_REG_PHY_BLOCK_PADTEST_CNFG_TEST_CLK_EN ,. While updating delay codes during testmode, this signal is used to gate the test clock. Functional interface is disabled. RESET:0x1" "TEST_CLK_ENABLED-1,TEST_CLK_GATED-0"
          
         hexmask.long 0x00 4.--15. 1. " EMMC_REG_PHY_BLOCK_PADTEST_CNFG_TEST_OE ,test interface OE control. Drive's PHY's itest_oe inputs. RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_PADTEST_OUT, PAD TEST Path Data out, Drives itest_a input of SD/eMMC PHY RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " EMMC_REG_PHY_BLOCK_PADTEST_OUT_TESTDATA_OUT ,Data written here is reflected on corresponding itest_a. Indivitual bits are mapped to corresponding itest_a inputs of the PHY RESET:0x0"
          
rgroup.long 0x12++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_PADTEST_IN, PAD TEST Path Data in, reflects value of otest_y output of SD/eMMC PHY RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " EMMC_REG_PHY_BLOCK_PADTEST_IN_TESTDATA_IN ,individual bits here capture data avaliable on corresponding otest_y output. should be used for DC test and low freq data patterns. RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_PRBS_CNFG, Register to configure PRBS engine RESET:0xffff"
         hexmask.long 0x00 0.--15. 1. " EMMC_REG_PHY_BLOCK_PRBS_CNFG_INIT_SEED ,Value programmed here is used as SEED for PRBS engine RESET:0xffff"
          
group.long  0x1a++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_PHYLPBK_CNFG, Register to setup loopback mode RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_PHY_BLOCK_PHYLPBK_CNFG_PHYLPBK_EN ,PHY Local loop back mode is enable RESET:0x0" "PHYLPBK_MODE_DIS-0,PHYLPBK_MODE_EN-1"
          
         bitfld.long 0x00 1. " EMMC_REG_PHY_BLOCK_PHYLPBK_CNFG_OUT_EN_PHYLPBK_MODE ,CMD/DATA output enable in PHY loopback mode RESET:0x0" "OUTPUT_DIS-0,OUTPUT_EN-1"
          
group.long  0x1c++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_COMMDL_CNFG, Config register to settings common to all DelayLines used in PHY RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_PHY_BLOCK_COMMDL_CNFG_DLSTEP_SEL ,DelayLine's per step delay selection, Drives PHY's idl_step input RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_REG_PHY_BLOCK_COMMDL_CNFG_DLOUT_EN ,When '1' DL outputs can be sampled on PADs. Drives idlout_en for all PADs RESET:0x0" "DL_OUTDIS-0,DL_OUTEN-1"
          
group.long  0x1d++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_SDCLKDL_CNFG, Settings for SD/eMMC CLK DelayLine. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_PHY_BLOCK_SDCLKDL_CNFG_EXTDLY_EN ,Drives SD/eMMC CLK DelayLine's extdlyen input RESET:0x0" "DEF_MODE-0,EXTDL_MODE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_PHY_BLOCK_SDCLKDL_CNFG_BYPASS_EN ,Drives SD/eMMC CLK DelayLine's bypassen input RESET:0x0" "BYPASSMODE-1,DLMODE-0"
          
         hexmask.long 0x00 2.--3. 1. " EMMC_REG_PHY_BLOCK_SDCLKDL_CNFG_INPSEL_CNFG ,Drives SD/eMMC CLK DelayLine's config input. Value here selects the input source to DelayLine RESET:0x0"
          
         bitfld.long 0x00 4. " EMMC_REG_PHY_BLOCK_SDCLKDL_CNFG_UPDATE_DC ,Prepares DealyLine for code update when '1'. Its recommended that this bit is 1 when SDCLKDL_DC is being written. Ensure this is '0' when not updating code. Note: Turn-off card clock using CLK_CTRL_R.SD_CLK_EN before programing this field. RESET:0x0" "BYPASSMODE-1,DLMODE-0"
          
group.long  0x1e++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_SDCLKDL_DC, SD/eMMC CLK DelayLine Delay Code value RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " EMMC_REG_PHY_BLOCK_SDCLKDL_DC_CCKDL_DC ,Drives SD/eMMC CLK DelayLine's Delay Code input. Value here Selects the number of active stages in the card clock delay line. Note: Turn-off card clock using CLK_CTRL_R.SD_CLK_EN before programing this field. RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_SMPLDL_CNFG, SD/eMMC cclk_rx DelayLine configuration settings RESET:0xc"
         bitfld.long 0x00 0. " EMMC_REG_PHY_BLOCK_SMPLDL_CNFG_EXTDLY_EN ,Drives CCLK_RX DelayLine's extdlyen input RESET:0x0" "DEF_MODE-0,EXTDL_MODE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_PHY_BLOCK_SMPLDL_CNFG_BYPASS_EN ,Drives CCLK_RX DelayLine's bypassen input RESET:0x0" "BYPASSMODE-1,DLMODE-0"
          
         hexmask.long 0x00 2.--3. 1. " EMMC_REG_PHY_BLOCK_SMPLDL_CNFG_INPSEL_CNFG ,Drives CCLK_RX DelayLine's config input. Value here selects the input source to DelayLine RESET:0x3"
          
         bitfld.long 0x00 4. " EMMC_REG_PHY_BLOCK_SMPLDL_CNFG_INPSEL_OVERRIDE ,PHY's Sampling delay line config is controlled by controller using sample_cclk_sel, this signal overides sample_cclk_sel such that INPSEL_CFG field directly control's PHY's config input.  - 0x0 : Controller logic drive Sampling delay line config.  - 0x1 : SMPLDL_CNFG.INPSEL_CNFG drives sampling delay line config. RESET:0x0"
          
group.long  0x21++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_ATDL_CNFG, SD/eMMC drift_cclk_rx DelayLine configuration settings RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_PHY_BLOCK_ATDL_CNFG_EXTDLY_EN ,Drives drift_cclk_rx DelayLine's extdlyen input RESET:0x0" "DEF_MODE-0,EXTDL_MODE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_PHY_BLOCK_ATDL_CNFG_BYPASS_EN ,Drives drift_cclk_rx DelayLine's bypassen input RESET:0x0" "BYPASSMODE-1,DLMODE-0"
          
         hexmask.long 0x00 2.--3. 1. " EMMC_REG_PHY_BLOCK_ATDL_CNFG_INPSEL_CNFG ,Drives drift_cclk_rx DelayLine's config input. Value here selects the input source to DelayLine RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_DLL_CTRL, SD/eMMC PHY's DLL Control settings register RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_PHY_BLOCK_DLL_CTRL_DLL_EN ,Enable's DLL when '1' RESET:0x0" "DLLDISABLE-0,DLLENABLE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_PHY_BLOCK_DLL_CTRL_OFFST_EN ,Enables offset mode of PHY when DLL is enabled. when DLL is disabled this allows direct control of delay generated by DLL's Subordinate RESET:0x0" "OFFSTDIS-0,OFFSTEN-1"
          
         bitfld.long 0x00 2. " EMMC_REG_PHY_BLOCK_DLL_CTRL_SLV_SWDC_UPDATE ,Corresponding output drives PHY's DLL Subordinate's dc update input. This is used to turn-off Subordinate Delay line's output when changing its delay code using DLL_OFFST register RESET:0x0" "DL_OUT_OFF-1,DL_OUT_ON-0"
          
group.long  0x25++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_DLL_CNFG1, SD/eMMC PHY DLL configuration register 1 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " EMMC_REG_PHY_BLOCK_DLL_CNFG1_WAITCYCLE ,Sets the value of DLL's wait cycle input RESET:0x0"
          
         hexmask.long 0x00 4.--5. 1. " EMMC_REG_PHY_BLOCK_DLL_CNFG1_SLVDLY ,Sets the value of DLL subordinate's update delay input islv_update_dly RESET:0x0"
          
group.long  0x26++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_DLL_CNFG2, SD/eMMC PHY DLL configuration register 2 RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " EMMC_REG_PHY_BLOCK_DLL_CNFG2_JUMPSTEP ,Sets the value of DLL's jump step input RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_DLLDL_CNFG, SD/eMMC PHY DLL MST & Subordinate DL configuration settings RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_PHY_BLOCK_DLLDL_CNFG_MST_EXTDLYEN ,Enable Extended delay mode for manager RESET:0x0"
          
         hexmask.long 0x00 1.--2. 1. " EMMC_REG_PHY_BLOCK_DLLDL_CNFG_MST_INPSEL ,Clock source select for Manager DL RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_REG_PHY_BLOCK_DLLDL_CNFG_MST_BYPASS ,Bypass enable control for Manager DL RESET:0x0"
          
         bitfld.long 0x00 4. " EMMC_REG_PHY_BLOCK_DLLDL_CNFG_SLV_EXTDLYEN ,Enable Extended delay mode for Subordinate RESET:0x0"
          
         hexmask.long 0x00 5.--6. 1. " EMMC_REG_PHY_BLOCK_DLLDL_CNFG_SLV_INPSEL ,Clock source select for Subordinate DL RESET:0x0"
          
         bitfld.long 0x00 7. " EMMC_REG_PHY_BLOCK_DLLDL_CNFG_SLV_BYPASS ,Bypass enable control for Subordinate DL RESET:0x0"
          
group.long  0x29++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_DLL_OFFST, SD/eMMC PHY DLL Offset value settings RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " EMMC_REG_PHY_BLOCK_DLL_OFFST_OFFST ,Sets the value of DLL's offset input RESET:0x0"
          
group.long  0x2a++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_DLLMST_TSTDC, SD/eMMC PHY DLL Manager testing Delay code register RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " EMMC_REG_PHY_BLOCK_DLLMST_TSTDC_MSTTST_DC ,Sets the value of DLL's Manager test code input when DLL is disabled. RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_DLLLBT_CNFG, SD/eMMC PHY DLL Low Bandwidth Timer configuration register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " EMMC_REG_PHY_BLOCK_DLLLBT_CNFG_LBT_LOADVAL ,Sets the value of DLL's olbt_loadval input. Controls the lbt timer's timeout value at which DLL runs a revalidation cycle. RESET:0x0"
          
rgroup.long 0x2e++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_DLL_STATUS, SD/eMMC PHY DLL Status register RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_PHY_BLOCK_DLL_STATUS_LOCK_STS ,Captures the value of DLL's lock status information RESET:0x0" "DLL_IS_LOCKED-1,DLL_NOT_LOCKED-0"
          
         bitfld.long 0x00 1. " EMMC_REG_PHY_BLOCK_DLL_STATUS_ERROR_STS ,Captures the value of DLL's lock error status information. Value is valid only when LOCK_STS is set. -  IF LOCK_STS =1 and ERR_STS = 0 then DLL is locked and no errors are generated -  IF LOCK_STS =1 and ERR_STS = 1 then DLL is locked to default and has errors. Transactions at this phase can fail RESET:0x0" "DLL_ERROR-1,DLL_LOCK_OKAY-0"
          
rgroup.long 0x30++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_DLLDBG_MLKDC, SD/eMMC PHY DLL's Manager lock code status RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " EMMC_REG_PHY_BLOCK_DLLDBG_MLKDC_MSTLKDC ,Captures the value Delay Code to which DLL's Manager has locked RESET:0x0"
          
rgroup.long 0x32++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_DLLDBG_SLKDC, SD/eMMC PHY DLL's Subordinate lock code status RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " EMMC_REG_PHY_BLOCK_DLLDBG_SLKDC_SLVLKDC ,Captures the value Delay Code to which DLL's Subordinate has locked RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_TST_PHY1_DL0, Settings for PHY1 Delay line 0 during testmode RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " EMMC_REG_PHY_BLOCK_TST_PHY1_DL0_PHY1_DL0_DC ,Delay code for PHY1 Delay Line0 Drives Delay Line0  delay code input for PHY1. Value here selects the number of active stages in the Delay line 0 of PHY1. These bits are used only for testmode purposes. The value of these bits are reflected on the signal test_phy1_dl0_dc. RESET:0x0"
          
         bitfld.long 0x00 7. " EMMC_REG_PHY_BLOCK_TST_PHY1_DL0_PHY1_DL0_UPDATE_DC ,Delay code Update for PHY1 Delay Line0 Prepares Delay Line0 of PHY1 for code update when '1'. Its recommended that this bit is 1 when PHY1_DL0_DC is being written. Ensure this is 0 when not updating the code. This bit is used only for testmode purposes. The value of this bit is reflected on the signal test_phy1_dl0_dc_update. RESET:0x0" "TST_DLMODE-0,TST_UPDATEMODE-1"
          
group.long  0x35++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_TST_PHY2_DL0, Settings for PHY2 Delay line 0 during testmode RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " EMMC_REG_PHY_BLOCK_TST_PHY2_DL0_PHY2_DL0_DC ,Delay code for PHY2 Delay Line0 Drives Delay Line0  delay code input for PHY2. Value here selects the number of active stages in the Delay line 0 of PHY2. These bits are used only for testmode purposes. The value of these bits are reflected on the signal test_phy2_dl0_dc. RESET:0x0"
          
         bitfld.long 0x00 7. " EMMC_REG_PHY_BLOCK_TST_PHY2_DL0_PHY2_DL0_UPDATE_DC ,Delay code Update for PHY2 Delay Line0 Prepares Delay Line0 of PHY2 for code update when '1'. Its recommended that this bit is 1 when PHY2_DL0_DC is being written. Ensure this is 0 when not updating the code. This bit is used only for testmode purposes. The value of this bit is reflected on the signal test_phy2_dl0_dc_update. RESET:0x0" "TST_DLMODE-0,TST_UPDATEMODE-1"
          
group.long  0x36++0x3
    line.long 0x00 "EMMC_REG_PHY_BLOCK_TST_PHY2_DL1, Settings for PHY2 Delay line 1 during testmode RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " EMMC_REG_PHY_BLOCK_TST_PHY2_DL1_PHY2_DL1_DC ,Delay code for PHY2 Delay Line1 Drives Delay Line1  delay code input for PHY2. Value here selects the number of active stages in the Delay line 1 of PHY2. These bits are used only for testmode purposes. The value of these bits are reflected on the signal test_phy2_dl1_dc. RESET:0x0"
          
         bitfld.long 0x00 7. " EMMC_REG_PHY_BLOCK_TST_PHY2_DL1_PHY2_DL1_UPDATE_DC ,Delay code Update for PHY2 Delay Line1 Prepares Delay Line1 of PHY2 for code update when '1'. Its recommended that this bit is 1 when PHY2_DL1_DC is being written. Ensure this is 0 when not updating the code. This bit is used only for testmode purposes. The value of this bit is reflected on the signal test_phy2_dl1_dc_update. RESET:0x0" "TST_DLMODE-0,TST_UPDATEMODE-1"
          
tree.end
    

tree "EMMC_REG__VENDOR1_BLOCK"
base e:0x40065500
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "EMMC_REG_VENDOR1_BLOCK_MSHC_VER_ID_R, This register reflects the current release number of DWC_mshc/DWC_mshc_lite. RESET:0x30323030"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_VENDOR1_BLOCK_MSHC_VER_ID_R_MSHC_VER_ID ,Current release number  This field indicates the Synopsys DesignWare Cores DWC_mshc/DWC_mshc_lite current release number that is read by an application.  An application reading this register in conjunction with the MSHC_VER_TYPE_R register, gathers details of the current release. RESET:0x30323030"
          
rgroup.long 0x4++0x3
    line.long 0x00 "EMMC_REG_VENDOR1_BLOCK_MSHC_VER_TYPE_R, This register reflects the current release type of DWC_mshc/DWC_mshc_lite. RESET:0x67612a2a"
         hexmask.long 0x00 0.--31. 1. " EMMC_REG_VENDOR1_BLOCK_MSHC_VER_TYPE_R_MSHC_VER_TYPE ,Current release type  This field indicates the Synopsys DesignWare Cores DWC_mshc/DWC_mshc_lite current release type that is read by an application.  An application reading this register in conjunction with the MSHC_VER_ID_R register, gathers details of the current release. RESET:0x67612a2a"
          
group.long  0x8++0x3
    line.long 0x00 "EMMC_REG_VENDOR1_BLOCK_MSHC_CTRL_R, This register is used to control the operation of MSHC Host Controller. RESET:0x1"
         bitfld.long 0x00 0. " EMMC_REG_VENDOR1_BLOCK_MSHC_CTRL_R_CMD_CONFLICT_CHECK ,Command conflict check  This bit enables command conflict check.  Note: DWC_mshc controller monitors the CMD line whenever a command is issued and checks whether the value driven on sd_cmd_out matches the value on sd_cmd_in at next subsequent edge of cclk_tx to determine command conflict error. This bit is cleared only if the feed back delay (including IO Pad delay) is more than (t_card_clk_period - t_setup), where t_setup is the setup time of a flop in DWC_mshc. The I/O pad delay is consistent across CMD and DATA lines, and it is within the value: (2*t_card_clk_period - t_setup) RESET:0x1" "CMD_CONFLICT_CHK_LAT1-1,DISABLE_CMD_CONFLICT_CHK-0"
          
         bitfld.long 0x00 1. " EMMC_REG_VENDOR1_BLOCK_MSHC_CTRL_R_NEGEDGE_DATAOUT_EN ,Negedge Data Out  This bit enables the data to be sent out on negedge of cclk_tx. This is valid only for speed mode HS400. RESET:0x0" "DISABLED-0,ENABLED-1"
          
         hexmask.long 0x00 2.--3. 1. " EMMC_REG_VENDOR1_BLOCK_MSHC_CTRL_R_RSVD1 ,These bits (RSVD1) of the MSHC_CTRL_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 4. " EMMC_REG_VENDOR1_BLOCK_MSHC_CTRL_R_SW_CG_DIS ,Internal clock gating disable control  This bit must be used to disable IP's internal clock gating when required. when disabled clocks are not gated. Clocks to the core (except hclk) must be stopped when programming this bit. RESET:0x0" "DISABLE-1,ENABLE-0"
          
         bitfld.long 0x00 5. " EMMC_REG_VENDOR1_BLOCK_MSHC_CTRL_R_SLV_ERR_RESP_NONEXIS_REG ,When 0 this bit gives subordinate error response for non existent register access. Currently this is a read-ony bit with default value 0. RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "EMMC_REG_VENDOR1_BLOCK_MBIU_CTRL_R, This register is used to select the valid burst types that the AHB Manager bus interface can generate. When more than one bit is set the manager selects the burst it prefers among those that are enabled in this register. RESET:0xf"
         bitfld.long 0x00 0. " EMMC_REG_VENDOR1_BLOCK_MBIU_CTRL_R_UNDEFL_INCR_EN ,Undefined INCR Burst Controls generation of undefined length INCR transfer on Manager interface. RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_VENDOR1_BLOCK_MBIU_CTRL_R_BURST_INCR4_EN ,INCR4 Burst Controls generation of INCR4 transfers on Manager interface. RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_VENDOR1_BLOCK_MBIU_CTRL_R_BURST_INCR8_EN ,INCR8 Burst Controls generation of INCR8 transfers on Manager interface. RESET:0x1" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_VENDOR1_BLOCK_MBIU_CTRL_R_BURST_INCR16_EN ,INCR16 Burst Controls generation of INCR16 transfers on Manager interface. RESET:0x1" "FALSE-0,TRUE-1"
          
         hexmask.long 0x00 4.--7. 1. " EMMC_REG_VENDOR1_BLOCK_MBIU_CTRL_R_RSVD ,Reserved field RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "EMMC_REG_VENDOR1_BLOCK_EMMC_CTRL_R, This register is used to control the eMMC operation. RESET:0xc"
         bitfld.long 0x00 0. " EMMC_REG_VENDOR1_BLOCK_EMMC_CTRL_R_CARD_IS_EMMC ,eMMC Card present  This bit indicates the type of card connected. An application program this bit based on the card connected to MSHC. RESET:0x0" "EMMC_CARD-1,NON_EMMC_CARD-0"
          
         bitfld.long 0x00 1. " EMMC_REG_VENDOR1_BLOCK_EMMC_CTRL_R_DISABLE_DATA_CRC_CHK ,Disable Data CRC Check  This bit controls masking of CRC16 error for Card Write in eMMC mode. This is useful in bus testing (CMD19) for an eMMC device. In bus testing, an eMMC card does not send CRC status for a block, which may generate CRC error. This CRC error can be masked using this bit during bus testing. RESET:0x0" "DISABLE-1,ENABLE-0"
          
         bitfld.long 0x00 2. " EMMC_REG_VENDOR1_BLOCK_EMMC_CTRL_R_EMMC_RST_N ,EMMC Device Reset signal control.  This register field controls the sd_rst_n output of DWC_mshc RESET:0x1" "RST_ASSERT-0,RST_DEASSERT-1"
          
         bitfld.long 0x00 3. " EMMC_REG_VENDOR1_BLOCK_EMMC_CTRL_R_EMMC_RST_N_OE ,Output Enable control for EMMC Device Reset signal PAD control.  This field drived sd_rst_n_oe output of DWC_mshc RESET:0x1" "DISABLE-0,ENABLE-1"
          
         bitfld.long 0x00 8. " EMMC_REG_VENDOR1_BLOCK_EMMC_CTRL_R_ENH_STROBE_ENABLE ,Enhanced Strobe Enable  This bit instructs DWC_mshc to sample the CMD line using data strobe for HS400 mode. RESET:0x0" "ENH_STB_FOR_CMD-1,NO_STB_FOR_CMD-0"
          
         bitfld.long 0x00 9. " EMMC_REG_VENDOR1_BLOCK_EMMC_CTRL_R_CQE_ALGO_SEL ,Scheduler algorithm selected for execution  This bit selects the Algorithm used for selecting one of the many ready tasks for execution. RESET:0x0" "FCFS_ONLY-1,PRI_REORDER_PLUS_FCFS-0"
          
         bitfld.long 0x00 10. " EMMC_REG_VENDOR1_BLOCK_EMMC_CTRL_R_CQE_PREFETCH_DISABLE ,Enable or Disable CQE's PREFETCH feature  This field allows Software to disable CQE's data prefetch feature when set to 1. RESET:0x0" "PREFETCH_DISABLE-1,PREFETCH_ENABLE-0"
          
         hexmask.long 0x00 11.--15. 1. " EMMC_REG_VENDOR1_BLOCK_EMMC_CTRL_R_RSVD ,These bits (RSVD) of the EMMC_CTRL_R register are reserved. They always return 0. RESET:0x0"
          
group.long  0x2e++0x3
    line.long 0x00 "EMMC_REG_VENDOR1_BLOCK_BOOT_CTRL_R, This register is used to control the eMMC Boot operation. RESET:0x0"
         bitfld.long 0x00 0. " EMMC_REG_VENDOR1_BLOCK_BOOT_CTRL_R_MAN_BOOT_EN ,Mandatory Boot Enable  This bit is used to initiate the mandatory boot operation. The application sets this bit along with VALIDATE_BOOT bit. Writing 0 is ignored. The DWC_mshc clears this bit after the boot transfer is completed or terminated. RESET:0x0" "MAN_BOOT_DIS-0,MAN_BOOT_EN-1"
          
         hexmask.long 0x00 1.--6. 1. " EMMC_REG_VENDOR1_BLOCK_BOOT_CTRL_R_RSVD_6_1 ,These bits (RSVD _6_1) of the BOOT_CTRL_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 7. " EMMC_REG_VENDOR1_BLOCK_BOOT_CTRL_R_VALIDATE_BOOT ,Validate Mandatory Boot Enable bit  This bit is used to validate the MAN_BOOT_EN bit. RESET:0x0" "FALSE-0,TRUE-1"
          
         bitfld.long 0x00 8. " EMMC_REG_VENDOR1_BLOCK_BOOT_CTRL_R_BOOT_ACK_ENABLE ,Boot Acknowledge Enable  When this bit set, DWC_mshc checks for boot acknowledge start pattern of 0-1-0 during boot operation. This bit is applicable for both mandatory and alternate boot mode. RESET:0x0" "FALSE-0,TRUE-1"
          
         hexmask.long 0x00 9.--11. 1. " EMMC_REG_VENDOR1_BLOCK_BOOT_CTRL_R_RSVD_11_9 ,These bits (RSVD_11_9) of the BOOT_CTRL_R register are reserved. They always return 0. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " EMMC_REG_VENDOR1_BLOCK_BOOT_CTRL_R_BOOT_TOUT_CNT ,Boot Ack Timeout Counter Value.  This value determines the interval by which boot ack timeout (50 ms) is detected when boot ack is expected during boot operation.  - 0xF : Reserved  - 0xE : TMCLK x 2^27  - ..   - ............  - 0x1 : TMCLK x 2^14  - 0x0 : TMCLK x 2^13 RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "EMMC_REG_VENDOR1_BLOCK_AT_CTRL_R, This register controls some aspects of tuning and auto-tuning features. Do not program this register when HOST_CTRL2_R.SAMPLE_CLK_SEL is '1' RESET:0x1f000005"
         bitfld.long 0x00 0. " EMMC_REG_VENDOR1_BLOCK_AT_CTRL_R_AT_EN ,Setting this bit enables Auto tuning engine. This bit is enabled by default when core is configured with mode3 retuning support. Clear this bit to 0 when core is configured to have Mode3 re-tuning but SW wishes to disable mode3 re-tuning.  This field should be programmed only when CLK_CTRL_R.SD_CLK_EN is 0. RESET:0x1" "AT_DISABLE-0,AT_ENABLE-1"
          
         bitfld.long 0x00 1. " EMMC_REG_VENDOR1_BLOCK_AT_CTRL_R_CI_SEL ,Selects the interval when the corrected center phase select code can be driven on tuning_cclk_sel output. RESET:0x0" "WHEN_IN_BLK_GAP-0,WHEN_IN_IDLE-1"
          
         bitfld.long 0x00 2. " EMMC_REG_VENDOR1_BLOCK_AT_CTRL_R_SWIN_TH_EN ,Sampling window Threshold enable  Selects the tuning mode  Field should be programmed only when SAMPLE_CLK_SEL is '0' RESET:0x1" "LARGEST_WIN_MODE-0,THRESHOLD_MODE-1"
          
         bitfld.long 0x00 3. " EMMC_REG_VENDOR1_BLOCK_AT_CTRL_R_RPT_TUNE_ERR ,Framing errors are not generated when executing tuning. This debug bit allows users to report these errors. RESET:0x0" "DEBUG_ERRORS-1,ERRORS_DISABLED-0"
          
         bitfld.long 0x00 4. " EMMC_REG_VENDOR1_BLOCK_AT_CTRL_R_SW_TUNE_EN ,This fields enables software-managed tuning flow. RESET:0x0" "SW_TUNING_DISABLE-0,SW_TUNING_ENABLE-1"
          
         hexmask.long 0x00 5.--7. 1. " EMMC_REG_VENDOR1_BLOCK_AT_CTRL_R_RSDV2 ,These bits (RSVD2) of the AT_CTRL_R register are reserved. They always return 0. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " EMMC_REG_VENDOR1_BLOCK_AT_CTRL_R_WIN_EDGE_SEL ,This field sets the phase for Left and Right edges for drift monitoring. [Left edge offset + Right edge offset] must not be less than total taps of delayLine. - 0x0: User selection disabled. Tuning calculated edges are used. - 0x1: Right edge Phase is center + 2 stages, Left edge Phase is center - 2 stages. - 0x2: Right edge Phase is center + 3 stages, Left edge Phase is center - 3 stages. - ... - 0xF: Right edge Phase is center + 16 stages, Left edge Phase is center - 16 stages. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " EMMC_REG_VENDOR1_BLOCK_AT_CTRL_R_RSDV3 ,These bits (RSVD3) of the AT_CTRL_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 16. " EMMC_REG_VENDOR1_BLOCK_AT_CTRL_R_TUNE_CLK_STOP_EN ,Clock stopping control for Tuning and auto-tuning circuit.  When enabled, clock gate control output of DWC_mshc (clk2card_on) is pulled low before changing phase select codes on tuning_cclk_sel and autotuning_cclk_sel. This effectively stops the Device/Card clock, cclk_rx and also drift_cclk_rx. Changing phase code when clocks are stopped ensures glitch free phase switching. Set this bit to 0 if the PHY or delayline can guarantee glitch free switching. RESET:0x0" "DISABLE_CLK_STOPPING-0,ENABLE_CLK_STOPPING-1"
          
         bitfld.long 0x00 17.--18. " EMMC_REG_VENDOR1_BLOCK_AT_CTRL_R_PRE_CHANGE_DLY ,Maximum Latency specification between cclk_tx and cclk_rx. RESET:0x0" "LATENCY_LT_1-0,LATENCY_LT_2-1,LATENCY_LT_3-2,LATENCY_LT_4-3"
          
         bitfld.long 0x00 19.--20. " EMMC_REG_VENDOR1_BLOCK_AT_CTRL_R_POST_CHANGE_DLY ,Time taken for phase switching and stable clock output.  Specifies the maximum time (in terms of cclk cycles) that the delay line can take to switch its output phase after a change in tuning_cclk_sel or autotuning_cclk_sel. Set a value of 0x3 for glitch free clock switching when the PHY Type is SNPS SD/eMMC phy. RESET:0x0" "LATENCY_LT_1-0,LATENCY_LT_2-1,LATENCY_LT_3-2,LATENCY_LT_4-3"
          
         hexmask.long 0x00 24.--30. 1. " EMMC_REG_VENDOR1_BLOCK_AT_CTRL_R_SWIN_TH_VAL ,Sampling window threshold value setting  The maximum value that can be set here depends on the length of delayline used for tuning. A delayLine with 128 taps can use values from 0x0 to 0x7F.  This field is valid only when SWIN_TH_EN is '1'. Should be programmed only when SAMPLE_CLK_SEL is '0'      - 0x0 : Threshold values is 0x1, windows of length 1 tap and above can be selected as sampling window.      - 0x1 : Threshold values is 0x2, windows of length 2 taps and above can be selected as sampling window.      - 0x2 : Threshold values is 0x1, windows of length 3 taps and above can be selected as sampling window.      - ........      - 0x7F : Threshold values is 0x1, windows of length 127 taps and above can be selected as sampling window. RESET:0x1f"
          
group.long  0x44++0x3
    line.long 0x00 "EMMC_REG_VENDOR1_BLOCK_AT_STAT_R, Register to read the Center, Left and Right codes used by tuning and auto-tuning engines. Center code field is also used for software managed tuning. RESET:0x80000006"
         hexmask.long 0x00 0.--7. 1. " EMMC_REG_VENDOR1_BLOCK_AT_STAT_R_CENTER_PH_CODE ,Centered Phase code. Reading this field returns the current value on tuning_cclk_sel output. Setting AT_CTRL_R.SW_TUNE_EN enables software to write to this field and its contents are reflected on tuning_cclk_sel. RESET:0x6"
          
         hexmask.long 0x00 8.--15. 1. " EMMC_REG_VENDOR1_BLOCK_AT_STAT_R_R_EDGE_PH_CODE ,Right Edge Phase code. Reading this field returns the phase code value used by Auto-tuning engine to sample data on Right edge of sampling window. RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " EMMC_REG_VENDOR1_BLOCK_AT_STAT_R_L_EDGE_PH_CODE ,Left Edge Phase code. Reading this field returns the phase code value used by Auto-tuning engine to sample data on Left edge of sampling window. RESET:0x0"
          
         hexmask.long 0x00 24.--30. 1. " EMMC_REG_VENDOR1_BLOCK_AT_STAT_R_RSDV1 ,These bits of the AT_STAT_R register are reserved. They always return 0. RESET:0x0"
          
         bitfld.long 0x00 31. " EMMC_REG_VENDOR1_BLOCK_AT_STAT_R_DL2_BUSY ,Delay Line 2 busy indication. If this bit is set then it indicates that the cclk_rx delay line is in the process of delay code updation. RESET:0x1"
          
tree.end
    

tree "EMMC_REG__EMBEDDED_CONTROL_BLOCK"
base e:0x40065f6c
width 80.
group.long  0x0++0x3
    line.long 0x00 "EMMC_REG_EMBEDDED_CONTROL_BLOCK_EMBEDDED_CTRL_R, This register controls the embedded device. When the Host Controller is connected to a removable device, this register is not used. RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " EMMC_REG_EMBEDDED_CONTROL_BLOCK_EMBEDDED_CTRL_R_NUM_CLK_PIN ,Number of Clock Pins (SD Mode)  This field indicates support of clock pins to select one of devices for shared bus system. Up to 7 clock pins can be supported.  - 0x0 : Shared bus is not supported  - 0x1 : 1 SDCLK is supported  - 0x2 - 2 SDCLK is supported  -  .    .  -  .    .  -  .    .  - 0x7 : 7 SDCLK is supported RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_REG_EMBEDDED_CONTROL_BLOCK_EMBEDDED_CTRL_R_RSVD_3 ,This bit (RSVD_3) of the EMBEDDED_CTRL_R register is reserved. It always returns 0. RESET:0x0"
          
         hexmask.long 0x00 4.--5. 1. " EMMC_REG_EMBEDDED_CONTROL_BLOCK_EMBEDDED_CTRL_R_NUM_INT_PIN ,Number of Interrupt Input Pins  This field indicates support of interrupt input pins for an embedded system. RESET:0x0"
          
         hexmask.long 0x00 6.--7. 1. " EMMC_REG_EMBEDDED_CONTROL_BLOCK_EMBEDDED_CTRL_R_RSVD_7_6 ,These bits (RSVD_7_6) of the EMBEDDED_CTRL_R register are reserved. They always return 0. RESET:0x0"
          
         hexmask.long 0x00 8.--14. 1. " EMMC_REG_EMBEDDED_CONTROL_BLOCK_EMBEDDED_CTRL_R_BUS_WIDTH_PRESET ,Bus Width Preset (SD Mode)  Each bit of this field specifies the bus width for each embedded device. The shared bus supports mixing of 4-bit and 8-bit bus width devices.  - D08 : Bus Width Preset for Device 1  - D09 : Bus Width Preset for Device 2  - D10 : Bus Width Preset for Device 3  - D11 : Bus Width Preset for Device 4  - D12 : Bus Width Preset for Device 5  - D13 : Bus Width Preset for Device 6  - D14 : Bus Width Preset for Device 7  Function of each bit is defined as follows:  - 0 : 4-bit bus width mode  - 1 : 8-bit bus width mode RESET:0x0"
          
         bitfld.long 0x00 15. " EMMC_REG_EMBEDDED_CONTROL_BLOCK_EMBEDDED_CTRL_R_RSVD_15 ,This bit (RSVD_15) of the EMBEDDED_CTRL_R register is reserved. It always returns 0. RESET:0x0"
          
         hexmask.long 0x00 16.--18. 1. " EMMC_REG_EMBEDDED_CONTROL_BLOCK_EMBEDDED_CTRL_R_CLK_PIN_SEL ,Clock Pin Select (SD Mode)  This bit is selected by one of clock pin outputs.  - 0x0 : Clock pins are disabled  - 0x1 : CLK[1] is selected  - 0x2 : CLK[2] is selected  -  .      .  -  .      .  -  .      .  - 0x7 : CLK[7] is selected RESET:0x0"
          
         bitfld.long 0x00 19. " EMMC_REG_EMBEDDED_CONTROL_BLOCK_EMBEDDED_CTRL_R_RSVD_19 ,This bit (RSVD_19) of the EMBEDDED_CTRL_R register is reserved. It always returns 0. RESET:0x0"
          
         hexmask.long 0x00 20.--22. 1. " EMMC_REG_EMBEDDED_CONTROL_BLOCK_EMBEDDED_CTRL_R_INT_PIN_SEL ,Interrupt Pin Select  These bits enable the interrupt pin inputs.  - 000 : Interrupts (INT_A,INT_B,INT_C) are disabled  - xx1 : INT_A is enabled  - x1x : INT_B is enabled  - 1xx : INT_C is enabled RESET:0x0"
          
         bitfld.long 0x00 23. " EMMC_REG_EMBEDDED_CONTROL_BLOCK_EMBEDDED_CTRL_R_RSVD_23 ,This bit (RSVD_23) of the EMBEDDED_CTRL_R register is reserved. It always returns 0. RESET:0x0"
          
         hexmask.long 0x00 24.--30. 1. " EMMC_REG_EMBEDDED_CONTROL_BLOCK_EMBEDDED_CTRL_R_BACK_END_PWR_CTRL ,Back-End Power Control (SD Mode)  Each bit of this field controls back-end power supply for an embedded device.  - 0 : Back-End Power is off  - 1 : Back-End Power is supplied  D24 : Back-End Power for Device 1  D25 : Back-End Power for Device 2  D26 : Back-End Power for Device 3  D27 : Back-End Power for Device 4  D28 : Back-End Power for Device 5  D29 : Back-End Power for Device 6  D30 : Back-End Power for Device 7 RESET:0x0"
          
         bitfld.long 0x00 31. " EMMC_REG_EMBEDDED_CONTROL_BLOCK_EMBEDDED_CTRL_R_RSVD_31 ,This bit (RSVD_31) of the EMBEDDED_CTRL_R register is reserved. It always returns 0. RESET:0x0"
          
tree.end

tree "RI_QSPI_DISPLAY_RDMA"
base e:0x40068000
width 80.
tree.end

tree "RI_QSPI_DISPLAY_RDMA__RI_RDMA_REG"
base e:0x40068000
width 80.
group.long  0x0++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_CTRL_ENABLE ,Global enable for the RDMA RESET:0x0"
          
         bitfld.long 0x00 1. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next read will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
         bitfld.long 0x00 11. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_CTRL_TERMINATE ,Manual termination of stream, concludes transaction and sends tlast. Self-clearing RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_SIZE1, SIZE1 interrupt triggers in case size1 byte have been read from the buffer / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_CURR_ADDR, the current address of the DMA read pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS, interrupt status bits reflect the occurrence of an event / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS_UNFL ,Underflow: data towards AXI-4S is consumed faster than the DMA is able to read data from the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS_ENABLE_UNFL ,Enable interrupt unfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev) RESET:0x0"
         bitfld.long 0x00 0. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS_SET_BERR ,Set interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " RI_QSPI_DISPLAY_RDMA_RI_RDMA_REG_IRQ_STATUS_SET_UNFL ,Set interrupt unfl RESET:0x0"
          
tree.end

tree "RI_QSPI_DISPLAY"
base e:0x40069000
width 80.
tree.end

tree "RI_QSPI_DISPLAY__QSPI_MASTER"
base e:0x40069000
width 80.
group.long  0x0++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_QSPI_MASTER_CFG_ITF, Configuration for (Q)SPI master interface RESET:0x40"
         bitfld.long 0x00 0.--1. " RI_QSPI_DISPLAY_QSPI_MASTER_CFG_ITF_SPI_MODE ,SPI interface mode - 00: 1 bit SPI (single SPI) (default) - 01: 2 bit SPI (dual SPI) - 10: 4 bit SPI (quad SPI) - 11: reserved RESET:0x0" "SNGL_SPI-0,DUAL_SPI-1,QUAD_SPI-2"
          
         bitfld.long 0x00 2. " RI_QSPI_DISPLAY_QSPI_MASTER_CFG_ITF_CPHA ,SPI clock phase - 0: change data on falling egde, sample data on rising  edge (default) - 1: change data on rising  egde, sample data on falling edge RESET:0x0"
          
         bitfld.long 0x00 3. " RI_QSPI_DISPLAY_QSPI_MASTER_CFG_ITF_CPOL ,SPI clock polarity - 0: clock in idle state is low (default) - 1: clock in idle state is high RESET:0x0"
          
         bitfld.long 0x00 4.--5. " RI_QSPI_DISPLAY_QSPI_MASTER_CFG_ITF_MOSI_SEL ,select QSPI data port for SPI MOSI (output) in single SPI mode - 0: MOSI[0] (default) - 1: MOSI[1] - 2: MOSI[2] - 3: MOSI[3] RESET:0x0" "MOSI_0-0,MOSI_1-1,MOSI_2-2,MOSI_3-3"
          
         bitfld.long 0x00 6.--7. " RI_QSPI_DISPLAY_QSPI_MASTER_CFG_ITF_MISO_SEL ,select QSPI data port for SPI MISO (input) in single SPI mode - 0: MISO[0] - 1: MISO[1] (default) - 2: MISO[2] - 3: MISO[3] RESET:0x1" "MISO_0-0,MISO_1-1,MISO_2-2,MISO_3-3"
          
group.long  0x4++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_QSPI_MASTER_CFG_SCLK, Configuration for SPI clock RESET:0x10001"
         hexmask.long 0x00 0.--7. 1. " RI_QSPI_DISPLAY_QSPI_MASTER_CFG_SCLK_CDIV ,SPI clock divider SPI clock[freq] = sys_clk / (2*(cdiv+1))     duty cycle is 50% RESET:0x1"
          
         hexmask.long 0x00 16.--24. 1. " RI_QSPI_DISPLAY_QSPI_MASTER_CFG_SCLK_SMPL_POINT ,sample point - [8]   : SPI clock high/low - [7:0] : clk_div_phase example: sample at rising edge: [8]   = 0 [7:0] = cdiv RESET:0x1"
          
group.long  0x8++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_QSPI_MASTER_CFG_SS_TIMING, configure SPI slave select timing RESET:0x100"
         hexmask.long 0x00 0.--3. 1. " RI_QSPI_DISPLAY_QSPI_MASTER_CFG_SS_TIMING_SETUP ,setup time, time from falling edge of 'slave select' to first active SPI clock edge, number of SPI clock periods, values 0-15 (default = 0) RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " RI_QSPI_DISPLAY_QSPI_MASTER_CFG_SS_TIMING_HOLD ,hold time, time from last active SPI clock edge to rising edge of 'slave select', number of SPI clock periods, values 0-15 (default = 0) RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " RI_QSPI_DISPLAY_QSPI_MASTER_CFG_SS_TIMING_INACTIVE ,minimum inactive time (inter transaction gap), SPI slave select is high for minimum this period between transactions, number of SPI clock periods, values 0-15 (default = 1) RESET:0x1"
          
group.long  0xc++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_QSPI_MASTER_CTRL, (Q)SPI master control RESET:0x0"
         bitfld.long 0x00 0. " RI_QSPI_DISPLAY_QSPI_MASTER_CTRL_RESTART ,Restart (Q)SPI master interface (single pulse / self clearing) reset state and flush buffers RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_QSPI_MASTER_EXT_SS_CTRL, (Q)SPI slave select control RESET:0x2"
         bitfld.long 0x00 0. " RI_QSPI_DISPLAY_QSPI_MASTER_EXT_SS_CTRL_ENABLE ,enable external slave select RESET:0x0"
          
         bitfld.long 0x00 1. " RI_QSPI_DISPLAY_QSPI_MASTER_EXT_SS_CTRL_VALUE ,value of external slave select 0: low 1: high (default) RESET:0x1"
          
rgroup.long 0x14++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_QSPI_MASTER_STATUS, (Q)SPI state RESET:0x0"
         bitfld.long 0x00 0.--2. " RI_QSPI_DISPLAY_QSPI_MASTER_STATUS_STATE ,FSM state of (Q)SPI master RESET:0x0" "IDLE-0,SS_SETUP-1,SS_HOLD-2,SS_INACTIVE-3,SHIFTING-4,SHIFT_LAST_WORD-5,WAIT-6,FINISH_TRANSFER-7"
          
tree.end

tree "RI_QSPI_DISPLAY__DISP_CTRL"
base e:0x40069040
width 80.
group.long  0x0++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_DISP_CTRL_CFG, Configuration for (Q)SPI display controller RESET:0x2"
         bitfld.long 0x00 0.--1. " RI_QSPI_DISPLAY_DISP_CTRL_CFG_PX_DWIDTH_SRC ,pixel data width of data source (frame buffer) - 00: 8  bit - 01: 16 bit - 10: 24 bit (default) - 11: 32 bit RESET:0x2" "PX_8_BIT-0,PX_16_BIT-1,PX_24_BIT-2,PX_32_BIT-3"
          
         bitfld.long 0x00 2.--3. " RI_QSPI_DISPLAY_DISP_CTRL_CFG_PX_DWIDTH_SNK ,pixel data width of data sink (display) - 00: 8  bit (default) - 01: 16 bit - 10: 24 bit - 11: 32 bit RESET:0x0" "PX_8_BIT-0,PX_16_BIT-1,PX_24_BIT-2,PX_32_BIT-3"
          
         hexmask.long 0x00 4.--5. 1. " RI_QSPI_DISPLAY_DISP_CTRL_CFG_PX_CONVERT_SELECT ,pixel conversion select - 00: no convert (default) - 01: RGB remap (see cfg_px_color_remap) - 10: RGB -> YCbCr - 11: no convert RESET:0x0"
          
         hexmask.long 0x00 6.--8. 1. " RI_QSPI_DISPLAY_DISP_CTRL_CFG_PX_COLOR_REMAP ,reorder pixel components, only applicable for 24 bit source pixel data width 0: RGB -> RGB (default), 1: RGB -> RBG 2: RGB -> GRB 3: RGB -> GBR 4: RGB -> BRG 5: RGB -> BGR 6-7: reserved RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_CTRL_0, (Q)SPI display command RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_CTRL_0_WRITE_LENGTH ,SPI command write length, # of bytes {0-16}, see 'ctrl_cmd_write_data_byte[15:0]' for data to be written, 'ctrl_cmd_write_data_byte_0' is the first byte RESET:0x0"
          
         hexmask.long 0x00 5.--7. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_CTRL_0_READ_LENGTH ,SPI command read length, # of bytes {0-4}, see 'sta_read_data_byte[3:0]' for read data, 'sta_read_data_byte_0' is the first byte RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_0, SPI command bytes 0-3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_0_BYTE_0 ,write data byte  0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_0_BYTE_1 ,write data byte  1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_0_BYTE_2 ,write data byte  2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_0_BYTE_3 ,write data byte  3 RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_1, SPI command bytes 4-7 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_1_BYTE_4 ,write data byte  4 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_1_BYTE_5 ,write data byte  5 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_1_BYTE_6 ,write data byte  6 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_1_BYTE_7 ,write data byte  7 RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_2, SPI command bytes 8-11 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_2_BYTE_8 ,write data byte  8 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_2_BYTE_9 ,write data byte  9 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_2_BYTE_10 ,write data byte 10 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_2_BYTE_11 ,write data byte 11 RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_3, SPI command bytes 12-15 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_3_BYTE_12 ,write data byte 12 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_3_BYTE_13 ,write data byte 13 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_3_BYTE_14 ,write data byte 14 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_WRITE_DATA_3_BYTE_15 ,write data byte 15 RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_CTRL_1, SPI transfer control RESET:0x0"
         bitfld.long 0x00 0. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_CMD_CTRL_1_START ,start SPI transfer (single pulse / self clearing) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_DISP_CTRL_PIXEL_DATA_TRANSFER, Pixel data transfer control RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " RI_QSPI_DISPLAY_DISP_CTRL_PIXEL_DATA_TRANSFER_LENGTH ,# of pixel data bytes for next SPI transaction RESET:0x0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_DISP_CTRL_SPI_READ_DATA, SPI read data RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_READ_DATA_BYTE_0 ,read data byte 0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_READ_DATA_BYTE_1 ,read data byte 1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_READ_DATA_BYTE_2 ,read data byte 2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " RI_QSPI_DISPLAY_DISP_CTRL_SPI_READ_DATA_BYTE_3 ,read data byte 3 RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_DISP_CTRL_QSPI_DISP_CTRL, (Q)SPI display controller control RESET:0x0"
         bitfld.long 0x00 0. " RI_QSPI_DISPLAY_DISP_CTRL_QSPI_DISP_CTRL_RESTART ,Restart (Q)SPI display controller (single pulse / self clearing) reset state and flush buffers RESET:0x0"
          
rgroup.long 0x28++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_DISP_CTRL_STATUS, (Q)SPI display control state RESET:0x0"
         bitfld.long 0x00 0.--2. " RI_QSPI_DISPLAY_DISP_CTRL_STATUS_STATE ,FSM state of (Q)SPI display control RESET:0x0" "IDLE-0,SPI_WRITE-1,SPI_READ-2,SPI_READ_FINISH-3,SEND_PIXEL_DATA-4,FINISHED-5"
          
group.long  0x2c++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_DISP_CTRL_IRQ_STATUS, (Q)SPI display control IRQ RESET:0x0"
         bitfld.long 0x00 0. " RI_QSPI_DISPLAY_DISP_CTRL_IRQ_STATUS_JOB_DONE ,IRQ status : job done; Indicates, that QSPI transfer job has finished RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_DISP_CTRL_IRQ_STATUS_ENABLE, (Q)SPI display control IRQ enable mask RESET:0x0"
         bitfld.long 0x00 0. " RI_QSPI_DISPLAY_DISP_CTRL_IRQ_STATUS_ENABLE_JOB_DONE ,IRQ enable : job done RESET:0x0"
          
wgroup.long 0x34++0x3
    line.long 0x00 "RI_QSPI_DISPLAY_DISP_CTRL_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev). RESET:0x0"
         bitfld.long 0x00 0. " RI_QSPI_DISPLAY_DISP_CTRL_IRQ_STATUS_SET_JOB_DONE ,Set irq_status.job_done RESET:0x0"
          
tree.end

tree "ETHERNET_MAC_SEC"
base e:0x40072000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETHERNET_MAC_SEC_TCTRL, TODO RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " ETHERNET_MAC_SEC_TCTRL_TVALFRAMES ,TODO RESET:0x0"
          
group.long  0x100++0x3
    line.long 0x00 "ETHERNET_MAC_SEC_RCTRL, TODO RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " ETHERNET_MAC_SEC_RCTRL_RVALFRAMES ,TODO RESET:0x0"
          
tree.end

tree "SGMII_WRAP_REG"
base e:0x40073000
width 80.
tree.end
    

tree "SGMII_WRAP_REG__SGMII_REG_TOP"
base e:0x40073000
width 80.
group.long  0x0++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_TX_CFG, None RESET:0x30"
         bitfld.long 0x00 0. " SGMII_WRAP_REG_SGMII_REG_TOP_TX_CFG_PCS_LOOPBACK ,enable TX PCS loopback RESET:0x0"
          
         hexmask.long 0x00 4.--8. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_TX_CFG_PCS_RESET_TIME ,PCS reset time RESET:0x3"
          
         hexmask.long 0x00 12.--14. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_TX_CFG_PRBS_SEL ,PRBS pattern select RESET:0x0"
          
         bitfld.long 0x00 15. " SGMII_WRAP_REG_SGMII_REG_TOP_TX_CFG_PRBS_FORCE_ERR ,force PRBS error RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_RX_CFG0, None RESET:0x6303"
         hexmask.long 0x00 0.--4. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_RX_CFG0_PCS_RESET_TIME ,PCS reset time RESET:0x3"
          
         hexmask.long 0x00 8.--12. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_RX_CFG0_CDR_RESET_TIME ,CDR reset time RESET:0x3"
          
         hexmask.long 0x00 13.--17. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_RX_CFG0_BUF_RESET_TIME ,Buffer reset time RESET:0x3"
          
         bitfld.long 0x00 20. " SGMII_WRAP_REG_SGMII_REG_TOP_RX_CFG0_BUF_BYPASS ,bypass Elastic Buffer RESET:0x0"
          
         hexmask.long 0x00 24.--26. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_RX_CFG0_PRBS_SEL ,PRBS pattern select RESET:0x0"
          
         bitfld.long 0x00 27. " SGMII_WRAP_REG_SGMII_REG_TOP_RX_CFG0_PRBS_CNT_RESET ,PRBS Error Counter reset RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_RX_CFG1, None RESET:0x19e0"
         hexmask.long 0x00 0.--5. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_RX_CFG1_CLKCOR_MIN_LAT ,Clock Correction minimum latency RESET:0x20"
          
         hexmask.long 0x00 6.--11. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_RX_CFG1_CLKCOR_MAX_LAT ,Clock Correction maximum latency RESET:0x27"
          
         bitfld.long 0x00 12. " SGMII_WRAP_REG_SGMII_REG_TOP_RX_CFG1_CLKCOR_USE ,use Elastic Buffer Clock Correction RESET:0x1"
          
wgroup.long 0xc++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_PRBS_ERR_CAPTURE, None RESET:0x0"
         bitfld.long 0x00 0. " SGMII_WRAP_REG_SGMII_REG_TOP_PRBS_ERR_CAPTURE_CAPTURE ,Triggers capture of PRBS Error counter RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_PRBS_ERR, None RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_PRBS_ERR_CNT ,PRBS error counter RESET:0x0"
          
         bitfld.long 0x00 15. " SGMII_WRAP_REG_SGMII_REG_TOP_PRBS_ERR_CNT_VALID ,PRBS error counter valid RESET:0x0"
          
         bitfld.long 0x00 16. " SGMII_WRAP_REG_SGMII_REG_TOP_PRBS_ERR_LOCKED ,PRBS locked RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_DEBUG, None RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_DEBUG_OVRS_SEL ,select Oversampler data phase RESET:0x0"
          
         hexmask.long 0x00 3.--5. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_DEBUG_DATA_SEL ,select data output RESET:0x0"
          
         bitfld.long 0x00 8. " SGMII_WRAP_REG_SGMII_REG_TOP_DEBUG_BYTE_ALIGNED ,receiver byte is aligned RESET:0x0"
          
         bitfld.long 0x00 9. " SGMII_WRAP_REG_SGMII_REG_TOP_DEBUG_RX_RESETDONE ,receiver reset done RESET:0x0"
          
         bitfld.long 0x00 10. " SGMII_WRAP_REG_SGMII_REG_TOP_DEBUG_TX_RESETDONE ,transmitter reset done RESET:0x0"
          
         bitfld.long 0x00 11. " SGMII_WRAP_REG_SGMII_REG_TOP_DEBUG_RX_BUF_ERR ,receiver buffer error RESET:0x0"
          
         bitfld.long 0x00 12. " SGMII_WRAP_REG_SGMII_REG_TOP_DEBUG_TX_BUF_ERR ,transmitter buffer error RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG, None RESET:0x320038"
         bitfld.long 0x00 0. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_UNIDIR_EN ,enable unidirectional mode RESET:0x0"
          
         bitfld.long 0x00 1. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_LOOPBACK ,enable internal loopback RESET:0x0"
          
         bitfld.long 0x00 2. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_POWERDOWN ,enable power down RESET:0x0"
          
         bitfld.long 0x00 3. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_ISOLATE ,isolate GMII RESET:0x1"
          
         bitfld.long 0x00 4. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_MR_AN_ENABLE ,enable Auto-Negotiation RESET:0x1"
          
         bitfld.long 0x00 5. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_FULL_DUPLEX ,enable full duplex operation RESET:0x1"
          
         bitfld.long 0x00 6. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_VALID ,configuration valid trigger RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_MR_SPEED ,advertised link speed RESET:0x0"
          
         bitfld.long 0x00 10. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_MR_FULL_DUPLEX ,advertise full duplex link RESET:0x0"
          
         bitfld.long 0x00 11. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_MR_ACK ,SGMII acknowledge RESET:0x0"
          
         bitfld.long 0x00 12. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_MR_LINK_UP ,advertise link up RESET:0x0"
          
         bitfld.long 0x00 13. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_AN_VALID ,Auto-Negotiation configuration valid trigger RESET:0x0"
          
         bitfld.long 0x00 14. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_AN_RESTART ,restart Auto-Negotiation trigger RESET:0x0"
          
         hexmask.long 0x00 16.--24. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_LINK_TIMER_VALUE ,link timer value RESET:0x32"
          
         bitfld.long 0x00 31. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_CFG_SIGNAL_DETECT ,enable signal detection RESET:0x0"
          
wgroup.long 0x1c++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_STATUS_CAPTURE, None RESET:0x0"
         bitfld.long 0x00 0. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_STATUS_CAPTURE_CAPTURE ,Triggers capture of SGMII status RESET:0x0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_STATUS, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_STATUS_VALUE ,SGMII status RESET:0x0"
          
         bitfld.long 0x00 16. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_STATUS_VALID ,SGMII status valid RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_MDIO_CTRL, None RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_MDIO_CTRL_PHY_ADDR ,PHY ADDR RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_AMS_REG, None RESET:0x60"
         bitfld.long 0x00 0. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_AMS_REG_CALIB_LVDS_OVR_I ,calib_lvds_ovr_i RESET:0x0"
          
         hexmask.long 0x00 1.--4. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_AMS_REG_CALIB_LVDS_VAL_I ,calib_lvds_val_i RESET:0x0"
          
         bitfld.long 0x00 5. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_AMS_REG_SGMII_RTERM_CAPTURE_EN_I ,sgmii_rterm_capture_en_i RESET:0x1"
          
         bitfld.long 0x00 6. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_AMS_REG_SGMII_RTERM_CAPTURE_WTRIG_I ,sgmii_rterm_capture_wtrig_i RESET:0x1"
          
         hexmask.long 0x00 7.--10. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_AMS_REG_SGMII_RTERM_CTRL_CAL_O ,sgmii_rterm_ctrl_cal_o RESET:0x0"
          
         bitfld.long 0x00 11. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_AMS_REG_SGMII_RTERM_CTRL_VALID_O ,sgmii_rterm_ctrl_valid_o RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_SPEED_SELECT, Speed select of SGMII RESET:0x0"
         bitfld.long 0x00 0. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_SPEED_SELECT_SPEEDIS10100 ,1Gbps setting RESET:0x0"
          
         bitfld.long 0x00 1. " SGMII_WRAP_REG_SGMII_REG_TOP_SGMII_SPEED_SELECT_SPEEDIS100 ,100M setting RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1, SGMII TX Pad configuration 1 RESET:0x100000"
         bitfld.long 0x00 0. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_DI_O ,di_o RESET:0x0"
          
         bitfld.long 0x00 1. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_EI_DETECT_EN_I ,ei_detect_en_i RESET:0x0"
          
         bitfld.long 0x00 3. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_RTERM_EN_I ,rterm_en_i RESET:0x0"
          
         bitfld.long 0x00 4. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_RX_EN_I ,rx_en_i RESET:0x0"
          
         bitfld.long 0x00 5. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_RX_POL_I ,rx_pol_i RESET:0x0"
          
         bitfld.long 0x00 6. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_RX_VCM_EN_I ,rx_vcm_en_i RESET:0x0"
          
         hexmask.long 0x00 7.--9. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_RX_GAIN_I ,rx_gain_i RESET:0x0"
          
         hexmask.long 0x00 10.--16. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_RX_CTLE_RES_I ,rx_ctle_res_i RESET:0x0"
          
         hexmask.long 0x00 17.--19. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_RX_CTLE_CAP_I ,rx_ctle_cap_i RESET:0x0"
          
         bitfld.long 0x00 20. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_TX_EN_I ,tx_en_i RESET:0x1"
          
         bitfld.long 0x00 21. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_TX_EI_I ,tx_ei_i RESET:0x0"
          
         bitfld.long 0x00 22. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_TX_FFE_I ,tx_ffe_i RESET:0x0"
          
         bitfld.long 0x00 23. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_TX_POL_I ,tx_pol_i RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_TX_BIAS_I ,tx_bias_i RESET:0x0"
          
         bitfld.long 0x00 28. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_1_TX_BIAS_OD_I ,tx_bias_od_i RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_2, SGMII TX Pad configuration 2 RESET:0x1"
         bitfld.long 0x00 0. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_2_TX_VCM_EN_I ,tx_vcm_en_i RESET:0x1"
          
         hexmask.long 0x00 1.--4. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_TX_SGMII_PADS_2_TX_VCM_I ,tx_vcm_i RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_RX_SGMII_PADS, SGMII RX Pad configuration RESET:0x10"
         bitfld.long 0x00 1. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_RX_SGMII_PADS_EI_DETECT_EN_I ,ei_detect_en_i RESET:0x0"
          
         bitfld.long 0x00 2. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_RX_SGMII_PADS_EI_DETECT_O ,ei_detect_o RESET:0x0"
          
         bitfld.long 0x00 3. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_RX_SGMII_PADS_RTERM_EN_I ,rterm_en_i RESET:0x0"
          
         bitfld.long 0x00 4. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_RX_SGMII_PADS_RX_EN_I ,rx_en_i RESET:0x1"
          
         bitfld.long 0x00 5. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_RX_SGMII_PADS_RX_POL_I ,rx_pol_i RESET:0x0"
          
         bitfld.long 0x00 6. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_RX_SGMII_PADS_RX_VCM_EN_I ,rx_vcm_en_i RESET:0x0"
          
         hexmask.long 0x00 7.--9. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_RX_SGMII_PADS_RX_GAIN_I ,rx_gain_i RESET:0x0"
          
         hexmask.long 0x00 10.--16. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_RX_SGMII_PADS_RX_CTLE_RES_I ,rx_ctle_res_i RESET:0x0"
          
         hexmask.long 0x00 17.--19. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_RX_SGMII_PADS_RX_CTLE_CAP_I ,rx_ctle_cap_i RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_BIAS_SGMII_PADS, SGMII BIAS Pad configuration RESET:0x3"
         bitfld.long 0x00 0. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_BIAS_SGMII_PADS_EN_I ,en_i RESET:0x1"
          
         bitfld.long 0x00 1. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_BIAS_SGMII_PADS_EN_VBIAS_I ,en_vbias_i RESET:0x1"
          
         bitfld.long 0x00 2. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_BIAS_SGMII_PADS_BG_STARTUP_I ,bg_startup_i RESET:0x0"
          
         hexmask.long 0x00 3.--6. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_BIAS_SGMII_PADS_TRIM_BIAS_I ,trim_bias_i RESET:0x0"
          
         hexmask.long 0x00 7.--11. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_BIAS_SGMII_PADS_TRIM_CURV_I ,trim_curv_i RESET:0x0"
          
         hexmask.long 0x00 12.--16. 1. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_BIAS_SGMII_PADS_TRIM_VBG_I ,trim_vbg_i RESET:0x0"
          
         bitfld.long 0x00 17. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_BIAS_SGMII_PADS_BG_VALID_N_O ,bg_valid_n_o RESET:0x0"
          
         bitfld.long 0x00 18. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_BIAS_SGMII_PADS_IBIAS_O ,ibias_o RESET:0x0"
          
         bitfld.long 0x00 19. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_BIAS_SGMII_PADS_VBG_O ,vbg_o RESET:0x0"
          
         bitfld.long 0x00 20. " SGMII_WRAP_REG_SGMII_REG_TOP_CTRL_BIAS_SGMII_PADS_VTMP_O ,vtmp_o RESET:0x0"
          
tree.end

tree "SGMII_WRAP_REG__ADPLL_REGS"
base e:0x40073040
width 80.
group.long  0x0++0x3
    line.long 0x00 "SGMII_WRAP_REG_ADPLL_REGS_CTRL_0, Control register 0 / reset settings for 10MHz input, 60MHz output RESET:0x212bde"
         bitfld.long 0x00 0. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_EN_ADPLL ,Enable the PLL RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 1. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_MAINDIV_N1 ,N1 of ADPLL main loop divider RESET:0x1" "ONE-0,TWO-1"
          
         bitfld.long 0x00 2.--3. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_MAINDIV_N2 ,N2 of ADPLL main loop divider RESET:0x3" "TWO-0,THREE-1,FOUR-2,FIVE-3"
          
         bitfld.long 0x00 4.--5. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_MAINDIV_N3 ,N3 of ADPLL main loop divider RESET:0x1" "TWO-0,THREE-1,FOUR-2,FIVE-3"
          
         bitfld.long 0x00 6.--7. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_MAINDIV_N4 ,N4 of ADPLL main loop divider RESET:0x3" "ONE-0,TWO-1,THREE-2,FOUR-3"
          
         bitfld.long 0x00 8.--9. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_OUTDIV_SEL ,ADPLL output divider RESET:0x3" "NODIV-0,DIV2-1,DIV4-2,DIV8-3"
          
         bitfld.long 0x00 10. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_OPEN_LOOP ,Enable open loop (PLL starts without loop regulation) RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 11.--12. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_DIVCORE_SEL ,Frequency divider setting for core output clock RESET:0x1" "NODIV-0,DIV3-1,DIV5-2,DIV10-3"
          
         bitfld.long 0x00 13. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_AUTO_CT ,Enable for automatic coarse tune RESET:0x1" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 14. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_PFD_SEL ,enable/disable synchronizer for PFD RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 15. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_LOCK_WINDOW_SEL ,Lock Detection Window selection RESET:0x0" "LONG-0,SHORT-1"
          
         bitfld.long 0x00 16. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_DIVCORE_MUX_SEL ,selects the divider chain for clk_core. Only COREDIV or OUTDIV + COREDIV RESET:0x1" "COREDIV-0,COREDIV_OUTDIV-1"
          
         bitfld.long 0x00 17. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_EN_FAST_LOCK ,Enable internal fast lock-in for fine tune value using binary search RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 18. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_ENFORCE_LOCK ,Overwrite locked-bit (Note: locked status can still read on adpll_status_o) RESET:0x0" "UNENFORCED-0,ENFORCED-1"
          
         bitfld.long 0x00 19. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_SET_OP_LOCK ,Force locked bit to 1 in OP mode. This mode bypasses the lock detection RESET:0x0" "UNENFORCED-0,FORCED1-1"
          
         bitfld.long 0x00 20. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_DISABLE_LOCK ,Force locked bit to 0 (Note: locked status can still read on adpll_status_o) RESET:0x0" "UNENFORCED-0,FORCED0-1"
          
         bitfld.long 0x00 21. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_REF_BYPASS ,enable/disable reference clock bypass to ADPLL core clock output RESET:0x1" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 22. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_BIST_MODE ,Set BIST mode or normal PLL usage mode RESET:0x0" "NORMAL-0,BIST-1"
          
         bitfld.long 0x00 23. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_0_CT_COMPENSATION ,Enable automatic increase/decrease of coarsetune value in case of finetune overflow/underflow RESET:0x0" "DISABLED-0,ENABLED-1"
          
group.long  0x4++0x3
    line.long 0x00 "SGMII_WRAP_REG_ADPLL_REGS_CTRL_1, Control register 1 RESET:0x11100604"
         hexmask.long 0x00 0.--4. 1. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_1_CI ,Integral coefficient of loop filter RESET:0x4"
          
         hexmask.long 0x00 5.--12. 1. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_1_CP ,Proportional coefficient of loop filter RESET:0x30"
          
         hexmask.long 0x00 13.--20. 1. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_1_FT ,ADPLL fine-tune value for open-loop mode and for automatic coarse tune RESET:0x80"
          
         hexmask.long 0x00 21.--26. 1. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_1_CT ,Coarse tune value for open loop (CT>=4!) and in the case AUTO_CT = 0 RESET:0x8"
          
         hexmask.long 0x00 27.--28. 1. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_1_FILTER_SHIFT ,Shift filter coefficients CI and CP left by FILTER_SHIFT when not locked RESET:0x2"
          
group.long  0x8++0x3
    line.long 0x00 "SGMII_WRAP_REG_ADPLL_REGS_CTRL_2, Control register 2 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " SGMII_WRAP_REG_ADPLL_REGS_CTRL_2_SAR_LIMIT ,Limit for binary search fast lock-in RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "SGMII_WRAP_REG_ADPLL_REGS_STATUS_CAPTURE, None RESET:0x0"
         bitfld.long 0x00 0. " SGMII_WRAP_REG_ADPLL_REGS_STATUS_CAPTURE_CAPTURE ,Triggers capture of status* registers; This bit is cleared by HW when status is ready RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "SGMII_WRAP_REG_ADPLL_REGS_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " SGMII_WRAP_REG_ADPLL_REGS_STATUS_PLL_LOCKED ,locked bit RESET:0x0"
          
         bitfld.long 0x00 1. " SGMII_WRAP_REG_ADPLL_REGS_STATUS_PLL_FT_OF ,overflow flag for fine tune RESET:0x0"
          
         bitfld.long 0x00 2. " SGMII_WRAP_REG_ADPLL_REGS_STATUS_PLL_FT_UF ,underflow flag for fine tune RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " SGMII_WRAP_REG_ADPLL_REGS_STATUS_PLL_FT ,fine tune Value RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " SGMII_WRAP_REG_ADPLL_REGS_STATUS_PLL_STATE ,ADPLL FSM state RESET:0x0"
          
         hexmask.long 0x00 13.--18. 1. " SGMII_WRAP_REG_ADPLL_REGS_STATUS_PLL_COARSE_TUNE ,coarse tune value RESET:0x0"
          
         bitfld.long 0x00 19. " SGMII_WRAP_REG_ADPLL_REGS_STATUS_PLL_CT_OF ,overflow flag for coarse tune RESET:0x0"
          
         bitfld.long 0x00 20. " SGMII_WRAP_REG_ADPLL_REGS_STATUS_PLL_CT_UF ,underflow flag for coarse tune RESET:0x0"
          
         bitfld.long 0x00 21. " SGMII_WRAP_REG_ADPLL_REGS_STATUS_BIST_BUSY ,1:BIST is still running; 0:BIST finished RESET:0x0"
          
         bitfld.long 0x00 22. " SGMII_WRAP_REG_ADPLL_REGS_STATUS_BIST_FAIL_COARSE ,1:BIST fail for coarsetune (monotony error or BIST was not correct started); 0:BIST pass RESET:0x0"
          
         bitfld.long 0x00 23. " SGMII_WRAP_REG_ADPLL_REGS_STATUS_BIST_FAIL_FINE ,1:BIST fail for finetune (monotony error or BIST was not correct started); 0:BIST pass RESET:0x0"
          
tree.end

tree "SGMII_WRAP_REG__FBIST"
base e:0x40073060
width 80.
group.long  0x0++0x3
    line.long 0x00 "SGMII_WRAP_REG_FBIST_CTRL, FBIST Control Register RESET:0x0"
         bitfld.long 0x00 0. " SGMII_WRAP_REG_FBIST_CTRL_BIST_EN ,Enable Frequency BIST RESET:0x0" "DISABLED-0,ENABLED-1"
          
group.long  0x4++0x3
    line.long 0x00 "SGMII_WRAP_REG_FBIST_CFG, FBIST Configuration Register RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " SGMII_WRAP_REG_FBIST_CFG_COUNTER_CHECK_VALUE ,Expected counter result RESET:0x0"
          
         hexmask.long 0x00 20.--23. 1. " SGMII_WRAP_REG_FBIST_CFG_COUNTER_CHECK_RANGE ,Tolerance range for result comparison RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " SGMII_WRAP_REG_FBIST_CFG_SOURCE_SELECT ,Select clock or meaurement RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "SGMII_WRAP_REG_FBIST_CFG_PRESCALER, FBIST Configuration Register Prescaler RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " SGMII_WRAP_REG_FBIST_CFG_PRESCALER_PS ,Reference clock pre-scaling (2^prescaler+2) RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "SGMII_WRAP_REG_FBIST_STATUS, FBIST Status Register RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " SGMII_WRAP_REG_FBIST_STATUS_COUNTER_RESULT ,Counter result RESET:0x0"
          
         bitfld.long 0x00 20. " SGMII_WRAP_REG_FBIST_STATUS_DONE ,FBIST done RESET:0x0"
          
         bitfld.long 0x00 21. " SGMII_WRAP_REG_FBIST_STATUS_PASS ,FBIST result RESET:0x0"
          
tree.end

tree "ETH_PHY1"
base e:0x40078000
width 80.
tree.end

tree "ETH_PHY1__IEEE_PMA_PMD"
base e:0x40078000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_CONTROL_1, None RESET:0x2000"
         bitfld.long 0x00 0. " ETH_PHY1_IEEE_PMA_PMD_CONTROL_1_PMA_LOCAL_LOOPBACK ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_IEEE_PMA_PMD_CONTROL_1_PMA_REMOTE_LOOPBACK ,None RESET:0x0" "FALSE-0"
          
         hexmask.long 0x00 2.--5. 1. " ETH_PHY1_IEEE_PMA_PMD_CONTROL_1_SPEED_SELECTION ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ETH_PHY1_IEEE_PMA_PMD_CONTROL_1_SPEED_SELECTION_MSB ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 11. " ETH_PHY1_IEEE_PMA_PMD_CONTROL_1_LOW_POWER ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_PMA_PMD_CONTROL_1_SPEED_SELECTION_LSB ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 15. " ETH_PHY1_IEEE_PMA_PMD_CONTROL_1_RESET ,None RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_STATUS_1, None RESET:0x2"
         bitfld.long 0x00 1. " ETH_PHY1_IEEE_PMA_PMD_STATUS_1_LOW_POWER_ABILITY ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 2. " ETH_PHY1_IEEE_PMA_PMD_STATUS_1_RECEIVE_LINK_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY1_IEEE_PMA_PMD_STATUS_1_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_IEEE_PMA_PMD_STATUS_1_PEASA ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 9. " ETH_PHY1_IEEE_PMA_PMD_STATUS_1_PIASA ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_DEVICE_IDENTIFIER_1, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_IEEE_PMA_PMD_DEVICE_IDENTIFIER_1_OUI ,None RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_DEVICE_IDENTIFIER_2, None RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY1_IEEE_PMA_PMD_DEVICE_IDENTIFIER_2_REVISION ,None RESET:0x0"
          
         hexmask.long 0x00 4.--9. 1. " ETH_PHY1_IEEE_PMA_PMD_DEVICE_IDENTIFIER_2_MODEL ,None RESET:0x0"
          
         hexmask.long 0x00 10.--15. 1. " ETH_PHY1_IEEE_PMA_PMD_DEVICE_IDENTIFIER_2_OUI ,None RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_SPEED_ABILITY, None RESET:0x20"
         bitfld.long 0x00 0. " ETH_PHY1_IEEE_PMA_PMD_SPEED_ABILITY_E10G_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 1. " ETH_PHY1_IEEE_PMA_PMD_SPEED_ABILITY_E2BASE_TL_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 2. " ETH_PHY1_IEEE_PMA_PMD_SPEED_ABILITY_E10PASS_TS_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 4. " ETH_PHY1_IEEE_PMA_PMD_SPEED_ABILITY_E1000M_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY1_IEEE_PMA_PMD_SPEED_ABILITY_E100M_CAPABLE ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 6. " ETH_PHY1_IEEE_PMA_PMD_SPEED_ABILITY_E10M_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY1_IEEE_PMA_PMD_SPEED_ABILITY_E10_1G_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 8. " ETH_PHY1_IEEE_PMA_PMD_SPEED_ABILITY_E40G_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 9. " ETH_PHY1_IEEE_PMA_PMD_SPEED_ABILITY_E100G_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 10. " ETH_PHY1_IEEE_PMA_PMD_SPEED_ABILITY_E10GPASS_XR_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 11. " ETH_PHY1_IEEE_PMA_PMD_SPEED_ABILITY_E25G_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_PMA_PMD_SPEED_ABILITY_E2D5G_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 15. " ETH_PHY1_IEEE_PMA_PMD_SPEED_ABILITY_E400G_CAPABLE ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1, None RESET:0x8a"
         bitfld.long 0x00 0. " ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_CLAUSE_22_REGISTERS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 1. " ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_PMD_PMA_PRESENT ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 2. " ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_WIS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 3. " ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_PCS_PRESENT ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 4. " ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_PHY_XS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_DTE_XS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 6. " ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_TC_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_AUTO_NEGOTIATION_PRESENT ,None RESET:0x1" "TRUE-1"
          
         hexmask.long 0x00 8.--11. 1. " ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_SEPARATED_PMA_PRESENT ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_OFDM ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_POWER_UNIT_PRESENT ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_2, None RESET:0x0"
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_2_CLAUSE_22_EXTENSION_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 14. " ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_2_VENDOR_SPECIFIC_DEVICE_1_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 15. " ETH_PHY1_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_2_VENDOR_SPECIFIC_DEVICE_2_PRESENT ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_CONTROL_2, None RESET:0x3d"
         hexmask.long 0x00 0.--6. 1. " ETH_PHY1_IEEE_PMA_PMD_CONTROL_2_PMA_PMD_TYPE_SELECTION ,None RESET:0x3d"
          
         bitfld.long 0x00 8. " ETH_PHY1_IEEE_PMA_PMD_CONTROL_2_PEASE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 9. " ETH_PHY1_IEEE_PMA_PMD_CONTROL_2_PIASE ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_STATUS_2, None RESET:0x9201"
         bitfld.long 0x00 0. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_PMA_LOCAL_LOOPBACK_ABILITY ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 1. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_E10GBASE_EW_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 2. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_E10GBASE_LW_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 3. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_E10GBASE_SW_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 4. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_E10GBASE_LX4_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_E10GBASE_ER_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 6. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_E10GBASE_LR_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_E10GBASE_SR_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 8. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_PMD_TRANSMIT_DISABLE_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 9. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_EXTENDED_ABILITIES ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 10. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_RECEIVE_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_TRANSMIT_FAULT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 12. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_RECEIVE_FAULT_ABILITY ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_TRANSMIT_FAULT_ABILITY ,None RESET:0x0" "FALSE-0"
          
         hexmask.long 0x00 14.--15. 1. " ETH_PHY1_IEEE_PMA_PMD_STATUS_2_DEVICE_PRESENT ,None RESET:0x2"
          
rgroup.long 0x28++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_PMD_RECEIVE_SIGNAL_DETECT, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_IEEE_PMA_PMD_PMD_RECEIVE_SIGNAL_DETECT_GLOBAL_PMD_RECEIVE_SIGNAL_DETECT ,None RESET:0x0"
          
         hexmask.long 0x00 1.--15. 1. " ETH_PHY1_IEEE_PMA_PMD_PMD_RECEIVE_SIGNAL_DETECT_PMD_RECEIVE_SIGNAL_DETECT ,None RESET:0x0"
          
rgroup.long 0x2c++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY, None RESET:0x800"
         bitfld.long 0x00 0. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_E10GBASE_CX4_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 1. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_E10GBASE_LRM_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 2. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_E10GBASE_T_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 3. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_E10GBASE_KX4_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 4. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_E10GBASE_KR_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_E1000BASE_T_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 6. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_E1000BASE_KX_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_E100BASE_TX_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 8. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_E10BASE_T_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 9. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_P2MP_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 10. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_E40G_100G_EXTENDED_ABILITIES ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 11. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_BASE_T1_EXTENDED_ABILITIES ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 12. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_E25G_EXTENDED_ABILITIES ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_E200G_400G_EXTENDED_ABILITIES ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 14. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_E2D5G_5G_EXTENDED_ABILITIES ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 15. " ETH_PHY1_IEEE_PMA_PMD_EXTENDED_ABILITY_BASE_H_EXTENDED_ABILITIES ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x38++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_PACKAGE_IDENTIFIER_1, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_IEEE_PMA_PMD_PACKAGE_IDENTIFIER_1_OUI ,None RESET:0x0"
          
rgroup.long 0x3c++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_PACKAGE_IDENTIFIER_2, None RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY1_IEEE_PMA_PMD_PACKAGE_IDENTIFIER_2_REVISION ,None RESET:0x0"
          
         hexmask.long 0x00 4.--9. 1. " ETH_PHY1_IEEE_PMA_PMD_PACKAGE_IDENTIFIER_2_MODEL ,None RESET:0x0"
          
         hexmask.long 0x00 10.--15. 1. " ETH_PHY1_IEEE_PMA_PMD_PACKAGE_IDENTIFIER_2_OUI ,None RESET:0x0"
          
rgroup.long 0x48++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY, None RESET:0x1"
         bitfld.long 0x00 0. " ETH_PHY1_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY_E100BASE_T1_ABILITY ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 1. " ETH_PHY1_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY_E1000BASE_T1_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 2. " ETH_PHY1_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY_E10BASE_T1L_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 3. " ETH_PHY1_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY_E10BASE_T1S_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 4. " ETH_PHY1_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY_E2D5GBASE_T1_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY1_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY_E5GBASE_T1_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 6. " ETH_PHY1_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY_E10GBASE_T1_ABILITY ,None RESET:0x0" "FALSE-0"
          
group.long  0x8d0++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_BASE_T1_PMA_PMD_CONTROL, None RESET:0x8000"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY1_IEEE_PMA_PMD_BASE_T1_PMA_PMD_CONTROL_TYPE_SELECTION ,None RESET:0x0"
          
         bitfld.long 0x00 14. " ETH_PHY1_IEEE_PMA_PMD_BASE_T1_PMA_PMD_CONTROL_MASTER_SLAVE_CONFIG_VALUE ,None RESET:0x0"
          
          
group.long  0x8d8++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PMA_PMD_E100BASE_T1_PMA_PMD_TEST_CONTROL, None RESET:0x0"
         hexmask.long 0x00 13.--15. 1. " ETH_PHY1_IEEE_PMA_PMD_E100BASE_T1_PMA_PMD_TEST_CONTROL_MODE ,None RESET:0x0"
          
tree.end

tree "ETH_PHY1__ECMT1_PMD"
base e:0x40079000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_LDRV_ENFORCE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_ECMT1_PMD_LDRV_ENFORCE_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_ECMT1_PMD_LDRV_ENFORCE_ZERO_SYMBOL ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_ECMT1_PMD_LDRV_ENFORCE_HYB_OFF ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_ECMT1_PMD_LDRV_ENFORCE_HYB_ON ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY1_ECMT1_PMD_LDRV_ENFORCE_SET_MAN_RES ,None RESET:0x0"
          
         hexmask.long 0x00 5.--12. 1. " ETH_PHY1_ECMT1_PMD_LDRV_ENFORCE_MAN_RES ,None RESET:0x0"
          
         hexmask.long 0x00 13.--20. 1. " ETH_PHY1_ECMT1_PMD_LDRV_ENFORCE_MAN_RES_REP ,None RESET:0x0"
          
         bitfld.long 0x00 21. " ETH_PHY1_ECMT1_PMD_LDRV_ENFORCE_SET_CH1_NCH2 ,None RESET:0x0"
          
         bitfld.long 0x00 23. " ETH_PHY1_ECMT1_PMD_LDRV_ENFORCE_SET_MAN_RES_REP ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_LDRV_MAN_0, None RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY1_ECMT1_PMD_LDRV_MAN_0_POS ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_LDRV_MAN_1, None RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY1_ECMT1_PMD_LDRV_MAN_1_NEG ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_LDRV_CAL_CONFIG, None RESET:0x644f8"
         bitfld.long 0x00 0. " ETH_PHY1_ECMT1_PMD_LDRV_CAL_CONFIG_RESET_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_ECMT1_PMD_LDRV_CAL_CONFIG_ENABLE_CONFIG ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_ECMT1_PMD_LDRV_CAL_CONFIG_INV_CMP ,None RESET:0x0"
          
         hexmask.long 0x00 3.--4. 1. " ETH_PHY1_ECMT1_PMD_LDRV_CAL_CONFIG_WINDOW_SIZE ,None RESET:0x3"
          
         hexmask.long 0x00 5.--8. 1. " ETH_PHY1_ECMT1_PMD_LDRV_CAL_CONFIG_NR_CMP_SETTLE ,None RESET:0x7"
          
         hexmask.long 0x00 9.--12. 1. " ETH_PHY1_ECMT1_PMD_LDRV_CAL_CONFIG_INCREMENT ,None RESET:0x2"
          
         hexmask.long 0x00 13.--19. 1. " ETH_PHY1_ECMT1_PMD_LDRV_CAL_CONFIG_START_VALUE_RES ,None RESET:0x32"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_CM_CLAMP_CONFIG, None RESET:0x7"
         bitfld.long 0x00 0. " ETH_PHY1_ECMT1_PMD_CM_CLAMP_CONFIG_ENABLE ,None RESET:0x1"
          
         hexmask.long 0x00 1.--3. 1. " ETH_PHY1_ECMT1_PMD_CM_CLAMP_CONFIG_CNT ,None RESET:0x3"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY1_ECMT1_PMD_CM_CLAMP_CONFIG_ENABLE_OVR ,None RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY1_ECMT1_PMD_CM_CLAMP_CONFIG_DISABLE_OVR ,None RESET:0x0"
          
         bitfld.long 0x00 30. " ETH_PHY1_ECMT1_PMD_CM_CLAMP_CONFIG_REF_CM_POL ,None RESET:0x0"
          
         bitfld.long 0x00 31. " ETH_PHY1_ECMT1_PMD_CM_CLAMP_CONFIG_REF_CM_SET ,None RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_CM_CLAMP_ADAPT_CONFIG, None RESET:0x9e"
         bitfld.long 0x00 0. " ETH_PHY1_ECMT1_PMD_CM_CLAMP_ADAPT_CONFIG_ENABLE ,None RESET:0x0"
          
         hexmask.long 0x00 1.--5. 1. " ETH_PHY1_ECMT1_PMD_CM_CLAMP_ADAPT_CONFIG_WAIT_OUT_CYCLES ,None RESET:0xf"
          
         hexmask.long 0x00 6.--8. 1. " ETH_PHY1_ECMT1_PMD_CM_CLAMP_ADAPT_CONFIG_RST_CF_CYCLES ,None RESET:0x2"
          
         bitfld.long 0x00 9. " ETH_PHY1_ECMT1_PMD_CM_CLAMP_ADAPT_CONFIG_RST_MAX_ADAPT_CNT ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY1_ECMT1_PMD_CM_CLAMP_ADAPT_CONFIG_DEBUG ,None RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_CM_CLAMP_STATUS, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY1_ECMT1_PMD_CM_CLAMP_STATUS_CLIPPING_FLAGS ,None RESET:0x0"
          
         hexmask.long 0x00 8.--10. 1. " ETH_PHY1_ECMT1_PMD_CM_CLAMP_STATUS_ACT_ADAPT_SCLICE_CNT ,None RESET:0x0"
          
         hexmask.long 0x00 11.--13. 1. " ETH_PHY1_ECMT1_PMD_CM_CLAMP_STATUS_MAX_ADAPT_SCLICE_CNT ,None RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_LDRV_TIMER, None RESET:0xa"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY1_ECMT1_PMD_LDRV_TIMER_ADJ_TIMER_CM_STARTUP ,None RESET:0xa"
          
group.long  0x20++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_LDRV_MUX, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_ECMT1_PMD_LDRV_MUX_TCLK_FWD_SEL ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_ECMT1_PMD_LDRV_MUX_TCLK_SEL ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ETH_PHY1_ECMT1_PMD_LDRV_MUX_MAN_SEL ,None RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_LDRV_RESCAL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_ECMT1_PMD_LDRV_RESCAL_READY ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_ECMT1_PMD_LDRV_RESCAL_TIMEOUT ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_ECMT1_PMD_LDRV_RESCAL_IDLE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_ECMT1_PMD_LDRV_RESCAL_SINGLE ,None RESET:0x0"
          
         hexmask.long 0x00 15.--25. 1. " ETH_PHY1_ECMT1_PMD_LDRV_RESCAL_VALUE ,None RESET:0x0"
          
         bitfld.long 0x00 26. " ETH_PHY1_ECMT1_PMD_LDRV_RESCAL_LDRV_CH1_OVERFLOW ,None RESET:0x0"
          
         bitfld.long 0x00 27. " ETH_PHY1_ECMT1_PMD_LDRV_RESCAL_LDRV_CH2_OVERFLOW ,None RESET:0x0"
          
         bitfld.long 0x00 28. " ETH_PHY1_ECMT1_PMD_LDRV_RESCAL_LDRV_CH1_UNDERFLOW ,None RESET:0x0"
          
         bitfld.long 0x00 29. " ETH_PHY1_ECMT1_PMD_LDRV_RESCAL_LDRV_CH2_UNDERFLOW ,None RESET:0x0"
          
         bitfld.long 0x00 30. " ETH_PHY1_ECMT1_PMD_LDRV_RESCAL_LDRV_CMP_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 31. " ETH_PHY1_ECMT1_PMD_LDRV_RESCAL_LDRV_RES_LOW_FLAG ,None RESET:0x0"
          
rgroup.long 0x28++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_LDRV_CAL_CH1_CH2, None RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " ETH_PHY1_ECMT1_PMD_LDRV_CAL_CH1_CH2_AVG_N_RES_CH1 ,None RESET:0x0"
          
         hexmask.long 0x00 16.--26. 1. " ETH_PHY1_ECMT1_PMD_LDRV_CAL_CH1_CH2_AVG_N_RES_CH2 ,None RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_ANA_TESTMUX, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_ECMT1_PMD_ANA_TESTMUX_EN ,None RESET:0x0"
          
         hexmask.long 0x00 1.--4. 1. " ETH_PHY1_ECMT1_PMD_ANA_TESTMUX_SEL ,None RESET:0x0"
          
rgroup.long 0x30++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_ESD_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_ECMT1_PMD_ESD_STATUS_EVH_P_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_ECMT1_PMD_ESD_STATUS_EVL_P_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_ECMT1_PMD_ESD_STATUS_EVH_N_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_ECMT1_PMD_ESD_STATUS_EVL_N_STATUS ,None RESET:0x0"
          
rgroup.long 0x34++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_ESD_EVENT, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_ECMT1_PMD_ESD_EVENT_COUNT ,None RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_ESD_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_ECMT1_PMD_ESD_CONTROL_ESD_COUNT_CLR ,None RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "ETH_PHY1_ECMT1_PMD_CABLE_DIAG_CONFIG, None RESET:0x20303"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY1_ECMT1_PMD_CABLE_DIAG_CONFIG_PULSE_WIDTH ,None RESET:0x3"
          
         hexmask.long 0x00 4.--13. 1. " ETH_PHY1_ECMT1_PMD_CABLE_DIAG_CONFIG_DETECTION_THRESHOLD ,None RESET:0x30"
          
         hexmask.long 0x00 14.--18. 1. " ETH_PHY1_ECMT1_PMD_CABLE_DIAG_CONFIG_PRETEST_THRESHOLD ,None RESET:0x8"
          
tree.end

tree "ETH_PHY1__E100T1_PMD"
base e:0x40079080
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_0, None RESET:0x20022804"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_0_CI ,None RESET:0x4"
          
         hexmask.long 0x00 5.--12. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_0_CP ,None RESET:0x40"
          
         bitfld.long 0x00 13. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_0_MAIN_DIV_N1 ,None RESET:0x1"
          
         hexmask.long 0x00 14.--15. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_0_MAIN_DIV_N2 ,None RESET:0x0"
          
         hexmask.long 0x00 16.--17. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_0_MAIN_DIV_N3 ,None RESET:0x2"
          
         hexmask.long 0x00 18.--19. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_0_MAIN_DIV_N4 ,None RESET:0x0"
          
         hexmask.long 0x00 20.--21. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_0_OUTDIV ,None RESET:0x0"
          
         hexmask.long 0x00 22.--29. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_0_FT ,None RESET:0x80"
          
         bitfld.long 0x00 30. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_0_EN_CTRL ,None RESET:0x0"
          
         bitfld.long 0x00 31. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_0_EN_OVR ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1, None RESET:0x4120"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_DIVCORE ,None RESET:0x0"
          
         hexmask.long 0x00 2.--7. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_CT ,None RESET:0x8"
          
         bitfld.long 0x00 8. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_AUTO_CT ,None RESET:0x1"
          
         bitfld.long 0x00 9. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_ENFORCE_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_PFD_SELECT ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_LOCK_WINDOW ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_DIVCORE_SEL ,None RESET:0x0"
          
         hexmask.long 0x00 13.--14. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_FILTER_SHIFT ,None RESET:0x2"
          
         bitfld.long 0x00 15. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_FAST_LOCK ,None RESET:0x0"
          
         hexmask.long 0x00 16.--18. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_SAR_LIMIT ,None RESET:0x0"
          
         bitfld.long 0x00 19. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_SET_OP_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 20. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_DISABLE_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 21. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_REF_BYPASS ,None RESET:0x0"
          
         bitfld.long 0x00 22. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_BIST_MODE ,None RESET:0x0"
          
         bitfld.long 0x00 23. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_CT_COMPENSATION ,None RESET:0x0"
          
         bitfld.long 0x00 24. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_OPEN_LOOP ,None RESET:0x0"
          
         bitfld.long 0x00 25. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_CFG_1_LDO_EN_OVR ,None RESET:0x0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_ADPLL_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_STATUS_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_STATUS_FT_OF ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_STATUS_FT_UF ,None RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_STATUS_FT ,None RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_STATUS_STATE ,None RESET:0x0"
          
         hexmask.long 0x00 13.--18. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_STATUS_COARSETUNE ,None RESET:0x0"
          
         bitfld.long 0x00 19. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_STATUS_CT_OF ,None RESET:0x0"
          
         bitfld.long 0x00 20. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_STATUS_CT_UF ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_ADPLL_STATUS_CAPTURE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_STATUS_CAPTURE_REQ ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_ADPLL_STARTUP, None RESET:0x29"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_STARTUP_ADJ_TIMER_EN_BANDGAP ,None RESET:0x1"
          
         hexmask.long 0x00 2.--3. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_STARTUP_ADJ_TIMER_EN_PLLLDO ,None RESET:0x2"
          
         hexmask.long 0x00 4.--5. 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_STARTUP_ADJ_TIMER_EN_PLL ,None RESET:0x2"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_ADPLL_BIST_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_BIST_STATUS_BUSY ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_BIST_STATUS_FAIL_COARSE ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_E100T1_PMD_E100M_ADPLL_BIST_STATUS_FAIL_FINE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_PI_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMD_E100M_PI_CONTROL_PI_RESET_SW ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_E100T1_PMD_E100M_PI_CONTROL_PI_RESET_OVR ,None RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_FBIST_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMD_E100M_FBIST_CONTROL_EN ,None RESET:0x0"
          
         hexmask.long 0x00 1.--3. 1. " ETH_PHY1_E100T1_PMD_E100M_FBIST_CONTROL_SRC_SEL ,None RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " ETH_PHY1_E100T1_PMD_E100M_FBIST_CONTROL_PRESCALER ,None RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " ETH_PHY1_E100T1_PMD_E100M_FBIST_CONTROL_COUNTER_CHECK_RANGE ,None RESET:0x0"
          
         hexmask.long 0x00 12.--28. 1. " ETH_PHY1_E100T1_PMD_E100M_FBIST_CONTROL_COUNTER_CHECK_VALUE ,None RESET:0x0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_FBIST_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMD_E100M_FBIST_STATUS_PASSED ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_E100T1_PMD_E100M_FBIST_STATUS_COUNTER_DONE ,None RESET:0x0"
          
         hexmask.long 0x00 2.--18. 1. " ETH_PHY1_E100T1_PMD_E100M_FBIST_STATUS_COUNTER_RESULT ,None RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_ADC_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMD_E100M_ADC_CONTROL_AMPLIFIER_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_E100T1_PMD_E100M_ADC_CONTROL_ADC_ENABLE ,None RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_ADC_CALIBRATION, None RESET:0x3c00"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMD_E100M_ADC_CALIBRATION_OFFSET_CORRECTION_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_E100T1_PMD_E100M_ADC_CALIBRATION_OFFSET_CORRECTION_OVERWRITE ,None RESET:0x0"
          
         hexmask.long 0x00 2.--7. 1. " ETH_PHY1_E100T1_PMD_E100M_ADC_CALIBRATION_OFFSET_CORRECTION_OVERWRITE_VALUES ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_E100T1_PMD_E100M_ADC_CALIBRATION_BWT_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY1_E100T1_PMD_E100M_ADC_CALIBRATION_BWT_OVERWRITE ,None RESET:0x0"
          
         hexmask.long 0x00 10.--14. 1. " ETH_PHY1_E100T1_PMD_E100M_ADC_CALIBRATION_BWT_OVERWRITE_VALUES ,None RESET:0xf"
          
rgroup.long 0x2c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_ADC_STATUS, None RESET:0x0"
         hexmask.long 0x00 1.--6. 1. " ETH_PHY1_E100T1_PMD_E100M_ADC_STATUS_OFFSET_CORRECTION_RESULTS ,None RESET:0x0"
          
         hexmask.long 0x00 7.--9. 1. " ETH_PHY1_E100T1_PMD_E100M_ADC_STATUS_OFFSET_CORRECTION_STATUS ,None RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY1_E100T1_PMD_E100M_ADC_STATUS_BWT_RESULT ,None RESET:0x0"
          
         bitfld.long 0x00 24. " ETH_PHY1_E100T1_PMD_E100M_ADC_STATUS_BWT_RDY ,None RESET:0x0"
          
         bitfld.long 0x00 25. " ETH_PHY1_E100T1_PMD_E100M_ADC_STATUS_BWT_OF ,None RESET:0x0"
          
         bitfld.long 0x00 26. " ETH_PHY1_E100T1_PMD_E100M_ADC_STATUS_BWT_UF ,None RESET:0x0"
          
         bitfld.long 0x00 27. " ETH_PHY1_E100T1_PMD_E100M_ADC_STATUS_BWT_BIST ,None RESET:0x0"
          
rgroup.long 0x30++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_ADC_OUTPUT, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY1_E100T1_PMD_E100M_ADC_OUTPUT_CONVERSION_RESULT ,None RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_ADC_STARTUP, None RESET:0x55"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY1_E100T1_PMD_E100M_ADC_STARTUP_ADJ_TIMER_EN_VDDA08 ,None RESET:0x1"
          
         hexmask.long 0x00 2.--3. 1. " ETH_PHY1_E100T1_PMD_E100M_ADC_STARTUP_ADJ_TIMER_EN_REFBUF ,None RESET:0x1"
          
         hexmask.long 0x00 4.--5. 1. " ETH_PHY1_E100T1_PMD_E100M_ADC_STARTUP_ADJ_TIMER_EN_BWT_TOUT ,None RESET:0x1"
          
         hexmask.long 0x00 6.--7. 1. " ETH_PHY1_E100T1_PMD_E100M_ADC_STARTUP_ADJ_TIMER_AMP_ENABLE ,None RESET:0x1"
          
group.long  0x38++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_ADC_POWER_SUPPLY, None RESET:0xf0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMD_E100M_ADC_POWER_SUPPLY_BAND_GAP_ENFORCE_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_E100T1_PMD_E100M_ADC_POWER_SUPPLY_REF_BUFFER_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_E100T1_PMD_E100M_ADC_POWER_SUPPLY_VDDA_ENABLE ,None RESET:0x0"
          
         hexmask.long 0x00 4.--8. 1. " ETH_PHY1_E100T1_PMD_E100M_ADC_POWER_SUPPLY_TRIMM_REFERENCE ,None RESET:0xf"
          
         hexmask.long 0x00 16.--17. 1. " ETH_PHY1_E100T1_PMD_E100M_ADC_POWER_SUPPLY_TEST_MUX_SEL ,None RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_TCLK_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMD_E100M_TCLK_CONTROL_CORE_EN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_E100T1_PMD_E100M_TCLK_CONTROL_FWD_EN_DOWN ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_E100T1_PMD_E100M_TCLK_CONTROL_FWD_EN_UP ,None RESET:0x0"
          
rgroup.long 0x40++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_PMD_CTRL_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMD_E100M_PMD_CTRL_STATUS_ADPLL_EN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_E100T1_PMD_E100M_PMD_CTRL_STATUS_ADPLL_LDO_EN ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_E100T1_PMD_E100M_PMD_CTRL_STATUS_LDRV_HYB_ON ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_E100T1_PMD_E100M_PMD_CTRL_STATUS_LDRV_FORCE_CM ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY1_E100T1_PMD_E100M_PMD_CTRL_STATUS_LDRV_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ETH_PHY1_E100T1_PMD_E100M_PMD_CTRL_STATUS_LDRV_CAL_START ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ETH_PHY1_E100T1_PMD_E100M_PMD_CTRL_STATUS_ADC_AMP_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY1_E100T1_PMD_E100M_PMD_CTRL_STATUS_ADC_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_E100T1_PMD_E100M_PMD_CTRL_STATUS_ADC_EN_VDDA08 ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY1_E100T1_PMD_E100M_PMD_CTRL_STATUS_ADC_EN_REFBUF ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY1_E100T1_PMD_E100M_PMD_CTRL_STATUS_ADC_EN_BG ,None RESET:0x0"
          
rgroup.long 0x44++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_PMD_FAIL_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMD_E100M_PMD_FAIL_STATUS_ADPLL_FAILED ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_E100T1_PMD_E100M_PMD_FAIL_STATUS_ADC_FAILED ,None RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_PMD_FAIL_CONTROL, None RESET:0x1"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMD_E100M_PMD_FAIL_CONTROL_FAIL_CONFIG ,None RESET:0x1"
          
rgroup.long 0x4c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_PI_TEST, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY1_E100T1_PMD_E100M_PI_TEST_SEL_PHASEA ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_E100T1_PMD_E100M_PI_TEST_SEL_PHASEA_PRE ,None RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " ETH_PHY1_E100T1_PMD_E100M_PI_TEST_SEL_WEIGHTA ,None RESET:0x0"
          
         hexmask.long 0x00 16.--17. 1. " ETH_PHY1_E100T1_PMD_E100M_PI_TEST_SEL_PHASEB ,None RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " ETH_PHY1_E100T1_PMD_E100M_PI_TEST_SEL_WEIGHTB ,None RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_LDRV_SET_MUX_0, None RESET:0xa42129"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY1_E100T1_PMD_E100M_LDRV_SET_MUX_0_VALUE ,None RESET:0xa42129"
          
group.long  0x64++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_LDRV_SET_MUX_1, None RESET:0x6b39d4"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY1_E100T1_PMD_E100M_LDRV_SET_MUX_1_VALUE ,None RESET:0x6b39d4"
          
group.long  0x68++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_LDRV_SET_MUX_4, None RESET:0x4a021"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY1_E100T1_PMD_E100M_LDRV_SET_MUX_4_VALUE ,None RESET:0x4a021"
          
group.long  0x6c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_LDRV_CODE_SELECT_0, None RESET:0x451440"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY1_E100T1_PMD_E100M_LDRV_CODE_SELECT_0_VALUE ,None RESET:0x451440"
          
group.long  0x70++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_LDRV_SET_MUX_2, None RESET:0x4a5619"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY1_E100T1_PMD_E100M_LDRV_SET_MUX_2_VALUE ,None RESET:0x4a5619"
          
group.long  0x74++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_LDRV_CODE_SELECT_1, None RESET:0x451011"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY1_E100T1_PMD_E100M_LDRV_CODE_SELECT_1_VALUE ,None RESET:0x451011"
          
group.long  0x78++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_LDRV_SET_MUX_3, None RESET:0xbdc46b"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY1_E100T1_PMD_E100M_LDRV_SET_MUX_3_VALUE ,None RESET:0xbdc46b"
          
group.long  0x7c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMD_E100M_LDRV_CODE_SELECT_2, None RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY1_E100T1_PMD_E100M_LDRV_CODE_SELECT_2_VALUE ,None RESET:0x0"
          
tree.end

tree "ETH_PHY1__E100T1_PMA"
base e:0x40079200
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMA_E100M_STATUS_ADFE_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_E100T1_PMA_E100M_STATUS_TR_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_E100T1_PMA_E100M_STATUS_LOC_RCVR_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY1_E100T1_PMA_E100M_STATUS_REM_RCVR_STATUS_OK ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY1_E100T1_PMA_E100M_STATUS_LINK_STATUS ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_CTRL, None RESET:0x100"
         bitfld.long 0x00 8. " ETH_PHY1_E100T1_PMA_E100M_CTRL_PHY_LOOPBACK ,None RESET:0x1"
          
group.long  0x8++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL, None RESET:0x2ba3"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL_PMA_DFE_MSE_ADAPT ,None RESET:0x1"
          
         bitfld.long 0x00 1. " ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL_PMA_EC_MSE_ADAPT ,None RESET:0x1"
          
         bitfld.long 0x00 2. " ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL_PMA_SCR_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL_PMA_LINK_RECOVER ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL_PMA_ADAPT_MMM ,None RESET:0x1"
          
         bitfld.long 0x00 6. " ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL_PMA_EC_EARLY_ADAPT ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL_PMA_DFE_ADAPT ,None RESET:0x1"
          
         bitfld.long 0x00 8. " ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL_PMA_DFETAP_CAPTURE ,None RESET:0x1"
          
         hexmask.long 0x00 9.--10. 1. " ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL_PMA_TR_EDALGORITHM_SEL ,None RESET:0x1"
          
         bitfld.long 0x00 11. " ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL_PMA_TR_MODE ,None RESET:0x1"
          
         bitfld.long 0x00 12. " ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL_PMA_DFE_EARLY_ADAPT ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL_PMA_BLD_ADAPT ,None RESET:0x1"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_PHY_CTRL, None RESET:0x900"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMA_E100M_PHY_CTRL_PHY_ADC_INVERT ,None RESET:0x0"
          
         hexmask.long 0x00 3.--12. 1. " ETH_PHY1_E100T1_PMA_E100M_PHY_CTRL_PHY_MAXWAIT_TIMER ,None RESET:0x120"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_LDRV_INV_OUTPUT, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMA_E100M_LDRV_INV_OUTPUT_VALUE ,None RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_LDRV_IF_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMA_E100M_LDRV_IF_STATUS_RD_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_E100T1_PMA_E100M_LDRV_IF_STATUS_WR_ERROR ,None RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_PMA_TIMEOUT, None RESET:0x4444444"
         hexmask.long 0x00 0.--2. 1. " ETH_PHY1_E100T1_PMA_E100M_PMA_TIMEOUT_SCR_LOCK ,None RESET:0x4"
          
         hexmask.long 0x00 4.--6. 1. " ETH_PHY1_E100T1_PMA_E100M_PMA_TIMEOUT_TR_MMM_ADAPT ,None RESET:0x4"
          
         hexmask.long 0x00 8.--10. 1. " ETH_PHY1_E100T1_PMA_E100M_PMA_TIMEOUT_TR_DFE_ADAPT ,None RESET:0x4"
          
         hexmask.long 0x00 12.--14. 1. " ETH_PHY1_E100T1_PMA_E100M_PMA_TIMEOUT_LMS_ADAPT ,None RESET:0x4"
          
         hexmask.long 0x00 16.--18. 1. " ETH_PHY1_E100T1_PMA_E100M_PMA_TIMEOUT_EC_ADAPT ,None RESET:0x4"
          
         hexmask.long 0x00 20.--22. 1. " ETH_PHY1_E100T1_PMA_E100M_PMA_TIMEOUT_RECOVERY ,None RESET:0x4"
          
         hexmask.long 0x00 24.--26. 1. " ETH_PHY1_E100T1_PMA_E100M_PMA_TIMEOUT_BLIND_ADAPT ,None RESET:0x4"
          
         bitfld.long 0x00 28. " ETH_PHY1_E100T1_PMA_E100M_PMA_TIMEOUT_BLIND_IS_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 29. " ETH_PHY1_E100T1_PMA_E100M_PMA_TIMEOUT_LMS_IS_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 30. " ETH_PHY1_E100T1_PMA_E100M_PMA_TIMEOUT_EC_IS_LOCK ,None RESET:0x0"
          
rgroup.long 0x24++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_MSE, None RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " ETH_PHY1_E100T1_PMA_E100M_MSE_VALUE ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY1_E100T1_PMA_E100M_MSE_VALID ,None RESET:0x0"
          
rgroup.long 0x28++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_MSE_WC, None RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " ETH_PHY1_E100T1_PMA_E100M_MSE_WC_VALUE ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY1_E100T1_PMA_E100M_MSE_WC_VALID ,None RESET:0x0"
          
rgroup.long 0x2c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_PEAK_MSE, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY1_E100T1_PMA_E100M_PEAK_MSE_CURRENT ,None RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY1_E100T1_PMA_E100M_PEAK_MSE_WORST ,None RESET:0x0"
          
rgroup.long 0x30++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_SQI, None RESET:0x0"
         hexmask.long 0x00 1.--3. 1. " ETH_PHY1_E100T1_PMA_E100M_SQI_CURRENT ,None RESET:0x0"
          
         hexmask.long 0x00 5.--7. 1. " ETH_PHY1_E100T1_PMA_E100M_SQI_WORST ,None RESET:0x0"
          
rgroup.long 0x34++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_ADFE_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMA_E100M_ADFE_STATUS_FFF_COEFF_SAT ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_STATUS_FBF_COEFF_SAT ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_E100T1_PMA_E100M_ADFE_STATUS_FFF_FLT_SAT ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY1_E100T1_PMA_E100M_ADFE_STATUS_FBF_FLT_SAT ,None RESET:0x0"
          
         bitfld.long 0x00 16. " ETH_PHY1_E100T1_PMA_E100M_ADFE_STATUS_RDCD_COEFF_SAT ,None RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_ADFE_FFF_COEFF_ADDR, None RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_FFF_COEFF_ADDR_VALUE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_E100T1_PMA_E100M_ADFE_FFF_COEFF_ADDR_EN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY1_E100T1_PMA_E100M_ADFE_FFF_COEFF_ADDR_RNW ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY1_E100T1_PMA_E100M_ADFE_FFF_COEFF_ADDR_ERROR ,None RESET:0x0"
          
rgroup.long 0x3c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_ADFE_FFF_COEFF_RDATA, None RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_FFF_COEFF_RDATA_VALUE ,None RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_ADFE_FFF_COEFF_WDATA, None RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_FFF_COEFF_WDATA_VALUE ,None RESET:0x0"
          
group.long  0x44++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_ADFE_FBF_COEFF_ADDR, None RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_FBF_COEFF_ADDR_VALUE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_E100T1_PMA_E100M_ADFE_FBF_COEFF_ADDR_EN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY1_E100T1_PMA_E100M_ADFE_FBF_COEFF_ADDR_RNW ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY1_E100T1_PMA_E100M_ADFE_FBF_COEFF_ADDR_ERROR ,None RESET:0x0"
          
rgroup.long 0x48++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_ADFE_FBF_COEFF_RDATA, None RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_FBF_COEFF_RDATA_VALUE ,None RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_ADFE_FBF_COEFF_WDATA, None RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_FBF_COEFF_WDATA_VALUE ,None RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG1, None RESET:0x4450404"
         hexmask.long 0x00 0.--2. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG1_FFF_CORR_STEP_SHIFT ,None RESET:0x4"
          
         hexmask.long 0x00 8.--10. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG1_FBF_CORR_STEP_SHIFT ,None RESET:0x4"
          
         hexmask.long 0x00 16.--18. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG1_BLD_CORR_STEP_SHIFT ,None RESET:0x5"
          
         hexmask.long 0x00 20.--22. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG1_TR_CORR_STEP_SHIFT ,None RESET:0x4"
          
         hexmask.long 0x00 24.--25. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG1_FFF_WEIGHT_SEL ,None RESET:0x0"
          
         hexmask.long 0x00 26.--27. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG1_FBF_WEIGHT_SEL ,None RESET:0x1"
          
group.long  0x54++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG2, None RESET:0x14d54554"
         hexmask.long 0x00 0.--2. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG2_LOCK_WINDOW ,None RESET:0x4"
          
         hexmask.long 0x00 3.--5. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG2_LOCK_COUNT ,None RESET:0x2"
          
         hexmask.long 0x00 6.--11. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG2_LOCK_TH ,None RESET:0x15"
          
         hexmask.long 0x00 14.--19. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG2_LOCK_BLD_TH ,None RESET:0x15"
          
         hexmask.long 0x00 20.--21. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG2_BLW_MODE ,None RESET:0x1"
          
         hexmask.long 0x00 22.--23. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG2_LOCK_BLD_TH_EN ,None RESET:0x3"
          
         hexmask.long 0x00 24.--26. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG2_LOCK_BLD_WINDOW ,None RESET:0x4"
          
         hexmask.long 0x00 27.--28. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG2_LOCK_BLD_CAPTURE ,None RESET:0x2"
          
         hexmask.long 0x00 29.--30. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG2_LOCK_BLD_COUNT ,None RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG3, None RESET:0x83"
         hexmask.long 0x00 0.--2. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG3_SD_CFG ,None RESET:0x3"
          
         hexmask.long 0x00 3.--8. 1. " ETH_PHY1_E100T1_PMA_E100M_ADFE_CFG3_SD_AVERAGE_TH ,None RESET:0x10"
          
group.long  0x5c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_EC_CFG, None RESET:0x4004"
         hexmask.long 0x00 0.--2. 1. " ETH_PHY1_E100T1_PMA_E100M_EC_CFG_STEP_SHIFT ,None RESET:0x4"
          
         hexmask.long 0x00 12.--15. 1. " ETH_PHY1_E100T1_PMA_E100M_EC_CFG_TX_DELAY ,None RESET:0x4"
          
group.long  0x60++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_EC_COEFF_ADDR, None RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " ETH_PHY1_E100T1_PMA_E100M_EC_COEFF_ADDR_VALUE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_E100T1_PMA_E100M_EC_COEFF_ADDR_EN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY1_E100T1_PMA_E100M_EC_COEFF_ADDR_RNW ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY1_E100T1_PMA_E100M_EC_COEFF_ADDR_ERROR ,None RESET:0x0"
          
rgroup.long 0x64++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_EC_COEFF_RDATA, None RESET:0x0"
         hexmask.long 0x00 0.--17. 1. " ETH_PHY1_E100T1_PMA_E100M_EC_COEFF_RDATA_VALUE ,None RESET:0x0"
          
group.long  0x68++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_EC_COEFF_WDATA, None RESET:0x0"
         hexmask.long 0x00 0.--17. 1. " ETH_PHY1_E100T1_PMA_E100M_EC_COEFF_WDATA_VALUE ,None RESET:0x0"
          
rgroup.long 0x6c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_EC_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMA_E100M_EC_STATUS_COEFF_SAT ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_E100T1_PMA_E100M_EC_STATUS_FLT_SAT ,None RESET:0x0"
          
group.long  0x70++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_TR_CONFIG, None RESET:0x1f0e0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_CONFIG_MODE ,None RESET:0xf0e0"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_CONFIG_PICTRL ,None RESET:0x1"
          
         bitfld.long 0x00 24. " ETH_PHY1_E100T1_PMA_E100M_TR_CONFIG_DEBUG ,None RESET:0x0"
          
         bitfld.long 0x00 28. " ETH_PHY1_E100T1_PMA_E100M_TR_CONFIG_ENABLE_EXTERNAL_STEP_CTRL ,None RESET:0x0"
          
group.long  0x74++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_TR_CURSOR_REF1, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_CURSOR_REF1_PRE ,None RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_CURSOR_REF1_POST ,None RESET:0x0"
          
group.long  0x78++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_TR_CURSOR_REF2, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_CURSOR_REF2_MAIN ,None RESET:0x0"
          
group.long  0x7c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_TR_TED, None RESET:0x60091"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_TED_THRESHOLD ,None RESET:0x1"
          
         hexmask.long 0x00 2.--3. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_TED_SEL_INTG ,None RESET:0x0"
          
         hexmask.long 0x00 4.--5. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_TED_SEL_INTGSLOW ,None RESET:0x1"
          
         hexmask.long 0x00 6.--7. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_TED_SEL_RESISI ,None RESET:0x2"
          
         hexmask.long 0x00 16.--17. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_TED_PM_SEL_INTG ,None RESET:0x2"
          
         hexmask.long 0x00 18.--19. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_TED_PPD_SEL_INTG ,None RESET:0x1"
          
group.long  0x80++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_TR_LOOP0, None RESET:0xc00800"
         hexmask.long 0x00 0.--12. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_LOOP0_CPROP ,None RESET:0x800"
          
         hexmask.long 0x00 16.--27. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_LOOP0_CINTG ,None RESET:0xc0"
          
group.long  0x84++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_TR_LOOP1, None RESET:0x80800"
         hexmask.long 0x00 0.--12. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_LOOP1_CPROP ,None RESET:0x800"
          
         hexmask.long 0x00 16.--27. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_LOOP1_CINTG ,None RESET:0x8"
          
group.long  0x88++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_TR_LOCK, None RESET:0x2471500"
         hexmask.long 0x00 8.--10. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_LOCK_WINSIZE ,None RESET:0x5"
          
         hexmask.long 0x00 11.--13. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_LOCK_PHASE_CAP ,None RESET:0x2"
          
         hexmask.long 0x00 14.--16. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_LOCK_PHASE_LCK ,None RESET:0x4"
          
         hexmask.long 0x00 17.--19. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_LOCK_FREQ_CAP ,None RESET:0x3"
          
         hexmask.long 0x00 20.--22. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_LOCK_FREQ_LCK ,None RESET:0x4"
          
         hexmask.long 0x00 23.--24. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_LOCK_PPM_CAP ,None RESET:0x0"
          
         hexmask.long 0x00 25.--26. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_LOCK_PPM_LCK ,None RESET:0x1"
          
rgroup.long 0x8c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_TR_ACCUM, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_ACCUM_PHASE_ACCUM ,None RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_ACCUM_FREQ_ACCUM ,None RESET:0x0"
          
group.long  0x90++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_TR_ACCUM_CONFIG, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_ACCUM_CONFIG_MODE ,None RESET:0x0"
          
         hexmask.long 0x00 8.--12. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_ACCUM_CONFIG_PHASE_MSB ,None RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETH_PHY1_E100T1_PMA_E100M_TR_ACCUM_CONFIG_FREQ_OFF ,None RESET:0x0"
          
group.long  0x94++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_TR_ACCUM_CONFIG_WRITE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMA_E100M_TR_ACCUM_CONFIG_WRITE_REQ ,None RESET:0x0"
          
rgroup.long 0x98++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_DBG_TR_STATUS, None RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY1_E100T1_PMA_E100M_DBG_TR_STATUS_FSM ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ETH_PHY1_E100T1_PMA_E100M_DBG_TR_STATUS_LOCKED ,None RESET:0x0"
          
         hexmask.long 0x00 8.--13. 1. " ETH_PHY1_E100T1_PMA_E100M_DBG_TR_STATUS_LOSTLCKDCNT ,None RESET:0x0"
          
group.long  0x9c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_DBG_CTRL_INIT_TRIGGER, None RESET:0xf"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY1_E100T1_PMA_E100M_DBG_CTRL_INIT_TRIGGER_STATE ,None RESET:0xf"
          
group.long  0xa0++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_DBG_CTRL_STATE_TRIGGER, None RESET:0xf"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY1_E100T1_PMA_E100M_DBG_CTRL_STATE_TRIGGER_STATE ,None RESET:0xf"
          
group.long  0xa8++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_DBG_SYMB_PAIR_TRIGGER, None RESET:0xf"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY1_E100T1_PMA_E100M_DBG_SYMB_PAIR_TRIGGER_VALUE ,None RESET:0xf"
          
group.long  0xac++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_ADC_IF_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMA_E100M_ADC_IF_CTRL_ADC_IF_ENABLE_OVR ,None RESET:0x0"
          
group.long  0xb0++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL_OVERRIDE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PMA_E100M_PMA_CTRL_OVERRIDE_CLKGEN_MASTER_OVERRIDE ,None RESET:0x0"
          
group.long  0xb4++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PMA_E100M_PMA_WATCHDOG, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY1_E100T1_PMA_E100M_PMA_WATCHDOG_WND_SCALE ,None RESET:0x0"
          
tree.end

tree "ETH_PHY1__RI_ABB"
base e:0x40079300
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY1_RI_ABB_ABB_CTRL_0, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_RI_ABB_ABB_CTRL_0_OVERRIDE ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_RI_ABB_ABB_CTRL_0_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_RI_ABB_ABB_CTRL_0_FORCE_LOCKED ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY1_RI_ABB_RI_ABB_CONFIG_0, None RESET:0x6383002"
         hexmask.long 0x00 0.--5. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_0_PVTMON_CYCLES ,None RESET:0x2"
          
         hexmask.long 0x00 6.--18. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_0_RINGO_TARGET_VAL_N ,None RESET:0xc0"
          
         hexmask.long 0x00 19.--31. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_0_RINGO_TARGET_VAL_P ,None RESET:0xc7"
          
group.long  0x8++0x3
    line.long 0x00 "ETH_PHY1_RI_ABB_RI_ABB_CONFIG_1, None RESET:0x233b263e"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_1_LOCK_RANGE_HIGH_P ,None RESET:0x3e"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_1_LOCK_RANGE_LOW_P ,None RESET:0x26"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_1_LOCK_RANGE_HIGH_N ,None RESET:0x3b"
          
         hexmask.long 0x00 24.--31. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_1_LOCK_RANGE_LOW_N ,None RESET:0x23"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY1_RI_ABB_RI_ABB_CONFIG_2, None RESET:0x30100"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_2_CP ,None RESET:0x100"
          
         hexmask.long 0x00 16.--18. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_2_CI_SEL ,None RESET:0x3"
          
         hexmask.long 0x00 19.--20. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_2_MAIN_TIMER_SEL ,None RESET:0x0"
          
         hexmask.long 0x00 21.--23. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_2_TESTMODE ,None RESET:0x0"
          
         hexmask.long 0x00 24.--25. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_2_PWM_SEL ,None RESET:0x0"
          
         hexmask.long 0x00 26.--27. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_2_MCHK_TOL_SEL ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY1_RI_ABB_RI_ABB_CONFIG_3, None RESET:0x3e00010d"
         hexmask.long 0x00 0.--2. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_3_SLOPE_CNT ,None RESET:0x5"
          
         hexmask.long 0x00 3.--5. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_3_FILTER_SHIFT ,None RESET:0x1"
          
         bitfld.long 0x00 6. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_3_LOCK_FAST_DISABLE ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_3_RCNT_BIST_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_3_BIAS_DIR ,None RESET:0x1"
          
         hexmask.long 0x00 24.--31. 1. " ETH_PHY1_RI_ABB_RI_ABB_CONFIG_3_CRC_VAL ,None RESET:0x3e"
          
group.long  0x14++0x3
    line.long 0x00 "ETH_PHY1_RI_ABB_ABB_STATUS_CAPTURE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_RI_ABB_ABB_STATUS_CAPTURE_GET_STATUS ,None RESET:0x0"
          
         hexmask.long 0x00 1.--3. 1. " ETH_PHY1_RI_ABB_ABB_STATUS_CAPTURE_STATUS_SEL ,None RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY1_RI_ABB_ABB_STATUS_0, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_RI_ABB_ABB_STATUS_0_LOCKED ,None RESET:0x0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "ETH_PHY1_RI_ABB_ABB_STATUS_1, None RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " ETH_PHY1_RI_ABB_ABB_STATUS_1_RINGO_COUNT_P ,None RESET:0x0"
          
         hexmask.long 0x00 13.--25. 1. " ETH_PHY1_RI_ABB_ABB_STATUS_1_RINGO_COUNT_N ,None RESET:0x0"
          
         bitfld.long 0x00 26. " ETH_PHY1_RI_ABB_ABB_STATUS_1_CRC_PASS ,None RESET:0x0"
          
         bitfld.long 0x00 27. " ETH_PHY1_RI_ABB_ABB_STATUS_1_MCHK_PASS ,None RESET:0x0"
          
         bitfld.long 0x00 28. " ETH_PHY1_RI_ABB_ABB_STATUS_1_BIST_PASS ,None RESET:0x0"
          
         bitfld.long 0x00 29. " ETH_PHY1_RI_ABB_ABB_STATUS_1_BIST_DONE ,None RESET:0x0"
          
         bitfld.long 0x00 30. " ETH_PHY1_RI_ABB_ABB_STATUS_1_BIST_AUX_PASS ,None RESET:0x0"
          
         bitfld.long 0x00 31. " ETH_PHY1_RI_ABB_ABB_STATUS_1_BIST_AUX_DONE ,None RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "ETH_PHY1_RI_ABB_ABB_CLKMON_TEST, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY1_RI_ABB_ABB_CLKMON_TEST_FORCED ,None RESET:0x0"
          
rgroup.long 0x24++0x3
    line.long 0x00 "ETH_PHY1_RI_ABB_ABB_CLKMON_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_RI_ABB_ABB_CLKMON_STATUS_CLK_RUNNING ,None RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "ETH_PHY1_RI_ABB_ABB_TMUX, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_RI_ABB_ABB_TMUX_EN ,None RESET:0x0"
          
tree.end

tree "ETH_PHY1__RF_CRC"
base e:0x40079400
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "ETH_PHY1_RF_CRC_CRC_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_RF_CRC_CRC_STATUS_DONE ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_RF_CRC_CRC_STATUS_MISMATCH ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY1_RF_CRC_CRC_EXPECTED_CHECKSUM, None RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETH_PHY1_RF_CRC_CRC_EXPECTED_CHECKSUM_VALUE ,None RESET:0x0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "ETH_PHY1_RF_CRC_CRC_CURRENT_CHECKSUM, None RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETH_PHY1_RF_CRC_CRC_CURRENT_CHECKSUM_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY1_RF_CRC_CRC_AUTO_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_RF_CRC_CRC_AUTO_CTRL_CRC_AUTO_EN_0 ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_RF_CRC_CRC_AUTO_CTRL_CRC_AUTO_EN_1 ,None RESET:0x0"
          
tree.end

tree "ETH_PHY1__IRQ"
base e:0x40079500
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "ETH_PHY1_IRQ_IRQ_FUNC_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_IRQ_IRQ_FUNC_STATUS_WOL ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_IRQ_IRQ_FUNC_STATUS_LINK_STATUS_CHANGED ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_IRQ_IRQ_FUNC_STATUS_ENERGY_DETECT ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY1_IRQ_IRQ_FUNC_STATUS_LINK_QUALITY ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ETH_PHY1_IRQ_IRQ_FUNC_STATUS_MST_SLV_TRAINING_COMPLETE ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY1_IRQ_IRQ_FUNC_STATUS_ENTERED_SLEEP_MODE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_IRQ_IRQ_FUNC_STATUS_ENTERED_SLEEP_FAIL ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY1_IRQ_IRQ_FUNC_STATUS_POLARITY_CHANGE ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY1_IRQ_IRQ_FUNC_STATUS_ERROR_COUNT ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ETH_PHY1_IRQ_IRQ_FUNC_STATUS_FALSE_CARRIER ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY1_IRQ_IRQ_FUNC_STATUS_ABB_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY1_IRQ_IRQ_FUNC_STATUS_PRBS_OVERFLOW ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY1_IRQ_IRQ_FUNC_MASK, None RESET:0x3fdb"
         bitfld.long 0x00 0. " ETH_PHY1_IRQ_IRQ_FUNC_MASK_MASK_WOL ,None RESET:0x1"
          
         bitfld.long 0x00 1. " ETH_PHY1_IRQ_IRQ_FUNC_MASK_MASK_LINK_STATUS_CHANGED ,None RESET:0x1"
          
         bitfld.long 0x00 3. " ETH_PHY1_IRQ_IRQ_FUNC_MASK_MASK_ENERGY_DETECT ,None RESET:0x1"
          
         bitfld.long 0x00 4. " ETH_PHY1_IRQ_IRQ_FUNC_MASK_MASK_LINK_QUALITY ,None RESET:0x1"
          
         bitfld.long 0x00 6. " ETH_PHY1_IRQ_IRQ_FUNC_MASK_MASK_MST_SLV_TRAINING_COMPLETE ,None RESET:0x1"
          
         bitfld.long 0x00 7. " ETH_PHY1_IRQ_IRQ_FUNC_MASK_MASK_ENTERED_SLEEP_MODE ,None RESET:0x1"
          
         bitfld.long 0x00 8. " ETH_PHY1_IRQ_IRQ_FUNC_MASK_MASK_ENTERED_SLEEP_FAIL ,None RESET:0x1"
          
         bitfld.long 0x00 9. " ETH_PHY1_IRQ_IRQ_FUNC_MASK_MASK_POLARITY_CHANGE ,None RESET:0x1"
          
         bitfld.long 0x00 10. " ETH_PHY1_IRQ_IRQ_FUNC_MASK_MASK_ERROR_COUNT ,None RESET:0x1"
          
         bitfld.long 0x00 11. " ETH_PHY1_IRQ_IRQ_FUNC_MASK_MASK_FALSE_CARRIER ,None RESET:0x1"
          
         bitfld.long 0x00 12. " ETH_PHY1_IRQ_IRQ_FUNC_MASK_MASK_ABB_ENABLE ,None RESET:0x1"
          
         bitfld.long 0x00 13. " ETH_PHY1_IRQ_IRQ_FUNC_MASK_MASK_PRBS_OVERFLOW ,None RESET:0x1"
          
group.long  0x8++0x3
    line.long 0x00 "ETH_PHY1_IRQ_IRQ_FUNC_CLEAR, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_IRQ_IRQ_FUNC_CLEAR_CLEAR_WOL ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_IRQ_IRQ_FUNC_CLEAR_CLEAR_LINK_STATUS_CHANGED ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_IRQ_IRQ_FUNC_CLEAR_CLEAR_ENERGY_DETECT ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY1_IRQ_IRQ_FUNC_CLEAR_CLEAR_LINK_QUALITY ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ETH_PHY1_IRQ_IRQ_FUNC_CLEAR_CLEAR_MST_SLV_TRAINING_COMPLETE ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY1_IRQ_IRQ_FUNC_CLEAR_CLEAR_ENTERED_SLEEP_MODE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_IRQ_IRQ_FUNC_CLEAR_CLEAR_ENTERED_SLEEP_FAIL ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY1_IRQ_IRQ_FUNC_CLEAR_CLEAR_POLARITY_CHANGE ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY1_IRQ_IRQ_FUNC_CLEAR_CLEAR_ERROR_COUNT ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ETH_PHY1_IRQ_IRQ_FUNC_CLEAR_CLEAR_FALSE_CARRIER ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY1_IRQ_IRQ_FUNC_CLEAR_CLEAR_ABB_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY1_IRQ_IRQ_FUNC_CLEAR_CLEAR_PRBS_OVERFLOW ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY1_IRQ_IRQ_FUNC_TEST, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_IRQ_IRQ_FUNC_TEST_IRQ_FUNC_TEST_TRIGGER ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_IRQ_IRQ_FUNC_TEST_IRQ_FUNC_TEST_TRIGGER_CLEAR ,None RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "ETH_PHY1_IRQ_IRQ_SAFE_TEMP_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_STATUS_JABBER_DETECT ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_STATUS_ESD_EVENT ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_STATUS_RX_MAC_VALIDATE_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_STATUS_TX_MAC_VALIDATE_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_STATUS_PMA_WATCHDOG ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_STATUS_APB_PAR_ERR ,None RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "ETH_PHY1_IRQ_IRQ_SAFE_TEMP_MASK, None RESET:0x9f"
         bitfld.long 0x00 0. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_MASK_MASK_JABBER_DETECT ,None RESET:0x1"
          
         bitfld.long 0x00 1. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_MASK_MASK_ESD_EVENT ,None RESET:0x1"
          
         bitfld.long 0x00 2. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_MASK_MASK_RX_MAC_VALIDATE_ERROR ,None RESET:0x1"
          
         bitfld.long 0x00 3. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_MASK_MASK_TX_MAC_VALIDATE_ERROR ,None RESET:0x1"
          
         bitfld.long 0x00 4. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_MASK_MASK_PMA_WATCHDOG ,None RESET:0x1"
          
         bitfld.long 0x00 7. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_MASK_MASK_APB_PAR_ERR ,None RESET:0x1"
          
group.long  0x18++0x3
    line.long 0x00 "ETH_PHY1_IRQ_IRQ_SAFE_TEMP_CLEAR, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_CLEAR_CLEAR_JABBER_DETECT ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_CLEAR_CLEAR_ESD_EVENT ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_CLEAR_CLEAR_RX_MAC_VALIDATE_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_CLEAR_CLEAR_TX_MAC_VALIDATE_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_CLEAR_CLEAR_PMA_WATCHDOG ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_CLEAR_CLEAR_APB_PAR_ERR ,None RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "ETH_PHY1_IRQ_IRQ_SAFE_TEMP_TEST, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_TEST_IRQ_SAFE_TEMP_TEST_TRIGGER ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_IRQ_IRQ_SAFE_TEMP_TEST_IRQ_SAFE_TEMP_TEST_TRIGGER_CLEAR ,None RESET:0x0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "ETH_PHY1_IRQ_IRQ_SAFE_FUND_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_IRQ_IRQ_SAFE_FUND_STATUS_REGFILE_CRC_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_IRQ_IRQ_SAFE_FUND_STATUS_PLL100_LOCK_LOSS ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ETH_PHY1_IRQ_IRQ_SAFE_FUND_STATUS_ABB_LOCK_LOSS ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ETH_PHY1_IRQ_IRQ_SAFE_FUND_STATUS_ABB_LATENT_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY1_IRQ_IRQ_SAFE_FUND_STATUS_LINEDRIVER_RESCAL ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_IRQ_IRQ_SAFE_FUND_STATUS_FSM_PARITY ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY1_IRQ_IRQ_SAFE_FUND_STATUS_S_FAIL ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY1_IRQ_IRQ_SAFE_FUND_STATUS_CLKMON_FAIL ,None RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "ETH_PHY1_IRQ_IRQ_SAFE_FUND_TEST, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_IRQ_IRQ_SAFE_FUND_TEST_IRQ_SAFE_FUND_TEST_TRIGGER ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_IRQ_IRQ_SAFE_FUND_TEST_IRQ_SAFE_FUND_TEST_TRIGGER_CLEAR ,None RESET:0x0"
          
tree.end

tree "ETH_PHY1__TOP_CTRL"
base e:0x40079900
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_TOP_CTRL_TESTMODE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_TOP_CTRL_TESTMODE_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_TOP_CTRL_TOP_CTRL_TESTMODE_PMD_STARTUP_EN ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_TOP_CTRL_TOP_CTRL_TESTMODE_PMD_TEAR_RESCAL_EN ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_TOP_CTRL_TOP_CTRL_TESTMODE_PMD_TEAR_DOWN_EN ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY1_TOP_CTRL_TOP_CTRL_TESTMODE_PHY_LINK_CONTROL_100M ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_CONFIG, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_CONFIG_LINK_CONTROL ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_TOP_CTRL_CONFIG_PHY_CONFIG_DONE ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY1_TOP_CTRL_CONFIG_IEEE_POWERDOWN_PMD ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_ABB_LOCK_TIMER, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_ABB_LOCK_TIMER_SELECT ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_OA_SLEEP_WAKEUP, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_OA_SLEEP_WAKEUP_SLEEP_START ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_FAILURE_DEBUG, None RESET:0x1"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_FAILURE_DEBUG_ENABLE ,None RESET:0x1"
          
group.long  0x14++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_FSM_READ_STATE_REQ, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_FSM_READ_STATE_REQ_ENABLE ,None RESET:0x0"
          
         hexmask.long 0x00 1.--5. 1. " ETH_PHY1_TOP_CTRL_FSM_READ_STATE_REQ_ADDRESS ,None RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_FSM_READ_STATE_RESP, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_FSM_READ_STATE_RESP_VALID ,None RESET:0x0"
          
         hexmask.long 0x00 1.--6. 1. " ETH_PHY1_TOP_CTRL_FSM_READ_STATE_RESP_CURRENT_STATE ,None RESET:0x0"
          
         hexmask.long 0x00 7.--12. 1. " ETH_PHY1_TOP_CTRL_FSM_READ_STATE_RESP_PREV_STATE ,None RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_TC10_TIMERS, None RESET:0xf4"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY1_TOP_CTRL_TC10_TIMERS_ACK_SELECT ,None RESET:0x14"
          
         hexmask.long 0x00 5.--6. 1. " ETH_PHY1_TOP_CTRL_TC10_TIMERS_REQ_SELECT ,None RESET:0x3"
          
         hexmask.long 0x00 7.--8. 1. " ETH_PHY1_TOP_CTRL_TC10_TIMERS_FAIL_SELECT ,None RESET:0x1"
          
group.long  0x20++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_TC10_SKIP_SLEEP_ACK, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_TC10_SKIP_SLEEP_ACK_ENABLE ,None RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_TC10_IGNORE_REQ_TIMER_DONE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_TC10_IGNORE_REQ_TIMER_DONE_ENABLE ,None RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_TC10_ENABLE_SLEEP_CAPABILITY, None RESET:0x1"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_TC10_ENABLE_SLEEP_CAPABILITY_ENABLE ,None RESET:0x1"
          
group.long  0x30++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_CABLE_DIAGNOSTICS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_CABLE_DIAGNOSTICS_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_TOP_CTRL_CABLE_DIAGNOSTICS_DONE ,None RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_RBB100_POWER_GATING, None RESET:0x7"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_RBB100_POWER_GATING_CLK_ENABLE ,None RESET:0x1"
          
         bitfld.long 0x00 1. " ETH_PHY1_TOP_CTRL_RBB100_POWER_GATING_RESET_N ,None RESET:0x1"
          
         bitfld.long 0x00 2. " ETH_PHY1_TOP_CTRL_RBB100_POWER_GATING_ISO_N ,None RESET:0x1"
          
         bitfld.long 0x00 3. " ETH_PHY1_TOP_CTRL_RBB100_POWER_GATING_PC ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY1_TOP_CTRL_RBB100_POWER_GATING_PDL ,None RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_ZBB_PMD_POWER_GATING, None RESET:0x7"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_ZBB_PMD_POWER_GATING_CLK_ENABLE ,None RESET:0x1"
          
         bitfld.long 0x00 1. " ETH_PHY1_TOP_CTRL_ZBB_PMD_POWER_GATING_RESET_N ,None RESET:0x1"
          
         bitfld.long 0x00 2. " ETH_PHY1_TOP_CTRL_ZBB_PMD_POWER_GATING_ISO_N ,None RESET:0x1"
          
         bitfld.long 0x00 3. " ETH_PHY1_TOP_CTRL_ZBB_PMD_POWER_GATING_PC ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY1_TOP_CTRL_ZBB_PMD_POWER_GATING_PDL ,None RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_POWER_SWITCH_TEST_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_POWER_SWITCH_TEST_CTRL_TEST_CTRL_RBB ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_TOP_CTRL_POWER_SWITCH_TEST_CTRL_TEST_CTRL_ZBB_PMD ,None RESET:0x0"
          
rgroup.long 0x5c++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_POWER_SWITCH_TEST_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_TOP_CTRL_POWER_SWITCH_TEST_STATUS_TEST_STATUS_RBB ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_TOP_CTRL_POWER_SWITCH_TEST_STATUS_TEST_STATUS_ZBB_PMD ,None RESET:0x0"
          
rgroup.long 0x60++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_CABLE_DIAG_STATUS, None RESET:0x0"
         hexmask.long 0x00 4.--7. 1. " ETH_PHY1_TOP_CTRL_CABLE_DIAG_STATUS_STATUS ,None RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " ETH_PHY1_TOP_CTRL_CABLE_DIAG_STATUS_LOCATION ,None RESET:0x0"
          
rgroup.long 0x64++0x3
    line.long 0x00 "ETH_PHY1_TOP_CTRL_PHY_VERSION, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY1_TOP_CTRL_PHY_VERSION_PATCHLEVEL ,None RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY1_TOP_CTRL_PHY_VERSION_MINOR ,None RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY1_TOP_CTRL_PHY_VERSION_MAJOR ,None RESET:0x0"
          
tree.end

tree "ETH_PHY1__IEEE_PCS"
base e:0x4007a000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PCS_PCS_CONTROL_1, None RESET:0x0"
         bitfld.long 0x00 6. " ETH_PHY1_IEEE_PCS_PCS_CONTROL_1_SPEED_SELECTION_LSB ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 11. " ETH_PHY1_IEEE_PCS_PCS_CONTROL_1_LOW_POWER ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_PCS_PCS_CONTROL_1_SPEED_SELECTION_MSB ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 14. " ETH_PHY1_IEEE_PCS_PCS_CONTROL_1_LOOPBACK ,None RESET:0x0"
          
         bitfld.long 0x00 15. " ETH_PHY1_IEEE_PCS_PCS_CONTROL_1_RESET ,None RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PCS_PCS_STATUS_1, None RESET:0x2"
         bitfld.long 0x00 1. " ETH_PHY1_IEEE_PCS_PCS_STATUS_1_LOW_POWER_ABILITY ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 2. " ETH_PHY1_IEEE_PCS_PCS_STATUS_1_PCS_RECEIVE_LINK_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ETH_PHY1_IEEE_PCS_PCS_STATUS_1_CLOCK_STOP_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY1_IEEE_PCS_PCS_STATUS_1_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_IEEE_PCS_PCS_STATUS_1_RX_LPI_INDICATION ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 9. " ETH_PHY1_IEEE_PCS_PCS_STATUS_1_TX_LPI_INDICATION ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 10. " ETH_PHY1_IEEE_PCS_PCS_STATUS_1_RX_LPI_RECEIVED ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 11. " ETH_PHY1_IEEE_PCS_PCS_STATUS_1_TX_LPI_RECEIVED ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PCS_PCS_DEVICE_IDENTIFIER_1, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_IEEE_PCS_PCS_DEVICE_IDENTIFIER_1_OUI ,None RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PCS_PCS_DEVICE_IDENTIFIER_2, None RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY1_IEEE_PCS_PCS_DEVICE_IDENTIFIER_2_REVISION ,None RESET:0x0"
          
         hexmask.long 0x00 4.--9. 1. " ETH_PHY1_IEEE_PCS_PCS_DEVICE_IDENTIFIER_2_MODEL ,None RESET:0x0"
          
         hexmask.long 0x00 10.--15. 1. " ETH_PHY1_IEEE_PCS_PCS_DEVICE_IDENTIFIER_2_OUI ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1, None RESET:0x8a"
         bitfld.long 0x00 0. " ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_CLAUSE_22_REGISTERS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 1. " ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_PMD_PMA_PRESENT ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 2. " ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_WIS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 3. " ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_PCS_PRESENT ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 4. " ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_PHY_XS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_DTE_XS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 6. " ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_TC_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_AUTO_NEGOTIATION_PRESENT ,None RESET:0x1" "TRUE-1"
          
         hexmask.long 0x00 8.--11. 1. " ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_SEPARATED_PMA_PRESENT ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_OFDM ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_POWER_UNIT_PRESENT ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_2, None RESET:0x0"
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_2_CLAUSE_22_EXTENSION_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 14. " ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_2_VENDOR_SPECIFIC_DEVICE_1_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 15. " ETH_PHY1_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_2_VENDOR_SPECIFIC_DEVICE_2_PRESENT ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PCS_PCS_STATUS_2, None RESET:0x8000"
         bitfld.long 0x00 0. " ETH_PHY1_IEEE_PCS_PCS_STATUS_2_E10GBASE_R_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 1. " ETH_PHY1_IEEE_PCS_PCS_STATUS_2_E10GBASE_X_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 2. " ETH_PHY1_IEEE_PCS_PCS_STATUS_2_E10GBASE_W_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 3. " ETH_PHY1_IEEE_PCS_PCS_STATUS_2_E10GBASE_T_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 4. " ETH_PHY1_IEEE_PCS_PCS_STATUS_2_E40GBASE_R_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY1_IEEE_PCS_PCS_STATUS_2_E100GBASE_R_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 6. " ETH_PHY1_IEEE_PCS_PCS_STATUS_2_E40GBASE_T_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY1_IEEE_PCS_PCS_STATUS_2_E25GBASE_R_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 9. " ETH_PHY1_IEEE_PCS_PCS_STATUS_2_E25GBASE_T_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 10. " ETH_PHY1_IEEE_PCS_PCS_STATUS_2_RECEIVE_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ETH_PHY1_IEEE_PCS_PCS_STATUS_2_TRANSMIT_FAULT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 12. " ETH_PHY1_IEEE_PCS_PCS_STATUS_2_E2D5GBASE_T_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_PCS_PCS_STATUS_2_E5GBASE_T_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         hexmask.long 0x00 14.--15. 1. " ETH_PHY1_IEEE_PCS_PCS_STATUS_2_DEVICE_PRESENT ,None RESET:0x2"
          
rgroup.long 0x38++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PCS_PCS_PACKAGE_IDENTIFIER_1, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_IEEE_PCS_PCS_PACKAGE_IDENTIFIER_1_OUI ,None RESET:0x0"
          
rgroup.long 0x3c++0x3
    line.long 0x00 "ETH_PHY1_IEEE_PCS_PCS_PACKAGE_IDENTIFIER_2, None RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY1_IEEE_PCS_PCS_PACKAGE_IDENTIFIER_2_REVISION ,None RESET:0x0"
          
         hexmask.long 0x00 4.--9. 1. " ETH_PHY1_IEEE_PCS_PCS_PACKAGE_IDENTIFIER_2_MODEL ,None RESET:0x0"
          
         hexmask.long 0x00 10.--15. 1. " ETH_PHY1_IEEE_PCS_PCS_PACKAGE_IDENTIFIER_2_OUI ,None RESET:0x0"
          
tree.end

tree "ETH_PHY1__E100T1_PCS"
base e:0x4007b000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PCS_E100M_REMOTE_LOOPBACK, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PCS_E100M_REMOTE_LOOPBACK_VALUE ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PCS_E100M_TXPCS_TESTMODE, None RESET:0x600"
         hexmask.long 0x00 8.--15. 1. " ETH_PHY1_E100T1_PCS_E100M_TXPCS_TESTMODE_CNT ,None RESET:0x6"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PCS_E100M_TX_DISABLE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PCS_E100M_TX_DISABLE_DISABLED ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PCS_E100M_TXPCS_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PCS_E100M_TXPCS_STATUS_READY2TRANSMIT ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PCS_E100M_RXPCS, None RESET:0x100"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PCS_E100M_RXPCS_SCR_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_E100T1_PCS_E100M_RXPCS_CHECK_IDLE ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_E100T1_PCS_E100M_RXPCS_RCVR_IDLE_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_E100T1_PCS_E100M_RXPCS_REM_RCVR_STATUS_OK ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_E100T1_PCS_E100M_RXPCS_POLARITY_ENABLE ,None RESET:0x1"
          
         bitfld.long 0x00 9. " ETH_PHY1_E100T1_PCS_E100M_RXPCS_POLARITY_DETECTED ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY1_E100T1_PCS_E100M_RXPCS_POLARITY_INVERSION ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ETH_PHY1_E100T1_PCS_E100M_RXPCS_ABSEL ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY1_E100T1_PCS_E100M_RXPCS_JAB_EXTEND ,None RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PCS_E100M_RXPCS_SCR_CONFIG, None RESET:0x1220028"
         hexmask.long 0x00 0.--5. 1. " ETH_PHY1_E100T1_PCS_E100M_RXPCS_SCR_CONFIG_LOCK_VALIDATION_COUNT ,None RESET:0x28"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY1_E100T1_PCS_E100M_RXPCS_SCR_CONFIG_MAX_INVALID_IDLE ,None RESET:0x22"
          
         hexmask.long 0x00 24.--31. 1. " ETH_PHY1_E100T1_PCS_E100M_RXPCS_SCR_CONFIG_TH_REM_RCVR_STATUS_OK ,None RESET:0x1"
          
group.long  0x20++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PCS_E100M_DBG_CONFIG, None RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " ETH_PHY1_E100T1_PCS_E100M_DBG_CONFIG_TRACE_SELECT ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY1_E100T1_PCS_E100M_DBG_CONFIG_TRACE_ENABLE ,None RESET:0x0"
          
         hexmask.long 0x00 8.--12. 1. " ETH_PHY1_E100T1_PCS_E100M_DBG_CONFIG_TRIGGER_SELECT ,None RESET:0x0"
          
         bitfld.long 0x00 16. " ETH_PHY1_E100T1_PCS_E100M_DBG_CONFIG_PLAYBACK_ENABLE ,None RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PCS_E100M_DBG_RF_TRIGGER, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_E100T1_PCS_E100M_DBG_RF_TRIGGER_ENABLE ,None RESET:0x0"
          
rgroup.long 0x28++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PCS_E100M_TC1_STARTUP_TIME, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY1_E100T1_PCS_E100M_TC1_STARTUP_TIME_LTT ,None RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY1_E100T1_PCS_E100M_TC1_STARTUP_TIME_LRT ,None RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY1_E100T1_PCS_E100M_TC1_STARTUP_TIME_RRT ,None RESET:0x0"
          
rgroup.long 0x2c++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PCS_E100M_TC1_LFL_COMM, None RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " ETH_PHY1_E100T1_PCS_E100M_TC1_LFL_COMM_FAILURES ,None RESET:0x0"
          
         hexmask.long 0x00 10.--15. 1. " ETH_PHY1_E100T1_PCS_E100M_TC1_LFL_COMM_LOSSES ,None RESET:0x0"
          
         hexmask.long 0x00 16.--21. 1. " ETH_PHY1_E100T1_PCS_E100M_TC1_LFL_COMM_RECOVERIES ,None RESET:0x0"
          
         bitfld.long 0x00 31. " ETH_PHY1_E100T1_PCS_E100M_TC1_LFL_COMM_COMM_READY ,None RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "ETH_PHY1_E100T1_PCS_E100M_FRAME_INDICATOR_CFG, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY1_E100T1_PCS_E100M_FRAME_INDICATOR_CFG_PREEMPT_SMD_SEL ,None RESET:0x0"
          
tree.end

tree "ETH_PHY1__WOL"
base e:0x4007b800
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY1_WOL_WOL_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_WOL_WOL_CONTROL_MAGIC_PACKET_EN ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_WOL_WOL_CONTROL_SECURE_ON_PW_EN ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY1_WOL_WOL_CONFIG, None RESET:0x10000"
         bitfld.long 0x00 8. " ETH_PHY1_WOL_WOL_CONFIG_SFD_SWAP ,None RESET:0x0"
          
         hexmask.long 0x00 9.--10. 1. " ETH_PHY1_WOL_WOL_CONFIG_DATA_SWAP ,None RESET:0x0"
          
         bitfld.long 0x00 16. " ETH_PHY1_WOL_WOL_CONFIG_CRC_GATE ,None RESET:0x1"
          
rgroup.long 0x8++0x3
    line.long 0x00 "ETH_PHY1_WOL_WOL_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_WOL_WOL_STATUS_WOL_MAGIC_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_WOL_WOL_STATUS_WOL_SECURE_ON_HACK ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_WOL_WOL_STATUS_WOL_NIBBLE_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY1_WOL_WOL_STATUS_WOL_CRC_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY1_WOL_WOL_STATUS_WOL_SFD_ERROR ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY1_WOL_WOL_MAC_ADDR0, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY1_WOL_WOL_MAC_ADDR0_OCTET0 ,None RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY1_WOL_WOL_MAC_ADDR0_OCTET1 ,None RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY1_WOL_WOL_MAC_ADDR0_OCTET2 ,None RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " ETH_PHY1_WOL_WOL_MAC_ADDR0_OCTET3 ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY1_WOL_WOL_MAC_ADDR1, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY1_WOL_WOL_MAC_ADDR1_OCTET4 ,None RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY1_WOL_WOL_MAC_ADDR1_OCTET5 ,None RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "ETH_PHY1_WOL_WOL_SEC_PW0, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY1_WOL_WOL_SEC_PW0_OCTET0 ,None RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY1_WOL_WOL_SEC_PW0_OCTET1 ,None RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY1_WOL_WOL_SEC_PW0_OCTET2 ,None RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " ETH_PHY1_WOL_WOL_SEC_PW0_OCTET3 ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "ETH_PHY1_WOL_WOL_SEC_PW1, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY1_WOL_WOL_SEC_PW1_OCTET4 ,None RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY1_WOL_WOL_SEC_PW1_OCTET5 ,None RESET:0x0"
          
tree.end

tree "ETH_PHY1__PRBS"
base e:0x4007ba00
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY1_PRBS_PRBS_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_PRBS_PRBS_CONTROL_PRBS_GEN_EN ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_PRBS_PRBS_CONTROL_PRBS_CRC_CHECK_EN ,None RESET:0x0"
          
         bitfld.long 0x00 16. " ETH_PHY1_PRBS_PRBS_CONTROL_PRBS_CHECK_EN ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY1_PRBS_PRBS_CONFIG0, None RESET:0x610"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY1_PRBS_PRBS_CONFIG0_PRBS_IPG_LEN ,None RESET:0x10"
          
         bitfld.long 0x00 8. " ETH_PHY1_PRBS_PRBS_CONFIG0_PRBS_PAYLOAD_SEL ,None RESET:0x0"
          
         hexmask.long 0x00 9.--10. 1. " ETH_PHY1_PRBS_PRBS_CONFIG0_PRBS_PAYLOAD_CRC ,None RESET:0x3"
          
         bitfld.long 0x00 16. " ETH_PHY1_PRBS_PRBS_CONFIG0_PRBS_FORCE_ERROR ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "ETH_PHY1_PRBS_PRBS_CONFIG1, None RESET:0x400000"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_PRBS_PRBS_CONFIG1_FRAMES ,None RESET:0x0"
          
         hexmask.long 0x00 16.--29. 1. " ETH_PHY1_PRBS_PRBS_CONFIG1_LEN ,None RESET:0x40"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY1_PRBS_PRBS_CONFIG2, None RESET:0x1000000"
         bitfld.long 0x00 0. " ETH_PHY1_PRBS_PRBS_CONFIG2_PRBS_ERROR_RESET ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_PRBS_PRBS_CONFIG2_PRBS_CRC_ERROR_RESET ,None RESET:0x0"
          
         bitfld.long 0x00 16. " ETH_PHY1_PRBS_PRBS_CONFIG2_PRBS_FRAME_RESET ,None RESET:0x0"
          
         hexmask.long 0x00 23.--24. 1. " ETH_PHY1_PRBS_PRBS_CONFIG2_PRBS_LOCK_LOSS_SEL ,None RESET:0x2"
          
         hexmask.long 0x00 30.--31. 1. " ETH_PHY1_PRBS_PRBS_CONFIG2_PRBS_ERROR_THRESHOLD ,None RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "ETH_PHY1_PRBS_PRBS_STATUS1, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_PRBS_PRBS_STATUS1_PRBS_GEN_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_PRBS_PRBS_STATUS1_PRBS_CHECKER_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY1_PRBS_PRBS_STATUS1_PRBS_CHECKER_LOSS ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_PRBS_PRBS_STATUS1_PRBS_ERROR_CNT_OVF ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY1_PRBS_PRBS_STATUS1_PRBS_CRC_ERROR_CNT_OVF ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY1_PRBS_PRBS_STATUS1_PRBS_FRAME_CNT_OVF ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETH_PHY1_PRBS_PRBS_STATUS2, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_PRBS_PRBS_STATUS2_PRBS15_ERRORS ,None RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETH_PHY1_PRBS_PRBS_STATUS2_CRC_ERRORS ,None RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY1_PRBS_PRBS_STATUS3, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_PRBS_PRBS_STATUS3_RX_FRAME_COUNT ,None RESET:0x0"
          
tree.end

tree "ETH_PHY1__MAC_VALIDATE"
base e:0x4007bb00
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY1_MAC_VALIDATE_MAC_PACKET_VALIDATE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_MAC_VALIDATE_MAC_PACKET_VALIDATE_RX_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_MAC_VALIDATE_MAC_PACKET_VALIDATE_TX_ENABLE ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY1_MAC_VALIDATE_MAC_PACKET_VALIDATE_CONFIG, None RESET:0x105dc01"
         bitfld.long 0x00 0. " ETH_PHY1_MAC_VALIDATE_MAC_PACKET_VALIDATE_CONFIG_PAYLOAD_LEN_CHECK ,None RESET:0x1"
          
         hexmask.long 0x00 8.--21. 1. " ETH_PHY1_MAC_VALIDATE_MAC_PACKET_VALIDATE_CONFIG_MTU_SIZE ,None RESET:0x5dc"
          
         bitfld.long 0x00 24. " ETH_PHY1_MAC_VALIDATE_MAC_PACKET_VALIDATE_CONFIG_RELAX_PREAMBLE_CHECK ,None RESET:0x1"
          
group.long  0x8++0x3
    line.long 0x00 "ETH_PHY1_MAC_VALIDATE_RX_MII_DECODE_CONFIG, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY1_MAC_VALIDATE_RX_MII_DECODE_CONFIG_SWAP_DATA ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_MAC_VALIDATE_RX_MII_DECODE_CONFIG_SWAP_SFD ,None RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "ETH_PHY1_MAC_VALIDATE_RX_MAC_PACKET_ERROR, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_MAC_VALIDATE_RX_MAC_PACKET_ERROR_RX_INVALID_PACKET ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_MAC_VALIDATE_RX_MAC_PACKET_ERROR_RX_CRC_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_MAC_VALIDATE_RX_MAC_PACKET_ERROR_RX_PAYLOAD_LEN_ERROR ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY1_MAC_VALIDATE_TX_MII_DECODE_CONFIG, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY1_MAC_VALIDATE_TX_MII_DECODE_CONFIG_SWAP_DATA ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY1_MAC_VALIDATE_TX_MII_DECODE_CONFIG_SWAP_SFD ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETH_PHY1_MAC_VALIDATE_TX_MAC_PACKET_ERROR, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_MAC_VALIDATE_TX_MAC_PACKET_ERROR_TX_INVALID_PACKET ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_MAC_VALIDATE_TX_MAC_PACKET_ERROR_TX_CRC_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_MAC_VALIDATE_TX_MAC_PACKET_ERROR_TX_PAYLOAD_LEN_ERROR ,None RESET:0x0"
          
tree.end

tree "ETH_PHY1__IEEE_AUTONEG"
base e:0x4007e000
width 80.
rgroup.long 0x8++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_AN_DEVICE_IDENTIFIER_1, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICE_IDENTIFIER_1_OUI ,None RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_AN_DEVICE_IDENTIFIER_2, None RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICE_IDENTIFIER_2_REVISION ,None RESET:0x0"
          
         hexmask.long 0x00 4.--9. 1. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICE_IDENTIFIER_2_MODEL ,None RESET:0x0"
          
         hexmask.long 0x00 10.--15. 1. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICE_IDENTIFIER_2_OUI ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1, None RESET:0x8a"
         bitfld.long 0x00 0. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_CLAUSE_22_REGISTERS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 1. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_PMD_PMA_PRESENT ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 2. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_WIS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 3. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_PCS_PRESENT ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 4. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_PHY_XS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_DTE_XS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 6. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_TC_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_AUTO_NEGOTIATION_PRESENT ,None RESET:0x1" "TRUE-1"
          
         hexmask.long 0x00 8.--11. 1. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_SEPARATED_PMA_PRESENT ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_OFDM ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_POWER_UNIT_PRESENT ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_2, None RESET:0x0"
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_2_CLAUSE_22_EXTENSION_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 14. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_2_VENDOR_SPECIFIC_DEVICE_1_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 15. " ETH_PHY1_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_2_VENDOR_SPECIFIC_DEVICE_2_PRESENT ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x38++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_AN_PACKAGE_IDENTIFIER_1, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_IEEE_AUTONEG_AN_PACKAGE_IDENTIFIER_1_OUI ,None RESET:0x0"
          
rgroup.long 0x3c++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_AN_PACKAGE_IDENTIFIER_2, None RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY1_IEEE_AUTONEG_AN_PACKAGE_IDENTIFIER_2_REVISION ,None RESET:0x0"
          
         hexmask.long 0x00 4.--9. 1. " ETH_PHY1_IEEE_AUTONEG_AN_PACKAGE_IDENTIFIER_2_MODEL ,None RESET:0x0"
          
         hexmask.long 0x00 10.--15. 1. " ETH_PHY1_IEEE_AUTONEG_AN_PACKAGE_IDENTIFIER_2_OUI ,None RESET:0x0"
          
group.long  0x200++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_CONTROL, None RESET:0x0"
         bitfld.long 0x00 9. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_CONTROL_RESTART_AUTO_NEGOTIATION ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_CONTROL_AUTO_NEGOTIATION_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 15. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_CONTROL_AN_RESET ,None RESET:0x0"
          
rgroup.long 0x204++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_STATUS, None RESET:0x8"
         bitfld.long 0x00 2. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_STATUS_LINK_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_STATUS_AUTO_NEGOTIATION_ABILITY ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 4. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_STATUS_REMOTE_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_STATUS_AUTO_NEGOTIATION_COMPLETE ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_STATUS_PAGE_RECEIVED ,None RESET:0x0"
          
group.long  0x208++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1, None RESET:0x1"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1_SELECTOR_FIELD ,None RESET:0x1"
          
         hexmask.long 0x00 5.--9. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1_ECHOED_NONCE ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1_PAUSE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1_FORCE_MASTER ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1_REMOTE_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 14. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1_ACKNOWLEDGE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 15. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1_NEXT_PAGE ,None RESET:0x0"
          
group.long  0x20c++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_2, None RESET:0xa0"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_2_TRANSMITTED_NONCE ,None RESET:0x0"
          
         hexmask.long 0x00 5.--15. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_2_TECHNOLOGY_ABILITY ,None RESET:0x5"
          
group.long  0x210++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_3, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_3_TECHNOLOGY_ABILITY ,None RESET:0x0"
          
rgroup.long 0x214++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1, None RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1_SELECTOR_FIELD ,None RESET:0x0"
          
         hexmask.long 0x00 5.--9. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1_ECHOED_NONCE ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1_PAUSE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1_FORCE_MASTER ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1_REMOTE_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 14. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1_ACKNOWLEDGE ,None RESET:0x0"
          
         bitfld.long 0x00 15. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1_NEXT_PAGE ,None RESET:0x0"
          
rgroup.long 0x218++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_2, None RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_2_TRANSMITTED_NONCE ,None RESET:0x0"
          
         hexmask.long 0x00 5.--15. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_2_TECHNOLOGY_ABILITY ,None RESET:0x0"
          
rgroup.long 0x21c++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_3, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_3_TECHNOLOGY_ABILITY ,None RESET:0x0"
          
group.long  0x220++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_1, None RESET:0x2001"
         hexmask.long 0x00 0.--10. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_1_MESSAGE_UNFORMATTED_CODE_FIELD ,None RESET:0x1"
          
         bitfld.long 0x00 11. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_1_TOGGLE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_1_ACKNOWLEDGE_2 ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_1_MESSAGE_PAGE ,None RESET:0x1"
          
         bitfld.long 0x00 15. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_1_NEXT_PAGE ,None RESET:0x0"
          
group.long  0x224++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_2, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_2_UNFORMATTED_CODE_FIELD_1 ,None RESET:0x0"
          
group.long  0x228++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_3, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_3_UNFORMATTED_CODE_FIELD_2 ,None RESET:0x0"
          
rgroup.long 0x22c++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_1, None RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_1_MESSAGE_UNFORMATTED_CODE_FIELD ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_1_TOGGLE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_1_ACKNOWLEDGE_2 ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_1_MESSAGE_PAGE ,None RESET:0x0"
          
         bitfld.long 0x00 15. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_1_NEXT_PAGE ,None RESET:0x0"
          
rgroup.long 0x230++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_2, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_2_UNFORMATTED_CODE_FIELD_1 ,None RESET:0x0"
          
rgroup.long 0x234++0x3
    line.long 0x00 "ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_3, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY1_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_3_UNFORMATTED_CODE_FIELD_2 ,None RESET:0x0"
          
tree.end

tree "ETH_PHY1__VENDOR_AUTONEG"
base e:0x4007f000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY1_VENDOR_AUTONEG_AUTONEG_CONFIG, None RESET:0x0"
         bitfld.long 0x00 1. " ETH_PHY1_VENDOR_AUTONEG_AUTONEG_CONFIG_PRNG_SEED ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY1_VENDOR_AUTONEG_AUTONEG_CONFIG_PHY_CONFIG ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "ETH_PHY1_VENDOR_AUTONEG_AUTONEG_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_VENDOR_AUTONEG_AUTONEG_STATUS_CONFIG_AS_MASTER ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_VENDOR_AUTONEG_AUTONEG_STATUS_MS_CONFIG_FAULT ,None RESET:0x0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "ETH_PHY1_VENDOR_AUTONEG_AUTONEG_PMA_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_VENDOR_AUTONEG_AUTONEG_PMA_STATUS_LINK_STATUS_E100T1 ,None RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "ETH_PHY1_VENDOR_AUTONEG_AUTONEG_MODE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_VENDOR_AUTONEG_AUTONEG_MODE_LINK_CONTROL_E100T1 ,None RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "ETH_PHY1_VENDOR_AUTONEG_AUTONEG_PAUSE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_VENDOR_AUTONEG_AUTONEG_PAUSE_TRANSMIT ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY1_VENDOR_AUTONEG_AUTONEG_PAUSE_RECEIVE ,None RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "ETH_PHY1_VENDOR_AUTONEG_AUTONEG_RX_TRANSLATION_THRESHOLD_ENABLE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_VENDOR_AUTONEG_AUTONEG_RX_TRANSLATION_THRESHOLD_ENABLE_SLOPE_THRESHOLD_EN ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "ETH_PHY1_VENDOR_AUTONEG_AUTONEG_RX_TRANSLATION_THRESHOLD_CONFIG, None RESET:0x2d061416"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY1_VENDOR_AUTONEG_AUTONEG_RX_TRANSLATION_THRESHOLD_CONFIG_QUIET_THRESHOLD_CNT ,None RESET:0x16"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY1_VENDOR_AUTONEG_AUTONEG_RX_TRANSLATION_THRESHOLD_CONFIG_QUIET_THRESHOLD ,None RESET:0x14"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY1_VENDOR_AUTONEG_AUTONEG_RX_TRANSLATION_THRESHOLD_CONFIG_SLOPE_THRESHOLD ,None RESET:0x6"
          
         hexmask.long 0x00 24.--31. 1. " ETH_PHY1_VENDOR_AUTONEG_AUTONEG_RX_TRANSLATION_THRESHOLD_CONFIG_TRANSITION_THRESHOLD ,None RESET:0x2d"
          
group.long  0x1c++0x3
    line.long 0x00 "ETH_PHY1_VENDOR_AUTONEG_AUTONEG_MR_NEXT_PAGE_LOADED, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY1_VENDOR_AUTONEG_AUTONEG_MR_NEXT_PAGE_LOADED_MR_NEXT_PAGE_LOADED ,None RESET:0x0"
          
tree.end

tree "ETH_PHY2"
base e:0x40080000
width 80.
tree.end

tree "ETH_PHY2__IEEE_PMA_PMD"
base e:0x40080000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_CONTROL_1, None RESET:0x2000"
         bitfld.long 0x00 0. " ETH_PHY2_IEEE_PMA_PMD_CONTROL_1_PMA_LOCAL_LOOPBACK ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_IEEE_PMA_PMD_CONTROL_1_PMA_REMOTE_LOOPBACK ,None RESET:0x0" "FALSE-0"
          
         hexmask.long 0x00 2.--5. 1. " ETH_PHY2_IEEE_PMA_PMD_CONTROL_1_SPEED_SELECTION ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ETH_PHY2_IEEE_PMA_PMD_CONTROL_1_SPEED_SELECTION_MSB ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 11. " ETH_PHY2_IEEE_PMA_PMD_CONTROL_1_LOW_POWER ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_PMA_PMD_CONTROL_1_SPEED_SELECTION_LSB ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 15. " ETH_PHY2_IEEE_PMA_PMD_CONTROL_1_RESET ,None RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_STATUS_1, None RESET:0x2"
         bitfld.long 0x00 1. " ETH_PHY2_IEEE_PMA_PMD_STATUS_1_LOW_POWER_ABILITY ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 2. " ETH_PHY2_IEEE_PMA_PMD_STATUS_1_RECEIVE_LINK_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY2_IEEE_PMA_PMD_STATUS_1_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_IEEE_PMA_PMD_STATUS_1_PEASA ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 9. " ETH_PHY2_IEEE_PMA_PMD_STATUS_1_PIASA ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_DEVICE_IDENTIFIER_1, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_IEEE_PMA_PMD_DEVICE_IDENTIFIER_1_OUI ,None RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_DEVICE_IDENTIFIER_2, None RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY2_IEEE_PMA_PMD_DEVICE_IDENTIFIER_2_REVISION ,None RESET:0x0"
          
         hexmask.long 0x00 4.--9. 1. " ETH_PHY2_IEEE_PMA_PMD_DEVICE_IDENTIFIER_2_MODEL ,None RESET:0x0"
          
         hexmask.long 0x00 10.--15. 1. " ETH_PHY2_IEEE_PMA_PMD_DEVICE_IDENTIFIER_2_OUI ,None RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_SPEED_ABILITY, None RESET:0x20"
         bitfld.long 0x00 0. " ETH_PHY2_IEEE_PMA_PMD_SPEED_ABILITY_E10G_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 1. " ETH_PHY2_IEEE_PMA_PMD_SPEED_ABILITY_E2BASE_TL_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 2. " ETH_PHY2_IEEE_PMA_PMD_SPEED_ABILITY_E10PASS_TS_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 4. " ETH_PHY2_IEEE_PMA_PMD_SPEED_ABILITY_E1000M_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY2_IEEE_PMA_PMD_SPEED_ABILITY_E100M_CAPABLE ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 6. " ETH_PHY2_IEEE_PMA_PMD_SPEED_ABILITY_E10M_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY2_IEEE_PMA_PMD_SPEED_ABILITY_E10_1G_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 8. " ETH_PHY2_IEEE_PMA_PMD_SPEED_ABILITY_E40G_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 9. " ETH_PHY2_IEEE_PMA_PMD_SPEED_ABILITY_E100G_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 10. " ETH_PHY2_IEEE_PMA_PMD_SPEED_ABILITY_E10GPASS_XR_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 11. " ETH_PHY2_IEEE_PMA_PMD_SPEED_ABILITY_E25G_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_PMA_PMD_SPEED_ABILITY_E2D5G_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 15. " ETH_PHY2_IEEE_PMA_PMD_SPEED_ABILITY_E400G_CAPABLE ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1, None RESET:0x8a"
         bitfld.long 0x00 0. " ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_CLAUSE_22_REGISTERS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 1. " ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_PMD_PMA_PRESENT ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 2. " ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_WIS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 3. " ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_PCS_PRESENT ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 4. " ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_PHY_XS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_DTE_XS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 6. " ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_TC_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_AUTO_NEGOTIATION_PRESENT ,None RESET:0x1" "TRUE-1"
          
         hexmask.long 0x00 8.--11. 1. " ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_SEPARATED_PMA_PRESENT ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_OFDM ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_1_POWER_UNIT_PRESENT ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_2, None RESET:0x0"
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_2_CLAUSE_22_EXTENSION_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 14. " ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_2_VENDOR_SPECIFIC_DEVICE_1_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 15. " ETH_PHY2_IEEE_PMA_PMD_DEVICES_IN_PACKAGE_2_VENDOR_SPECIFIC_DEVICE_2_PRESENT ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_CONTROL_2, None RESET:0x3d"
         hexmask.long 0x00 0.--6. 1. " ETH_PHY2_IEEE_PMA_PMD_CONTROL_2_PMA_PMD_TYPE_SELECTION ,None RESET:0x3d"
          
         bitfld.long 0x00 8. " ETH_PHY2_IEEE_PMA_PMD_CONTROL_2_PEASE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 9. " ETH_PHY2_IEEE_PMA_PMD_CONTROL_2_PIASE ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_STATUS_2, None RESET:0x9201"
         bitfld.long 0x00 0. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_PMA_LOCAL_LOOPBACK_ABILITY ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 1. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_E10GBASE_EW_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 2. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_E10GBASE_LW_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 3. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_E10GBASE_SW_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 4. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_E10GBASE_LX4_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_E10GBASE_ER_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 6. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_E10GBASE_LR_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_E10GBASE_SR_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 8. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_PMD_TRANSMIT_DISABLE_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 9. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_EXTENDED_ABILITIES ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 10. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_RECEIVE_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_TRANSMIT_FAULT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 12. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_RECEIVE_FAULT_ABILITY ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_TRANSMIT_FAULT_ABILITY ,None RESET:0x0" "FALSE-0"
          
         hexmask.long 0x00 14.--15. 1. " ETH_PHY2_IEEE_PMA_PMD_STATUS_2_DEVICE_PRESENT ,None RESET:0x2"
          
rgroup.long 0x28++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_PMD_RECEIVE_SIGNAL_DETECT, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_IEEE_PMA_PMD_PMD_RECEIVE_SIGNAL_DETECT_GLOBAL_PMD_RECEIVE_SIGNAL_DETECT ,None RESET:0x0"
          
         hexmask.long 0x00 1.--15. 1. " ETH_PHY2_IEEE_PMA_PMD_PMD_RECEIVE_SIGNAL_DETECT_PMD_RECEIVE_SIGNAL_DETECT ,None RESET:0x0"
          
rgroup.long 0x2c++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY, None RESET:0x800"
         bitfld.long 0x00 0. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_E10GBASE_CX4_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 1. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_E10GBASE_LRM_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 2. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_E10GBASE_T_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 3. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_E10GBASE_KX4_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 4. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_E10GBASE_KR_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_E1000BASE_T_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 6. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_E1000BASE_KX_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_E100BASE_TX_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 8. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_E10BASE_T_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 9. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_P2MP_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 10. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_E40G_100G_EXTENDED_ABILITIES ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 11. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_BASE_T1_EXTENDED_ABILITIES ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 12. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_E25G_EXTENDED_ABILITIES ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_E200G_400G_EXTENDED_ABILITIES ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 14. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_E2D5G_5G_EXTENDED_ABILITIES ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 15. " ETH_PHY2_IEEE_PMA_PMD_EXTENDED_ABILITY_BASE_H_EXTENDED_ABILITIES ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x38++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_PACKAGE_IDENTIFIER_1, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_IEEE_PMA_PMD_PACKAGE_IDENTIFIER_1_OUI ,None RESET:0x0"
          
rgroup.long 0x3c++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_PACKAGE_IDENTIFIER_2, None RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY2_IEEE_PMA_PMD_PACKAGE_IDENTIFIER_2_REVISION ,None RESET:0x0"
          
         hexmask.long 0x00 4.--9. 1. " ETH_PHY2_IEEE_PMA_PMD_PACKAGE_IDENTIFIER_2_MODEL ,None RESET:0x0"
          
         hexmask.long 0x00 10.--15. 1. " ETH_PHY2_IEEE_PMA_PMD_PACKAGE_IDENTIFIER_2_OUI ,None RESET:0x0"
          
rgroup.long 0x48++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY, None RESET:0x1"
         bitfld.long 0x00 0. " ETH_PHY2_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY_E100BASE_T1_ABILITY ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 1. " ETH_PHY2_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY_E1000BASE_T1_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 2. " ETH_PHY2_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY_E10BASE_T1L_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 3. " ETH_PHY2_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY_E10BASE_T1S_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 4. " ETH_PHY2_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY_E2D5GBASE_T1_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY2_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY_E5GBASE_T1_ABILITY ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 6. " ETH_PHY2_IEEE_PMA_PMD_BASE_T1_PMA_PMD_EXTENDED_ABILITY_E10GBASE_T1_ABILITY ,None RESET:0x0" "FALSE-0"
          
group.long  0x8d0++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_BASE_T1_PMA_PMD_CONTROL, None RESET:0x8000"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY2_IEEE_PMA_PMD_BASE_T1_PMA_PMD_CONTROL_TYPE_SELECTION ,None RESET:0x0"
          
         bitfld.long 0x00 14. " ETH_PHY2_IEEE_PMA_PMD_BASE_T1_PMA_PMD_CONTROL_MASTER_SLAVE_CONFIG_VALUE ,None RESET:0x0"
          
          
group.long  0x8d8++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PMA_PMD_E100BASE_T1_PMA_PMD_TEST_CONTROL, None RESET:0x0"
         hexmask.long 0x00 13.--15. 1. " ETH_PHY2_IEEE_PMA_PMD_E100BASE_T1_PMA_PMD_TEST_CONTROL_MODE ,None RESET:0x0"
          
tree.end

tree "ETH_PHY2__ECMT1_PMD"
base e:0x40081000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_LDRV_ENFORCE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_ECMT1_PMD_LDRV_ENFORCE_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_ECMT1_PMD_LDRV_ENFORCE_ZERO_SYMBOL ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_ECMT1_PMD_LDRV_ENFORCE_HYB_OFF ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_ECMT1_PMD_LDRV_ENFORCE_HYB_ON ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY2_ECMT1_PMD_LDRV_ENFORCE_SET_MAN_RES ,None RESET:0x0"
          
         hexmask.long 0x00 5.--12. 1. " ETH_PHY2_ECMT1_PMD_LDRV_ENFORCE_MAN_RES ,None RESET:0x0"
          
         hexmask.long 0x00 13.--20. 1. " ETH_PHY2_ECMT1_PMD_LDRV_ENFORCE_MAN_RES_REP ,None RESET:0x0"
          
         bitfld.long 0x00 21. " ETH_PHY2_ECMT1_PMD_LDRV_ENFORCE_SET_CH1_NCH2 ,None RESET:0x0"
          
         bitfld.long 0x00 23. " ETH_PHY2_ECMT1_PMD_LDRV_ENFORCE_SET_MAN_RES_REP ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_LDRV_MAN_0, None RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY2_ECMT1_PMD_LDRV_MAN_0_POS ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_LDRV_MAN_1, None RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY2_ECMT1_PMD_LDRV_MAN_1_NEG ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_LDRV_CAL_CONFIG, None RESET:0x644f8"
         bitfld.long 0x00 0. " ETH_PHY2_ECMT1_PMD_LDRV_CAL_CONFIG_RESET_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_ECMT1_PMD_LDRV_CAL_CONFIG_ENABLE_CONFIG ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_ECMT1_PMD_LDRV_CAL_CONFIG_INV_CMP ,None RESET:0x0"
          
         hexmask.long 0x00 3.--4. 1. " ETH_PHY2_ECMT1_PMD_LDRV_CAL_CONFIG_WINDOW_SIZE ,None RESET:0x3"
          
         hexmask.long 0x00 5.--8. 1. " ETH_PHY2_ECMT1_PMD_LDRV_CAL_CONFIG_NR_CMP_SETTLE ,None RESET:0x7"
          
         hexmask.long 0x00 9.--12. 1. " ETH_PHY2_ECMT1_PMD_LDRV_CAL_CONFIG_INCREMENT ,None RESET:0x2"
          
         hexmask.long 0x00 13.--19. 1. " ETH_PHY2_ECMT1_PMD_LDRV_CAL_CONFIG_START_VALUE_RES ,None RESET:0x32"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_CM_CLAMP_CONFIG, None RESET:0x7"
         bitfld.long 0x00 0. " ETH_PHY2_ECMT1_PMD_CM_CLAMP_CONFIG_ENABLE ,None RESET:0x1"
          
         hexmask.long 0x00 1.--3. 1. " ETH_PHY2_ECMT1_PMD_CM_CLAMP_CONFIG_CNT ,None RESET:0x3"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY2_ECMT1_PMD_CM_CLAMP_CONFIG_ENABLE_OVR ,None RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY2_ECMT1_PMD_CM_CLAMP_CONFIG_DISABLE_OVR ,None RESET:0x0"
          
         bitfld.long 0x00 30. " ETH_PHY2_ECMT1_PMD_CM_CLAMP_CONFIG_REF_CM_POL ,None RESET:0x0"
          
         bitfld.long 0x00 31. " ETH_PHY2_ECMT1_PMD_CM_CLAMP_CONFIG_REF_CM_SET ,None RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_CM_CLAMP_ADAPT_CONFIG, None RESET:0x9e"
         bitfld.long 0x00 0. " ETH_PHY2_ECMT1_PMD_CM_CLAMP_ADAPT_CONFIG_ENABLE ,None RESET:0x0"
          
         hexmask.long 0x00 1.--5. 1. " ETH_PHY2_ECMT1_PMD_CM_CLAMP_ADAPT_CONFIG_WAIT_OUT_CYCLES ,None RESET:0xf"
          
         hexmask.long 0x00 6.--8. 1. " ETH_PHY2_ECMT1_PMD_CM_CLAMP_ADAPT_CONFIG_RST_CF_CYCLES ,None RESET:0x2"
          
         bitfld.long 0x00 9. " ETH_PHY2_ECMT1_PMD_CM_CLAMP_ADAPT_CONFIG_RST_MAX_ADAPT_CNT ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY2_ECMT1_PMD_CM_CLAMP_ADAPT_CONFIG_DEBUG ,None RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_CM_CLAMP_STATUS, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY2_ECMT1_PMD_CM_CLAMP_STATUS_CLIPPING_FLAGS ,None RESET:0x0"
          
         hexmask.long 0x00 8.--10. 1. " ETH_PHY2_ECMT1_PMD_CM_CLAMP_STATUS_ACT_ADAPT_SCLICE_CNT ,None RESET:0x0"
          
         hexmask.long 0x00 11.--13. 1. " ETH_PHY2_ECMT1_PMD_CM_CLAMP_STATUS_MAX_ADAPT_SCLICE_CNT ,None RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_LDRV_TIMER, None RESET:0xa"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY2_ECMT1_PMD_LDRV_TIMER_ADJ_TIMER_CM_STARTUP ,None RESET:0xa"
          
group.long  0x20++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_LDRV_MUX, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_ECMT1_PMD_LDRV_MUX_TCLK_FWD_SEL ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_ECMT1_PMD_LDRV_MUX_TCLK_SEL ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ETH_PHY2_ECMT1_PMD_LDRV_MUX_MAN_SEL ,None RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_LDRV_RESCAL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_ECMT1_PMD_LDRV_RESCAL_READY ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_ECMT1_PMD_LDRV_RESCAL_TIMEOUT ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_ECMT1_PMD_LDRV_RESCAL_IDLE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_ECMT1_PMD_LDRV_RESCAL_SINGLE ,None RESET:0x0"
          
         hexmask.long 0x00 15.--25. 1. " ETH_PHY2_ECMT1_PMD_LDRV_RESCAL_VALUE ,None RESET:0x0"
          
         bitfld.long 0x00 26. " ETH_PHY2_ECMT1_PMD_LDRV_RESCAL_LDRV_CH1_OVERFLOW ,None RESET:0x0"
          
         bitfld.long 0x00 27. " ETH_PHY2_ECMT1_PMD_LDRV_RESCAL_LDRV_CH2_OVERFLOW ,None RESET:0x0"
          
         bitfld.long 0x00 28. " ETH_PHY2_ECMT1_PMD_LDRV_RESCAL_LDRV_CH1_UNDERFLOW ,None RESET:0x0"
          
         bitfld.long 0x00 29. " ETH_PHY2_ECMT1_PMD_LDRV_RESCAL_LDRV_CH2_UNDERFLOW ,None RESET:0x0"
          
         bitfld.long 0x00 30. " ETH_PHY2_ECMT1_PMD_LDRV_RESCAL_LDRV_CMP_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 31. " ETH_PHY2_ECMT1_PMD_LDRV_RESCAL_LDRV_RES_LOW_FLAG ,None RESET:0x0"
          
rgroup.long 0x28++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_LDRV_CAL_CH1_CH2, None RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " ETH_PHY2_ECMT1_PMD_LDRV_CAL_CH1_CH2_AVG_N_RES_CH1 ,None RESET:0x0"
          
         hexmask.long 0x00 16.--26. 1. " ETH_PHY2_ECMT1_PMD_LDRV_CAL_CH1_CH2_AVG_N_RES_CH2 ,None RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_ANA_TESTMUX, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_ECMT1_PMD_ANA_TESTMUX_EN ,None RESET:0x0"
          
         hexmask.long 0x00 1.--4. 1. " ETH_PHY2_ECMT1_PMD_ANA_TESTMUX_SEL ,None RESET:0x0"
          
rgroup.long 0x30++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_ESD_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_ECMT1_PMD_ESD_STATUS_EVH_P_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_ECMT1_PMD_ESD_STATUS_EVL_P_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_ECMT1_PMD_ESD_STATUS_EVH_N_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_ECMT1_PMD_ESD_STATUS_EVL_N_STATUS ,None RESET:0x0"
          
rgroup.long 0x34++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_ESD_EVENT, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_ECMT1_PMD_ESD_EVENT_COUNT ,None RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_ESD_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_ECMT1_PMD_ESD_CONTROL_ESD_COUNT_CLR ,None RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "ETH_PHY2_ECMT1_PMD_CABLE_DIAG_CONFIG, None RESET:0x20303"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY2_ECMT1_PMD_CABLE_DIAG_CONFIG_PULSE_WIDTH ,None RESET:0x3"
          
         hexmask.long 0x00 4.--13. 1. " ETH_PHY2_ECMT1_PMD_CABLE_DIAG_CONFIG_DETECTION_THRESHOLD ,None RESET:0x30"
          
         hexmask.long 0x00 14.--18. 1. " ETH_PHY2_ECMT1_PMD_CABLE_DIAG_CONFIG_PRETEST_THRESHOLD ,None RESET:0x8"
          
tree.end

tree "ETH_PHY2__E100T1_PMD"
base e:0x40081080
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_0, None RESET:0x20022804"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_0_CI ,None RESET:0x4"
          
         hexmask.long 0x00 5.--12. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_0_CP ,None RESET:0x40"
          
         bitfld.long 0x00 13. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_0_MAIN_DIV_N1 ,None RESET:0x1"
          
         hexmask.long 0x00 14.--15. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_0_MAIN_DIV_N2 ,None RESET:0x0"
          
         hexmask.long 0x00 16.--17. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_0_MAIN_DIV_N3 ,None RESET:0x2"
          
         hexmask.long 0x00 18.--19. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_0_MAIN_DIV_N4 ,None RESET:0x0"
          
         hexmask.long 0x00 20.--21. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_0_OUTDIV ,None RESET:0x0"
          
         hexmask.long 0x00 22.--29. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_0_FT ,None RESET:0x80"
          
         bitfld.long 0x00 30. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_0_EN_CTRL ,None RESET:0x0"
          
         bitfld.long 0x00 31. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_0_EN_OVR ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1, None RESET:0x4120"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_DIVCORE ,None RESET:0x0"
          
         hexmask.long 0x00 2.--7. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_CT ,None RESET:0x8"
          
         bitfld.long 0x00 8. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_AUTO_CT ,None RESET:0x1"
          
         bitfld.long 0x00 9. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_ENFORCE_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_PFD_SELECT ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_LOCK_WINDOW ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_DIVCORE_SEL ,None RESET:0x0"
          
         hexmask.long 0x00 13.--14. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_FILTER_SHIFT ,None RESET:0x2"
          
         bitfld.long 0x00 15. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_FAST_LOCK ,None RESET:0x0"
          
         hexmask.long 0x00 16.--18. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_SAR_LIMIT ,None RESET:0x0"
          
         bitfld.long 0x00 19. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_SET_OP_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 20. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_DISABLE_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 21. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_REF_BYPASS ,None RESET:0x0"
          
         bitfld.long 0x00 22. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_BIST_MODE ,None RESET:0x0"
          
         bitfld.long 0x00 23. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_CT_COMPENSATION ,None RESET:0x0"
          
         bitfld.long 0x00 24. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_OPEN_LOOP ,None RESET:0x0"
          
         bitfld.long 0x00 25. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_CFG_1_LDO_EN_OVR ,None RESET:0x0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_ADPLL_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_STATUS_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_STATUS_FT_OF ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_STATUS_FT_UF ,None RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_STATUS_FT ,None RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_STATUS_STATE ,None RESET:0x0"
          
         hexmask.long 0x00 13.--18. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_STATUS_COARSETUNE ,None RESET:0x0"
          
         bitfld.long 0x00 19. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_STATUS_CT_OF ,None RESET:0x0"
          
         bitfld.long 0x00 20. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_STATUS_CT_UF ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_ADPLL_STATUS_CAPTURE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_STATUS_CAPTURE_REQ ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_ADPLL_STARTUP, None RESET:0x29"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_STARTUP_ADJ_TIMER_EN_BANDGAP ,None RESET:0x1"
          
         hexmask.long 0x00 2.--3. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_STARTUP_ADJ_TIMER_EN_PLLLDO ,None RESET:0x2"
          
         hexmask.long 0x00 4.--5. 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_STARTUP_ADJ_TIMER_EN_PLL ,None RESET:0x2"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_ADPLL_BIST_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_BIST_STATUS_BUSY ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_BIST_STATUS_FAIL_COARSE ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_E100T1_PMD_E100M_ADPLL_BIST_STATUS_FAIL_FINE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_PI_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMD_E100M_PI_CONTROL_PI_RESET_SW ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_E100T1_PMD_E100M_PI_CONTROL_PI_RESET_OVR ,None RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_FBIST_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMD_E100M_FBIST_CONTROL_EN ,None RESET:0x0"
          
         hexmask.long 0x00 1.--3. 1. " ETH_PHY2_E100T1_PMD_E100M_FBIST_CONTROL_SRC_SEL ,None RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " ETH_PHY2_E100T1_PMD_E100M_FBIST_CONTROL_PRESCALER ,None RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " ETH_PHY2_E100T1_PMD_E100M_FBIST_CONTROL_COUNTER_CHECK_RANGE ,None RESET:0x0"
          
         hexmask.long 0x00 12.--28. 1. " ETH_PHY2_E100T1_PMD_E100M_FBIST_CONTROL_COUNTER_CHECK_VALUE ,None RESET:0x0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_FBIST_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMD_E100M_FBIST_STATUS_PASSED ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_E100T1_PMD_E100M_FBIST_STATUS_COUNTER_DONE ,None RESET:0x0"
          
         hexmask.long 0x00 2.--18. 1. " ETH_PHY2_E100T1_PMD_E100M_FBIST_STATUS_COUNTER_RESULT ,None RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_ADC_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMD_E100M_ADC_CONTROL_AMPLIFIER_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_E100T1_PMD_E100M_ADC_CONTROL_ADC_ENABLE ,None RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_ADC_CALIBRATION, None RESET:0x3c00"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMD_E100M_ADC_CALIBRATION_OFFSET_CORRECTION_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_E100T1_PMD_E100M_ADC_CALIBRATION_OFFSET_CORRECTION_OVERWRITE ,None RESET:0x0"
          
         hexmask.long 0x00 2.--7. 1. " ETH_PHY2_E100T1_PMD_E100M_ADC_CALIBRATION_OFFSET_CORRECTION_OVERWRITE_VALUES ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_E100T1_PMD_E100M_ADC_CALIBRATION_BWT_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY2_E100T1_PMD_E100M_ADC_CALIBRATION_BWT_OVERWRITE ,None RESET:0x0"
          
         hexmask.long 0x00 10.--14. 1. " ETH_PHY2_E100T1_PMD_E100M_ADC_CALIBRATION_BWT_OVERWRITE_VALUES ,None RESET:0xf"
          
rgroup.long 0x2c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_ADC_STATUS, None RESET:0x0"
         hexmask.long 0x00 1.--6. 1. " ETH_PHY2_E100T1_PMD_E100M_ADC_STATUS_OFFSET_CORRECTION_RESULTS ,None RESET:0x0"
          
         hexmask.long 0x00 7.--9. 1. " ETH_PHY2_E100T1_PMD_E100M_ADC_STATUS_OFFSET_CORRECTION_STATUS ,None RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY2_E100T1_PMD_E100M_ADC_STATUS_BWT_RESULT ,None RESET:0x0"
          
         bitfld.long 0x00 24. " ETH_PHY2_E100T1_PMD_E100M_ADC_STATUS_BWT_RDY ,None RESET:0x0"
          
         bitfld.long 0x00 25. " ETH_PHY2_E100T1_PMD_E100M_ADC_STATUS_BWT_OF ,None RESET:0x0"
          
         bitfld.long 0x00 26. " ETH_PHY2_E100T1_PMD_E100M_ADC_STATUS_BWT_UF ,None RESET:0x0"
          
         bitfld.long 0x00 27. " ETH_PHY2_E100T1_PMD_E100M_ADC_STATUS_BWT_BIST ,None RESET:0x0"
          
rgroup.long 0x30++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_ADC_OUTPUT, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY2_E100T1_PMD_E100M_ADC_OUTPUT_CONVERSION_RESULT ,None RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_ADC_STARTUP, None RESET:0x55"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY2_E100T1_PMD_E100M_ADC_STARTUP_ADJ_TIMER_EN_VDDA08 ,None RESET:0x1"
          
         hexmask.long 0x00 2.--3. 1. " ETH_PHY2_E100T1_PMD_E100M_ADC_STARTUP_ADJ_TIMER_EN_REFBUF ,None RESET:0x1"
          
         hexmask.long 0x00 4.--5. 1. " ETH_PHY2_E100T1_PMD_E100M_ADC_STARTUP_ADJ_TIMER_EN_BWT_TOUT ,None RESET:0x1"
          
         hexmask.long 0x00 6.--7. 1. " ETH_PHY2_E100T1_PMD_E100M_ADC_STARTUP_ADJ_TIMER_AMP_ENABLE ,None RESET:0x1"
          
group.long  0x38++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_ADC_POWER_SUPPLY, None RESET:0xf0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMD_E100M_ADC_POWER_SUPPLY_BAND_GAP_ENFORCE_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_E100T1_PMD_E100M_ADC_POWER_SUPPLY_REF_BUFFER_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_E100T1_PMD_E100M_ADC_POWER_SUPPLY_VDDA_ENABLE ,None RESET:0x0"
          
         hexmask.long 0x00 4.--8. 1. " ETH_PHY2_E100T1_PMD_E100M_ADC_POWER_SUPPLY_TRIMM_REFERENCE ,None RESET:0xf"
          
         hexmask.long 0x00 16.--17. 1. " ETH_PHY2_E100T1_PMD_E100M_ADC_POWER_SUPPLY_TEST_MUX_SEL ,None RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_TCLK_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMD_E100M_TCLK_CONTROL_CORE_EN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_E100T1_PMD_E100M_TCLK_CONTROL_FWD_EN_DOWN ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_E100T1_PMD_E100M_TCLK_CONTROL_FWD_EN_UP ,None RESET:0x0"
          
rgroup.long 0x40++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_PMD_CTRL_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMD_E100M_PMD_CTRL_STATUS_ADPLL_EN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_E100T1_PMD_E100M_PMD_CTRL_STATUS_ADPLL_LDO_EN ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_E100T1_PMD_E100M_PMD_CTRL_STATUS_LDRV_HYB_ON ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_E100T1_PMD_E100M_PMD_CTRL_STATUS_LDRV_FORCE_CM ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY2_E100T1_PMD_E100M_PMD_CTRL_STATUS_LDRV_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ETH_PHY2_E100T1_PMD_E100M_PMD_CTRL_STATUS_LDRV_CAL_START ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ETH_PHY2_E100T1_PMD_E100M_PMD_CTRL_STATUS_ADC_AMP_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY2_E100T1_PMD_E100M_PMD_CTRL_STATUS_ADC_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_E100T1_PMD_E100M_PMD_CTRL_STATUS_ADC_EN_VDDA08 ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY2_E100T1_PMD_E100M_PMD_CTRL_STATUS_ADC_EN_REFBUF ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY2_E100T1_PMD_E100M_PMD_CTRL_STATUS_ADC_EN_BG ,None RESET:0x0"
          
rgroup.long 0x44++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_PMD_FAIL_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMD_E100M_PMD_FAIL_STATUS_ADPLL_FAILED ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_E100T1_PMD_E100M_PMD_FAIL_STATUS_ADC_FAILED ,None RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_PMD_FAIL_CONTROL, None RESET:0x1"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMD_E100M_PMD_FAIL_CONTROL_FAIL_CONFIG ,None RESET:0x1"
          
rgroup.long 0x4c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_PI_TEST, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY2_E100T1_PMD_E100M_PI_TEST_SEL_PHASEA ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_E100T1_PMD_E100M_PI_TEST_SEL_PHASEA_PRE ,None RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " ETH_PHY2_E100T1_PMD_E100M_PI_TEST_SEL_WEIGHTA ,None RESET:0x0"
          
         hexmask.long 0x00 16.--17. 1. " ETH_PHY2_E100T1_PMD_E100M_PI_TEST_SEL_PHASEB ,None RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " ETH_PHY2_E100T1_PMD_E100M_PI_TEST_SEL_WEIGHTB ,None RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_LDRV_SET_MUX_0, None RESET:0xa42129"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY2_E100T1_PMD_E100M_LDRV_SET_MUX_0_VALUE ,None RESET:0xa42129"
          
group.long  0x64++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_LDRV_SET_MUX_1, None RESET:0x6b39d4"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY2_E100T1_PMD_E100M_LDRV_SET_MUX_1_VALUE ,None RESET:0x6b39d4"
          
group.long  0x68++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_LDRV_SET_MUX_4, None RESET:0x4a021"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY2_E100T1_PMD_E100M_LDRV_SET_MUX_4_VALUE ,None RESET:0x4a021"
          
group.long  0x6c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_LDRV_CODE_SELECT_0, None RESET:0x451440"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY2_E100T1_PMD_E100M_LDRV_CODE_SELECT_0_VALUE ,None RESET:0x451440"
          
group.long  0x70++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_LDRV_SET_MUX_2, None RESET:0x4a5619"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY2_E100T1_PMD_E100M_LDRV_SET_MUX_2_VALUE ,None RESET:0x4a5619"
          
group.long  0x74++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_LDRV_CODE_SELECT_1, None RESET:0x451011"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY2_E100T1_PMD_E100M_LDRV_CODE_SELECT_1_VALUE ,None RESET:0x451011"
          
group.long  0x78++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_LDRV_SET_MUX_3, None RESET:0xbdc46b"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY2_E100T1_PMD_E100M_LDRV_SET_MUX_3_VALUE ,None RESET:0xbdc46b"
          
group.long  0x7c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMD_E100M_LDRV_CODE_SELECT_2, None RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY2_E100T1_PMD_E100M_LDRV_CODE_SELECT_2_VALUE ,None RESET:0x0"
          
tree.end

tree "ETH_PHY2__E100T1_PMA"
base e:0x40081200
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMA_E100M_STATUS_ADFE_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_E100T1_PMA_E100M_STATUS_TR_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_E100T1_PMA_E100M_STATUS_LOC_RCVR_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY2_E100T1_PMA_E100M_STATUS_REM_RCVR_STATUS_OK ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY2_E100T1_PMA_E100M_STATUS_LINK_STATUS ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_CTRL, None RESET:0x100"
         bitfld.long 0x00 8. " ETH_PHY2_E100T1_PMA_E100M_CTRL_PHY_LOOPBACK ,None RESET:0x1"
          
group.long  0x8++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL, None RESET:0x2ba3"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL_PMA_DFE_MSE_ADAPT ,None RESET:0x1"
          
         bitfld.long 0x00 1. " ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL_PMA_EC_MSE_ADAPT ,None RESET:0x1"
          
         bitfld.long 0x00 2. " ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL_PMA_SCR_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL_PMA_LINK_RECOVER ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL_PMA_ADAPT_MMM ,None RESET:0x1"
          
         bitfld.long 0x00 6. " ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL_PMA_EC_EARLY_ADAPT ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL_PMA_DFE_ADAPT ,None RESET:0x1"
          
         bitfld.long 0x00 8. " ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL_PMA_DFETAP_CAPTURE ,None RESET:0x1"
          
         hexmask.long 0x00 9.--10. 1. " ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL_PMA_TR_EDALGORITHM_SEL ,None RESET:0x1"
          
         bitfld.long 0x00 11. " ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL_PMA_TR_MODE ,None RESET:0x1"
          
         bitfld.long 0x00 12. " ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL_PMA_DFE_EARLY_ADAPT ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL_PMA_BLD_ADAPT ,None RESET:0x1"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_PHY_CTRL, None RESET:0x900"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMA_E100M_PHY_CTRL_PHY_ADC_INVERT ,None RESET:0x0"
          
         hexmask.long 0x00 3.--12. 1. " ETH_PHY2_E100T1_PMA_E100M_PHY_CTRL_PHY_MAXWAIT_TIMER ,None RESET:0x120"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_LDRV_INV_OUTPUT, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMA_E100M_LDRV_INV_OUTPUT_VALUE ,None RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_LDRV_IF_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMA_E100M_LDRV_IF_STATUS_RD_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_E100T1_PMA_E100M_LDRV_IF_STATUS_WR_ERROR ,None RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_PMA_TIMEOUT, None RESET:0x4444444"
         hexmask.long 0x00 0.--2. 1. " ETH_PHY2_E100T1_PMA_E100M_PMA_TIMEOUT_SCR_LOCK ,None RESET:0x4"
          
         hexmask.long 0x00 4.--6. 1. " ETH_PHY2_E100T1_PMA_E100M_PMA_TIMEOUT_TR_MMM_ADAPT ,None RESET:0x4"
          
         hexmask.long 0x00 8.--10. 1. " ETH_PHY2_E100T1_PMA_E100M_PMA_TIMEOUT_TR_DFE_ADAPT ,None RESET:0x4"
          
         hexmask.long 0x00 12.--14. 1. " ETH_PHY2_E100T1_PMA_E100M_PMA_TIMEOUT_LMS_ADAPT ,None RESET:0x4"
          
         hexmask.long 0x00 16.--18. 1. " ETH_PHY2_E100T1_PMA_E100M_PMA_TIMEOUT_EC_ADAPT ,None RESET:0x4"
          
         hexmask.long 0x00 20.--22. 1. " ETH_PHY2_E100T1_PMA_E100M_PMA_TIMEOUT_RECOVERY ,None RESET:0x4"
          
         hexmask.long 0x00 24.--26. 1. " ETH_PHY2_E100T1_PMA_E100M_PMA_TIMEOUT_BLIND_ADAPT ,None RESET:0x4"
          
         bitfld.long 0x00 28. " ETH_PHY2_E100T1_PMA_E100M_PMA_TIMEOUT_BLIND_IS_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 29. " ETH_PHY2_E100T1_PMA_E100M_PMA_TIMEOUT_LMS_IS_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 30. " ETH_PHY2_E100T1_PMA_E100M_PMA_TIMEOUT_EC_IS_LOCK ,None RESET:0x0"
          
rgroup.long 0x24++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_MSE, None RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " ETH_PHY2_E100T1_PMA_E100M_MSE_VALUE ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY2_E100T1_PMA_E100M_MSE_VALID ,None RESET:0x0"
          
rgroup.long 0x28++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_MSE_WC, None RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " ETH_PHY2_E100T1_PMA_E100M_MSE_WC_VALUE ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY2_E100T1_PMA_E100M_MSE_WC_VALID ,None RESET:0x0"
          
rgroup.long 0x2c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_PEAK_MSE, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY2_E100T1_PMA_E100M_PEAK_MSE_CURRENT ,None RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY2_E100T1_PMA_E100M_PEAK_MSE_WORST ,None RESET:0x0"
          
rgroup.long 0x30++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_SQI, None RESET:0x0"
         hexmask.long 0x00 1.--3. 1. " ETH_PHY2_E100T1_PMA_E100M_SQI_CURRENT ,None RESET:0x0"
          
         hexmask.long 0x00 5.--7. 1. " ETH_PHY2_E100T1_PMA_E100M_SQI_WORST ,None RESET:0x0"
          
rgroup.long 0x34++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_ADFE_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMA_E100M_ADFE_STATUS_FFF_COEFF_SAT ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_STATUS_FBF_COEFF_SAT ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_E100T1_PMA_E100M_ADFE_STATUS_FFF_FLT_SAT ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY2_E100T1_PMA_E100M_ADFE_STATUS_FBF_FLT_SAT ,None RESET:0x0"
          
         bitfld.long 0x00 16. " ETH_PHY2_E100T1_PMA_E100M_ADFE_STATUS_RDCD_COEFF_SAT ,None RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_ADFE_FFF_COEFF_ADDR, None RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_FFF_COEFF_ADDR_VALUE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_E100T1_PMA_E100M_ADFE_FFF_COEFF_ADDR_EN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY2_E100T1_PMA_E100M_ADFE_FFF_COEFF_ADDR_RNW ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY2_E100T1_PMA_E100M_ADFE_FFF_COEFF_ADDR_ERROR ,None RESET:0x0"
          
rgroup.long 0x3c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_ADFE_FFF_COEFF_RDATA, None RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_FFF_COEFF_RDATA_VALUE ,None RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_ADFE_FFF_COEFF_WDATA, None RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_FFF_COEFF_WDATA_VALUE ,None RESET:0x0"
          
group.long  0x44++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_ADFE_FBF_COEFF_ADDR, None RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_FBF_COEFF_ADDR_VALUE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_E100T1_PMA_E100M_ADFE_FBF_COEFF_ADDR_EN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY2_E100T1_PMA_E100M_ADFE_FBF_COEFF_ADDR_RNW ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY2_E100T1_PMA_E100M_ADFE_FBF_COEFF_ADDR_ERROR ,None RESET:0x0"
          
rgroup.long 0x48++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_ADFE_FBF_COEFF_RDATA, None RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_FBF_COEFF_RDATA_VALUE ,None RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_ADFE_FBF_COEFF_WDATA, None RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_FBF_COEFF_WDATA_VALUE ,None RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG1, None RESET:0x4450404"
         hexmask.long 0x00 0.--2. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG1_FFF_CORR_STEP_SHIFT ,None RESET:0x4"
          
         hexmask.long 0x00 8.--10. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG1_FBF_CORR_STEP_SHIFT ,None RESET:0x4"
          
         hexmask.long 0x00 16.--18. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG1_BLD_CORR_STEP_SHIFT ,None RESET:0x5"
          
         hexmask.long 0x00 20.--22. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG1_TR_CORR_STEP_SHIFT ,None RESET:0x4"
          
         hexmask.long 0x00 24.--25. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG1_FFF_WEIGHT_SEL ,None RESET:0x0"
          
         hexmask.long 0x00 26.--27. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG1_FBF_WEIGHT_SEL ,None RESET:0x1"
          
group.long  0x54++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG2, None RESET:0x14d54554"
         hexmask.long 0x00 0.--2. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG2_LOCK_WINDOW ,None RESET:0x4"
          
         hexmask.long 0x00 3.--5. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG2_LOCK_COUNT ,None RESET:0x2"
          
         hexmask.long 0x00 6.--11. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG2_LOCK_TH ,None RESET:0x15"
          
         hexmask.long 0x00 14.--19. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG2_LOCK_BLD_TH ,None RESET:0x15"
          
         hexmask.long 0x00 20.--21. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG2_BLW_MODE ,None RESET:0x1"
          
         hexmask.long 0x00 22.--23. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG2_LOCK_BLD_TH_EN ,None RESET:0x3"
          
         hexmask.long 0x00 24.--26. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG2_LOCK_BLD_WINDOW ,None RESET:0x4"
          
         hexmask.long 0x00 27.--28. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG2_LOCK_BLD_CAPTURE ,None RESET:0x2"
          
         hexmask.long 0x00 29.--30. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG2_LOCK_BLD_COUNT ,None RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG3, None RESET:0x83"
         hexmask.long 0x00 0.--2. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG3_SD_CFG ,None RESET:0x3"
          
         hexmask.long 0x00 3.--8. 1. " ETH_PHY2_E100T1_PMA_E100M_ADFE_CFG3_SD_AVERAGE_TH ,None RESET:0x10"
          
group.long  0x5c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_EC_CFG, None RESET:0x4004"
         hexmask.long 0x00 0.--2. 1. " ETH_PHY2_E100T1_PMA_E100M_EC_CFG_STEP_SHIFT ,None RESET:0x4"
          
         hexmask.long 0x00 12.--15. 1. " ETH_PHY2_E100T1_PMA_E100M_EC_CFG_TX_DELAY ,None RESET:0x4"
          
group.long  0x60++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_EC_COEFF_ADDR, None RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " ETH_PHY2_E100T1_PMA_E100M_EC_COEFF_ADDR_VALUE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_E100T1_PMA_E100M_EC_COEFF_ADDR_EN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY2_E100T1_PMA_E100M_EC_COEFF_ADDR_RNW ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY2_E100T1_PMA_E100M_EC_COEFF_ADDR_ERROR ,None RESET:0x0"
          
rgroup.long 0x64++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_EC_COEFF_RDATA, None RESET:0x0"
         hexmask.long 0x00 0.--17. 1. " ETH_PHY2_E100T1_PMA_E100M_EC_COEFF_RDATA_VALUE ,None RESET:0x0"
          
group.long  0x68++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_EC_COEFF_WDATA, None RESET:0x0"
         hexmask.long 0x00 0.--17. 1. " ETH_PHY2_E100T1_PMA_E100M_EC_COEFF_WDATA_VALUE ,None RESET:0x0"
          
rgroup.long 0x6c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_EC_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMA_E100M_EC_STATUS_COEFF_SAT ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_E100T1_PMA_E100M_EC_STATUS_FLT_SAT ,None RESET:0x0"
          
group.long  0x70++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_TR_CONFIG, None RESET:0x1f0e0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_CONFIG_MODE ,None RESET:0xf0e0"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_CONFIG_PICTRL ,None RESET:0x1"
          
         bitfld.long 0x00 24. " ETH_PHY2_E100T1_PMA_E100M_TR_CONFIG_DEBUG ,None RESET:0x0"
          
         bitfld.long 0x00 28. " ETH_PHY2_E100T1_PMA_E100M_TR_CONFIG_ENABLE_EXTERNAL_STEP_CTRL ,None RESET:0x0"
          
group.long  0x74++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_TR_CURSOR_REF1, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_CURSOR_REF1_PRE ,None RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_CURSOR_REF1_POST ,None RESET:0x0"
          
group.long  0x78++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_TR_CURSOR_REF2, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_CURSOR_REF2_MAIN ,None RESET:0x0"
          
group.long  0x7c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_TR_TED, None RESET:0x60091"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_TED_THRESHOLD ,None RESET:0x1"
          
         hexmask.long 0x00 2.--3. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_TED_SEL_INTG ,None RESET:0x0"
          
         hexmask.long 0x00 4.--5. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_TED_SEL_INTGSLOW ,None RESET:0x1"
          
         hexmask.long 0x00 6.--7. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_TED_SEL_RESISI ,None RESET:0x2"
          
         hexmask.long 0x00 16.--17. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_TED_PM_SEL_INTG ,None RESET:0x2"
          
         hexmask.long 0x00 18.--19. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_TED_PPD_SEL_INTG ,None RESET:0x1"
          
group.long  0x80++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_TR_LOOP0, None RESET:0xc00800"
         hexmask.long 0x00 0.--12. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_LOOP0_CPROP ,None RESET:0x800"
          
         hexmask.long 0x00 16.--27. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_LOOP0_CINTG ,None RESET:0xc0"
          
group.long  0x84++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_TR_LOOP1, None RESET:0x80800"
         hexmask.long 0x00 0.--12. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_LOOP1_CPROP ,None RESET:0x800"
          
         hexmask.long 0x00 16.--27. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_LOOP1_CINTG ,None RESET:0x8"
          
group.long  0x88++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_TR_LOCK, None RESET:0x2471500"
         hexmask.long 0x00 8.--10. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_LOCK_WINSIZE ,None RESET:0x5"
          
         hexmask.long 0x00 11.--13. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_LOCK_PHASE_CAP ,None RESET:0x2"
          
         hexmask.long 0x00 14.--16. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_LOCK_PHASE_LCK ,None RESET:0x4"
          
         hexmask.long 0x00 17.--19. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_LOCK_FREQ_CAP ,None RESET:0x3"
          
         hexmask.long 0x00 20.--22. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_LOCK_FREQ_LCK ,None RESET:0x4"
          
         hexmask.long 0x00 23.--24. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_LOCK_PPM_CAP ,None RESET:0x0"
          
         hexmask.long 0x00 25.--26. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_LOCK_PPM_LCK ,None RESET:0x1"
          
rgroup.long 0x8c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_TR_ACCUM, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_ACCUM_PHASE_ACCUM ,None RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_ACCUM_FREQ_ACCUM ,None RESET:0x0"
          
group.long  0x90++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_TR_ACCUM_CONFIG, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_ACCUM_CONFIG_MODE ,None RESET:0x0"
          
         hexmask.long 0x00 8.--12. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_ACCUM_CONFIG_PHASE_MSB ,None RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETH_PHY2_E100T1_PMA_E100M_TR_ACCUM_CONFIG_FREQ_OFF ,None RESET:0x0"
          
group.long  0x94++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_TR_ACCUM_CONFIG_WRITE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMA_E100M_TR_ACCUM_CONFIG_WRITE_REQ ,None RESET:0x0"
          
rgroup.long 0x98++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_DBG_TR_STATUS, None RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY2_E100T1_PMA_E100M_DBG_TR_STATUS_FSM ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ETH_PHY2_E100T1_PMA_E100M_DBG_TR_STATUS_LOCKED ,None RESET:0x0"
          
         hexmask.long 0x00 8.--13. 1. " ETH_PHY2_E100T1_PMA_E100M_DBG_TR_STATUS_LOSTLCKDCNT ,None RESET:0x0"
          
group.long  0x9c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_DBG_CTRL_INIT_TRIGGER, None RESET:0xf"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY2_E100T1_PMA_E100M_DBG_CTRL_INIT_TRIGGER_STATE ,None RESET:0xf"
          
group.long  0xa0++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_DBG_CTRL_STATE_TRIGGER, None RESET:0xf"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY2_E100T1_PMA_E100M_DBG_CTRL_STATE_TRIGGER_STATE ,None RESET:0xf"
          
group.long  0xa8++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_DBG_SYMB_PAIR_TRIGGER, None RESET:0xf"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY2_E100T1_PMA_E100M_DBG_SYMB_PAIR_TRIGGER_VALUE ,None RESET:0xf"
          
group.long  0xac++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_ADC_IF_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMA_E100M_ADC_IF_CTRL_ADC_IF_ENABLE_OVR ,None RESET:0x0"
          
group.long  0xb0++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL_OVERRIDE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PMA_E100M_PMA_CTRL_OVERRIDE_CLKGEN_MASTER_OVERRIDE ,None RESET:0x0"
          
group.long  0xb4++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PMA_E100M_PMA_WATCHDOG, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY2_E100T1_PMA_E100M_PMA_WATCHDOG_WND_SCALE ,None RESET:0x0"
          
tree.end

tree "ETH_PHY2__RI_ABB"
base e:0x40081300
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY2_RI_ABB_ABB_CTRL_0, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_RI_ABB_ABB_CTRL_0_OVERRIDE ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_RI_ABB_ABB_CTRL_0_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_RI_ABB_ABB_CTRL_0_FORCE_LOCKED ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY2_RI_ABB_RI_ABB_CONFIG_0, None RESET:0x6383002"
         hexmask.long 0x00 0.--5. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_0_PVTMON_CYCLES ,None RESET:0x2"
          
         hexmask.long 0x00 6.--18. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_0_RINGO_TARGET_VAL_N ,None RESET:0xc0"
          
         hexmask.long 0x00 19.--31. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_0_RINGO_TARGET_VAL_P ,None RESET:0xc7"
          
group.long  0x8++0x3
    line.long 0x00 "ETH_PHY2_RI_ABB_RI_ABB_CONFIG_1, None RESET:0x233b263e"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_1_LOCK_RANGE_HIGH_P ,None RESET:0x3e"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_1_LOCK_RANGE_LOW_P ,None RESET:0x26"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_1_LOCK_RANGE_HIGH_N ,None RESET:0x3b"
          
         hexmask.long 0x00 24.--31. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_1_LOCK_RANGE_LOW_N ,None RESET:0x23"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY2_RI_ABB_RI_ABB_CONFIG_2, None RESET:0x30100"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_2_CP ,None RESET:0x100"
          
         hexmask.long 0x00 16.--18. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_2_CI_SEL ,None RESET:0x3"
          
         hexmask.long 0x00 19.--20. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_2_MAIN_TIMER_SEL ,None RESET:0x0"
          
         hexmask.long 0x00 21.--23. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_2_TESTMODE ,None RESET:0x0"
          
         hexmask.long 0x00 24.--25. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_2_PWM_SEL ,None RESET:0x0"
          
         hexmask.long 0x00 26.--27. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_2_MCHK_TOL_SEL ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY2_RI_ABB_RI_ABB_CONFIG_3, None RESET:0x3e00010d"
         hexmask.long 0x00 0.--2. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_3_SLOPE_CNT ,None RESET:0x5"
          
         hexmask.long 0x00 3.--5. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_3_FILTER_SHIFT ,None RESET:0x1"
          
         bitfld.long 0x00 6. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_3_LOCK_FAST_DISABLE ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_3_RCNT_BIST_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_3_BIAS_DIR ,None RESET:0x1"
          
         hexmask.long 0x00 24.--31. 1. " ETH_PHY2_RI_ABB_RI_ABB_CONFIG_3_CRC_VAL ,None RESET:0x3e"
          
group.long  0x14++0x3
    line.long 0x00 "ETH_PHY2_RI_ABB_ABB_STATUS_CAPTURE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_RI_ABB_ABB_STATUS_CAPTURE_GET_STATUS ,None RESET:0x0"
          
         hexmask.long 0x00 1.--3. 1. " ETH_PHY2_RI_ABB_ABB_STATUS_CAPTURE_STATUS_SEL ,None RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY2_RI_ABB_ABB_STATUS_0, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_RI_ABB_ABB_STATUS_0_LOCKED ,None RESET:0x0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "ETH_PHY2_RI_ABB_ABB_STATUS_1, None RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " ETH_PHY2_RI_ABB_ABB_STATUS_1_RINGO_COUNT_P ,None RESET:0x0"
          
         hexmask.long 0x00 13.--25. 1. " ETH_PHY2_RI_ABB_ABB_STATUS_1_RINGO_COUNT_N ,None RESET:0x0"
          
         bitfld.long 0x00 26. " ETH_PHY2_RI_ABB_ABB_STATUS_1_CRC_PASS ,None RESET:0x0"
          
         bitfld.long 0x00 27. " ETH_PHY2_RI_ABB_ABB_STATUS_1_MCHK_PASS ,None RESET:0x0"
          
         bitfld.long 0x00 28. " ETH_PHY2_RI_ABB_ABB_STATUS_1_BIST_PASS ,None RESET:0x0"
          
         bitfld.long 0x00 29. " ETH_PHY2_RI_ABB_ABB_STATUS_1_BIST_DONE ,None RESET:0x0"
          
         bitfld.long 0x00 30. " ETH_PHY2_RI_ABB_ABB_STATUS_1_BIST_AUX_PASS ,None RESET:0x0"
          
         bitfld.long 0x00 31. " ETH_PHY2_RI_ABB_ABB_STATUS_1_BIST_AUX_DONE ,None RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "ETH_PHY2_RI_ABB_ABB_CLKMON_TEST, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY2_RI_ABB_ABB_CLKMON_TEST_FORCED ,None RESET:0x0"
          
rgroup.long 0x24++0x3
    line.long 0x00 "ETH_PHY2_RI_ABB_ABB_CLKMON_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_RI_ABB_ABB_CLKMON_STATUS_CLK_RUNNING ,None RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "ETH_PHY2_RI_ABB_ABB_TMUX, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_RI_ABB_ABB_TMUX_EN ,None RESET:0x0"
          
tree.end

tree "ETH_PHY2__RF_CRC"
base e:0x40081400
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "ETH_PHY2_RF_CRC_CRC_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_RF_CRC_CRC_STATUS_DONE ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_RF_CRC_CRC_STATUS_MISMATCH ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY2_RF_CRC_CRC_EXPECTED_CHECKSUM, None RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETH_PHY2_RF_CRC_CRC_EXPECTED_CHECKSUM_VALUE ,None RESET:0x0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "ETH_PHY2_RF_CRC_CRC_CURRENT_CHECKSUM, None RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETH_PHY2_RF_CRC_CRC_CURRENT_CHECKSUM_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY2_RF_CRC_CRC_AUTO_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_RF_CRC_CRC_AUTO_CTRL_CRC_AUTO_EN_0 ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_RF_CRC_CRC_AUTO_CTRL_CRC_AUTO_EN_1 ,None RESET:0x0"
          
tree.end

tree "ETH_PHY2__IRQ"
base e:0x40081500
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "ETH_PHY2_IRQ_IRQ_FUNC_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_IRQ_IRQ_FUNC_STATUS_WOL ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_IRQ_IRQ_FUNC_STATUS_LINK_STATUS_CHANGED ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_IRQ_IRQ_FUNC_STATUS_ENERGY_DETECT ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY2_IRQ_IRQ_FUNC_STATUS_LINK_QUALITY ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ETH_PHY2_IRQ_IRQ_FUNC_STATUS_MST_SLV_TRAINING_COMPLETE ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY2_IRQ_IRQ_FUNC_STATUS_ENTERED_SLEEP_MODE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_IRQ_IRQ_FUNC_STATUS_ENTERED_SLEEP_FAIL ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY2_IRQ_IRQ_FUNC_STATUS_POLARITY_CHANGE ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY2_IRQ_IRQ_FUNC_STATUS_ERROR_COUNT ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ETH_PHY2_IRQ_IRQ_FUNC_STATUS_FALSE_CARRIER ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY2_IRQ_IRQ_FUNC_STATUS_ABB_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY2_IRQ_IRQ_FUNC_STATUS_PRBS_OVERFLOW ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY2_IRQ_IRQ_FUNC_MASK, None RESET:0x3fdb"
         bitfld.long 0x00 0. " ETH_PHY2_IRQ_IRQ_FUNC_MASK_MASK_WOL ,None RESET:0x1"
          
         bitfld.long 0x00 1. " ETH_PHY2_IRQ_IRQ_FUNC_MASK_MASK_LINK_STATUS_CHANGED ,None RESET:0x1"
          
         bitfld.long 0x00 3. " ETH_PHY2_IRQ_IRQ_FUNC_MASK_MASK_ENERGY_DETECT ,None RESET:0x1"
          
         bitfld.long 0x00 4. " ETH_PHY2_IRQ_IRQ_FUNC_MASK_MASK_LINK_QUALITY ,None RESET:0x1"
          
         bitfld.long 0x00 6. " ETH_PHY2_IRQ_IRQ_FUNC_MASK_MASK_MST_SLV_TRAINING_COMPLETE ,None RESET:0x1"
          
         bitfld.long 0x00 7. " ETH_PHY2_IRQ_IRQ_FUNC_MASK_MASK_ENTERED_SLEEP_MODE ,None RESET:0x1"
          
         bitfld.long 0x00 8. " ETH_PHY2_IRQ_IRQ_FUNC_MASK_MASK_ENTERED_SLEEP_FAIL ,None RESET:0x1"
          
         bitfld.long 0x00 9. " ETH_PHY2_IRQ_IRQ_FUNC_MASK_MASK_POLARITY_CHANGE ,None RESET:0x1"
          
         bitfld.long 0x00 10. " ETH_PHY2_IRQ_IRQ_FUNC_MASK_MASK_ERROR_COUNT ,None RESET:0x1"
          
         bitfld.long 0x00 11. " ETH_PHY2_IRQ_IRQ_FUNC_MASK_MASK_FALSE_CARRIER ,None RESET:0x1"
          
         bitfld.long 0x00 12. " ETH_PHY2_IRQ_IRQ_FUNC_MASK_MASK_ABB_ENABLE ,None RESET:0x1"
          
         bitfld.long 0x00 13. " ETH_PHY2_IRQ_IRQ_FUNC_MASK_MASK_PRBS_OVERFLOW ,None RESET:0x1"
          
group.long  0x8++0x3
    line.long 0x00 "ETH_PHY2_IRQ_IRQ_FUNC_CLEAR, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_IRQ_IRQ_FUNC_CLEAR_CLEAR_WOL ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_IRQ_IRQ_FUNC_CLEAR_CLEAR_LINK_STATUS_CHANGED ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_IRQ_IRQ_FUNC_CLEAR_CLEAR_ENERGY_DETECT ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY2_IRQ_IRQ_FUNC_CLEAR_CLEAR_LINK_QUALITY ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ETH_PHY2_IRQ_IRQ_FUNC_CLEAR_CLEAR_MST_SLV_TRAINING_COMPLETE ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY2_IRQ_IRQ_FUNC_CLEAR_CLEAR_ENTERED_SLEEP_MODE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_IRQ_IRQ_FUNC_CLEAR_CLEAR_ENTERED_SLEEP_FAIL ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY2_IRQ_IRQ_FUNC_CLEAR_CLEAR_POLARITY_CHANGE ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY2_IRQ_IRQ_FUNC_CLEAR_CLEAR_ERROR_COUNT ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ETH_PHY2_IRQ_IRQ_FUNC_CLEAR_CLEAR_FALSE_CARRIER ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY2_IRQ_IRQ_FUNC_CLEAR_CLEAR_ABB_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY2_IRQ_IRQ_FUNC_CLEAR_CLEAR_PRBS_OVERFLOW ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY2_IRQ_IRQ_FUNC_TEST, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_IRQ_IRQ_FUNC_TEST_IRQ_FUNC_TEST_TRIGGER ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_IRQ_IRQ_FUNC_TEST_IRQ_FUNC_TEST_TRIGGER_CLEAR ,None RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "ETH_PHY2_IRQ_IRQ_SAFE_TEMP_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_STATUS_JABBER_DETECT ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_STATUS_ESD_EVENT ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_STATUS_RX_MAC_VALIDATE_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_STATUS_TX_MAC_VALIDATE_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_STATUS_PMA_WATCHDOG ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_STATUS_APB_PAR_ERR ,None RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "ETH_PHY2_IRQ_IRQ_SAFE_TEMP_MASK, None RESET:0x9f"
         bitfld.long 0x00 0. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_MASK_MASK_JABBER_DETECT ,None RESET:0x1"
          
         bitfld.long 0x00 1. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_MASK_MASK_ESD_EVENT ,None RESET:0x1"
          
         bitfld.long 0x00 2. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_MASK_MASK_RX_MAC_VALIDATE_ERROR ,None RESET:0x1"
          
         bitfld.long 0x00 3. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_MASK_MASK_TX_MAC_VALIDATE_ERROR ,None RESET:0x1"
          
         bitfld.long 0x00 4. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_MASK_MASK_PMA_WATCHDOG ,None RESET:0x1"
          
         bitfld.long 0x00 7. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_MASK_MASK_APB_PAR_ERR ,None RESET:0x1"
          
group.long  0x18++0x3
    line.long 0x00 "ETH_PHY2_IRQ_IRQ_SAFE_TEMP_CLEAR, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_CLEAR_CLEAR_JABBER_DETECT ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_CLEAR_CLEAR_ESD_EVENT ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_CLEAR_CLEAR_RX_MAC_VALIDATE_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_CLEAR_CLEAR_TX_MAC_VALIDATE_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_CLEAR_CLEAR_PMA_WATCHDOG ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_CLEAR_CLEAR_APB_PAR_ERR ,None RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "ETH_PHY2_IRQ_IRQ_SAFE_TEMP_TEST, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_TEST_IRQ_SAFE_TEMP_TEST_TRIGGER ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_IRQ_IRQ_SAFE_TEMP_TEST_IRQ_SAFE_TEMP_TEST_TRIGGER_CLEAR ,None RESET:0x0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "ETH_PHY2_IRQ_IRQ_SAFE_FUND_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_IRQ_IRQ_SAFE_FUND_STATUS_REGFILE_CRC_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_IRQ_IRQ_SAFE_FUND_STATUS_PLL100_LOCK_LOSS ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ETH_PHY2_IRQ_IRQ_SAFE_FUND_STATUS_ABB_LOCK_LOSS ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ETH_PHY2_IRQ_IRQ_SAFE_FUND_STATUS_ABB_LATENT_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ETH_PHY2_IRQ_IRQ_SAFE_FUND_STATUS_LINEDRIVER_RESCAL ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_IRQ_IRQ_SAFE_FUND_STATUS_FSM_PARITY ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY2_IRQ_IRQ_SAFE_FUND_STATUS_S_FAIL ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY2_IRQ_IRQ_SAFE_FUND_STATUS_CLKMON_FAIL ,None RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "ETH_PHY2_IRQ_IRQ_SAFE_FUND_TEST, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_IRQ_IRQ_SAFE_FUND_TEST_IRQ_SAFE_FUND_TEST_TRIGGER ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_IRQ_IRQ_SAFE_FUND_TEST_IRQ_SAFE_FUND_TEST_TRIGGER_CLEAR ,None RESET:0x0"
          
tree.end

tree "ETH_PHY2__TOP_CTRL"
base e:0x40081900
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_TOP_CTRL_TESTMODE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_TOP_CTRL_TESTMODE_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_TOP_CTRL_TOP_CTRL_TESTMODE_PMD_STARTUP_EN ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_TOP_CTRL_TOP_CTRL_TESTMODE_PMD_TEAR_RESCAL_EN ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_TOP_CTRL_TOP_CTRL_TESTMODE_PMD_TEAR_DOWN_EN ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY2_TOP_CTRL_TOP_CTRL_TESTMODE_PHY_LINK_CONTROL_100M ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_CONFIG, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_CONFIG_LINK_CONTROL ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_TOP_CTRL_CONFIG_PHY_CONFIG_DONE ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY2_TOP_CTRL_CONFIG_IEEE_POWERDOWN_PMD ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_ABB_LOCK_TIMER, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_ABB_LOCK_TIMER_SELECT ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_OA_SLEEP_WAKEUP, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_OA_SLEEP_WAKEUP_SLEEP_START ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_FAILURE_DEBUG, None RESET:0x1"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_FAILURE_DEBUG_ENABLE ,None RESET:0x1"
          
group.long  0x14++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_FSM_READ_STATE_REQ, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_FSM_READ_STATE_REQ_ENABLE ,None RESET:0x0"
          
         hexmask.long 0x00 1.--5. 1. " ETH_PHY2_TOP_CTRL_FSM_READ_STATE_REQ_ADDRESS ,None RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_FSM_READ_STATE_RESP, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_FSM_READ_STATE_RESP_VALID ,None RESET:0x0"
          
         hexmask.long 0x00 1.--6. 1. " ETH_PHY2_TOP_CTRL_FSM_READ_STATE_RESP_CURRENT_STATE ,None RESET:0x0"
          
         hexmask.long 0x00 7.--12. 1. " ETH_PHY2_TOP_CTRL_FSM_READ_STATE_RESP_PREV_STATE ,None RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_TC10_TIMERS, None RESET:0xf4"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY2_TOP_CTRL_TC10_TIMERS_ACK_SELECT ,None RESET:0x14"
          
         hexmask.long 0x00 5.--6. 1. " ETH_PHY2_TOP_CTRL_TC10_TIMERS_REQ_SELECT ,None RESET:0x3"
          
         hexmask.long 0x00 7.--8. 1. " ETH_PHY2_TOP_CTRL_TC10_TIMERS_FAIL_SELECT ,None RESET:0x1"
          
group.long  0x20++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_TC10_SKIP_SLEEP_ACK, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_TC10_SKIP_SLEEP_ACK_ENABLE ,None RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_TC10_IGNORE_REQ_TIMER_DONE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_TC10_IGNORE_REQ_TIMER_DONE_ENABLE ,None RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_TC10_ENABLE_SLEEP_CAPABILITY, None RESET:0x1"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_TC10_ENABLE_SLEEP_CAPABILITY_ENABLE ,None RESET:0x1"
          
group.long  0x30++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_CABLE_DIAGNOSTICS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_CABLE_DIAGNOSTICS_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_TOP_CTRL_CABLE_DIAGNOSTICS_DONE ,None RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_RBB100_POWER_GATING, None RESET:0x7"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_RBB100_POWER_GATING_CLK_ENABLE ,None RESET:0x1"
          
         bitfld.long 0x00 1. " ETH_PHY2_TOP_CTRL_RBB100_POWER_GATING_RESET_N ,None RESET:0x1"
          
         bitfld.long 0x00 2. " ETH_PHY2_TOP_CTRL_RBB100_POWER_GATING_ISO_N ,None RESET:0x1"
          
         bitfld.long 0x00 3. " ETH_PHY2_TOP_CTRL_RBB100_POWER_GATING_PC ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY2_TOP_CTRL_RBB100_POWER_GATING_PDL ,None RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_ZBB_PMD_POWER_GATING, None RESET:0x7"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_ZBB_PMD_POWER_GATING_CLK_ENABLE ,None RESET:0x1"
          
         bitfld.long 0x00 1. " ETH_PHY2_TOP_CTRL_ZBB_PMD_POWER_GATING_RESET_N ,None RESET:0x1"
          
         bitfld.long 0x00 2. " ETH_PHY2_TOP_CTRL_ZBB_PMD_POWER_GATING_ISO_N ,None RESET:0x1"
          
         bitfld.long 0x00 3. " ETH_PHY2_TOP_CTRL_ZBB_PMD_POWER_GATING_PC ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY2_TOP_CTRL_ZBB_PMD_POWER_GATING_PDL ,None RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_POWER_SWITCH_TEST_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_POWER_SWITCH_TEST_CTRL_TEST_CTRL_RBB ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_TOP_CTRL_POWER_SWITCH_TEST_CTRL_TEST_CTRL_ZBB_PMD ,None RESET:0x0"
          
rgroup.long 0x5c++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_POWER_SWITCH_TEST_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_TOP_CTRL_POWER_SWITCH_TEST_STATUS_TEST_STATUS_RBB ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_TOP_CTRL_POWER_SWITCH_TEST_STATUS_TEST_STATUS_ZBB_PMD ,None RESET:0x0"
          
rgroup.long 0x60++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_CABLE_DIAG_STATUS, None RESET:0x0"
         hexmask.long 0x00 4.--7. 1. " ETH_PHY2_TOP_CTRL_CABLE_DIAG_STATUS_STATUS ,None RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " ETH_PHY2_TOP_CTRL_CABLE_DIAG_STATUS_LOCATION ,None RESET:0x0"
          
rgroup.long 0x64++0x3
    line.long 0x00 "ETH_PHY2_TOP_CTRL_PHY_VERSION, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY2_TOP_CTRL_PHY_VERSION_PATCHLEVEL ,None RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY2_TOP_CTRL_PHY_VERSION_MINOR ,None RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY2_TOP_CTRL_PHY_VERSION_MAJOR ,None RESET:0x0"
          
tree.end

tree "ETH_PHY2__IEEE_PCS"
base e:0x40082000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PCS_PCS_CONTROL_1, None RESET:0x0"
         bitfld.long 0x00 6. " ETH_PHY2_IEEE_PCS_PCS_CONTROL_1_SPEED_SELECTION_LSB ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 11. " ETH_PHY2_IEEE_PCS_PCS_CONTROL_1_LOW_POWER ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_PCS_PCS_CONTROL_1_SPEED_SELECTION_MSB ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 14. " ETH_PHY2_IEEE_PCS_PCS_CONTROL_1_LOOPBACK ,None RESET:0x0"
          
         bitfld.long 0x00 15. " ETH_PHY2_IEEE_PCS_PCS_CONTROL_1_RESET ,None RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PCS_PCS_STATUS_1, None RESET:0x2"
         bitfld.long 0x00 1. " ETH_PHY2_IEEE_PCS_PCS_STATUS_1_LOW_POWER_ABILITY ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 2. " ETH_PHY2_IEEE_PCS_PCS_STATUS_1_PCS_RECEIVE_LINK_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ETH_PHY2_IEEE_PCS_PCS_STATUS_1_CLOCK_STOP_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY2_IEEE_PCS_PCS_STATUS_1_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_IEEE_PCS_PCS_STATUS_1_RX_LPI_INDICATION ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 9. " ETH_PHY2_IEEE_PCS_PCS_STATUS_1_TX_LPI_INDICATION ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 10. " ETH_PHY2_IEEE_PCS_PCS_STATUS_1_RX_LPI_RECEIVED ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 11. " ETH_PHY2_IEEE_PCS_PCS_STATUS_1_TX_LPI_RECEIVED ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PCS_PCS_DEVICE_IDENTIFIER_1, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_IEEE_PCS_PCS_DEVICE_IDENTIFIER_1_OUI ,None RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PCS_PCS_DEVICE_IDENTIFIER_2, None RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY2_IEEE_PCS_PCS_DEVICE_IDENTIFIER_2_REVISION ,None RESET:0x0"
          
         hexmask.long 0x00 4.--9. 1. " ETH_PHY2_IEEE_PCS_PCS_DEVICE_IDENTIFIER_2_MODEL ,None RESET:0x0"
          
         hexmask.long 0x00 10.--15. 1. " ETH_PHY2_IEEE_PCS_PCS_DEVICE_IDENTIFIER_2_OUI ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1, None RESET:0x8a"
         bitfld.long 0x00 0. " ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_CLAUSE_22_REGISTERS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 1. " ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_PMD_PMA_PRESENT ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 2. " ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_WIS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 3. " ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_PCS_PRESENT ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 4. " ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_PHY_XS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_DTE_XS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 6. " ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_TC_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_AUTO_NEGOTIATION_PRESENT ,None RESET:0x1" "TRUE-1"
          
         hexmask.long 0x00 8.--11. 1. " ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_SEPARATED_PMA_PRESENT ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_OFDM ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_1_POWER_UNIT_PRESENT ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_2, None RESET:0x0"
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_2_CLAUSE_22_EXTENSION_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 14. " ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_2_VENDOR_SPECIFIC_DEVICE_1_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 15. " ETH_PHY2_IEEE_PCS_PCS_DEVICES_IN_PACKAGE_2_VENDOR_SPECIFIC_DEVICE_2_PRESENT ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PCS_PCS_STATUS_2, None RESET:0x8000"
         bitfld.long 0x00 0. " ETH_PHY2_IEEE_PCS_PCS_STATUS_2_E10GBASE_R_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 1. " ETH_PHY2_IEEE_PCS_PCS_STATUS_2_E10GBASE_X_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 2. " ETH_PHY2_IEEE_PCS_PCS_STATUS_2_E10GBASE_W_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 3. " ETH_PHY2_IEEE_PCS_PCS_STATUS_2_E10GBASE_T_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 4. " ETH_PHY2_IEEE_PCS_PCS_STATUS_2_E40GBASE_R_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY2_IEEE_PCS_PCS_STATUS_2_E100GBASE_R_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 6. " ETH_PHY2_IEEE_PCS_PCS_STATUS_2_E40GBASE_T_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY2_IEEE_PCS_PCS_STATUS_2_E25GBASE_R_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 9. " ETH_PHY2_IEEE_PCS_PCS_STATUS_2_E25GBASE_T_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 10. " ETH_PHY2_IEEE_PCS_PCS_STATUS_2_RECEIVE_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ETH_PHY2_IEEE_PCS_PCS_STATUS_2_TRANSMIT_FAULT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 12. " ETH_PHY2_IEEE_PCS_PCS_STATUS_2_E2D5GBASE_T_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_PCS_PCS_STATUS_2_E5GBASE_T_CAPABLE ,None RESET:0x0" "FALSE-0"
          
         hexmask.long 0x00 14.--15. 1. " ETH_PHY2_IEEE_PCS_PCS_STATUS_2_DEVICE_PRESENT ,None RESET:0x2"
          
rgroup.long 0x38++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PCS_PCS_PACKAGE_IDENTIFIER_1, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_IEEE_PCS_PCS_PACKAGE_IDENTIFIER_1_OUI ,None RESET:0x0"
          
rgroup.long 0x3c++0x3
    line.long 0x00 "ETH_PHY2_IEEE_PCS_PCS_PACKAGE_IDENTIFIER_2, None RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY2_IEEE_PCS_PCS_PACKAGE_IDENTIFIER_2_REVISION ,None RESET:0x0"
          
         hexmask.long 0x00 4.--9. 1. " ETH_PHY2_IEEE_PCS_PCS_PACKAGE_IDENTIFIER_2_MODEL ,None RESET:0x0"
          
         hexmask.long 0x00 10.--15. 1. " ETH_PHY2_IEEE_PCS_PCS_PACKAGE_IDENTIFIER_2_OUI ,None RESET:0x0"
          
tree.end

tree "ETH_PHY2__E100T1_PCS"
base e:0x40083000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PCS_E100M_REMOTE_LOOPBACK, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PCS_E100M_REMOTE_LOOPBACK_VALUE ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PCS_E100M_TXPCS_TESTMODE, None RESET:0x600"
         hexmask.long 0x00 8.--15. 1. " ETH_PHY2_E100T1_PCS_E100M_TXPCS_TESTMODE_CNT ,None RESET:0x6"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PCS_E100M_TX_DISABLE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PCS_E100M_TX_DISABLE_DISABLED ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PCS_E100M_TXPCS_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PCS_E100M_TXPCS_STATUS_READY2TRANSMIT ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PCS_E100M_RXPCS, None RESET:0x100"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PCS_E100M_RXPCS_SCR_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_E100T1_PCS_E100M_RXPCS_CHECK_IDLE ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_E100T1_PCS_E100M_RXPCS_RCVR_IDLE_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_E100T1_PCS_E100M_RXPCS_REM_RCVR_STATUS_OK ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_E100T1_PCS_E100M_RXPCS_POLARITY_ENABLE ,None RESET:0x1"
          
         bitfld.long 0x00 9. " ETH_PHY2_E100T1_PCS_E100M_RXPCS_POLARITY_DETECTED ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY2_E100T1_PCS_E100M_RXPCS_POLARITY_INVERSION ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ETH_PHY2_E100T1_PCS_E100M_RXPCS_ABSEL ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY2_E100T1_PCS_E100M_RXPCS_JAB_EXTEND ,None RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PCS_E100M_RXPCS_SCR_CONFIG, None RESET:0x1220028"
         hexmask.long 0x00 0.--5. 1. " ETH_PHY2_E100T1_PCS_E100M_RXPCS_SCR_CONFIG_LOCK_VALIDATION_COUNT ,None RESET:0x28"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY2_E100T1_PCS_E100M_RXPCS_SCR_CONFIG_MAX_INVALID_IDLE ,None RESET:0x22"
          
         hexmask.long 0x00 24.--31. 1. " ETH_PHY2_E100T1_PCS_E100M_RXPCS_SCR_CONFIG_TH_REM_RCVR_STATUS_OK ,None RESET:0x1"
          
group.long  0x20++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PCS_E100M_DBG_CONFIG, None RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " ETH_PHY2_E100T1_PCS_E100M_DBG_CONFIG_TRACE_SELECT ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY2_E100T1_PCS_E100M_DBG_CONFIG_TRACE_ENABLE ,None RESET:0x0"
          
         hexmask.long 0x00 8.--12. 1. " ETH_PHY2_E100T1_PCS_E100M_DBG_CONFIG_TRIGGER_SELECT ,None RESET:0x0"
          
         bitfld.long 0x00 16. " ETH_PHY2_E100T1_PCS_E100M_DBG_CONFIG_PLAYBACK_ENABLE ,None RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PCS_E100M_DBG_RF_TRIGGER, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_E100T1_PCS_E100M_DBG_RF_TRIGGER_ENABLE ,None RESET:0x0"
          
rgroup.long 0x28++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PCS_E100M_TC1_STARTUP_TIME, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY2_E100T1_PCS_E100M_TC1_STARTUP_TIME_LTT ,None RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY2_E100T1_PCS_E100M_TC1_STARTUP_TIME_LRT ,None RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY2_E100T1_PCS_E100M_TC1_STARTUP_TIME_RRT ,None RESET:0x0"
          
rgroup.long 0x2c++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PCS_E100M_TC1_LFL_COMM, None RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " ETH_PHY2_E100T1_PCS_E100M_TC1_LFL_COMM_FAILURES ,None RESET:0x0"
          
         hexmask.long 0x00 10.--15. 1. " ETH_PHY2_E100T1_PCS_E100M_TC1_LFL_COMM_LOSSES ,None RESET:0x0"
          
         hexmask.long 0x00 16.--21. 1. " ETH_PHY2_E100T1_PCS_E100M_TC1_LFL_COMM_RECOVERIES ,None RESET:0x0"
          
         bitfld.long 0x00 31. " ETH_PHY2_E100T1_PCS_E100M_TC1_LFL_COMM_COMM_READY ,None RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "ETH_PHY2_E100T1_PCS_E100M_FRAME_INDICATOR_CFG, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY2_E100T1_PCS_E100M_FRAME_INDICATOR_CFG_PREEMPT_SMD_SEL ,None RESET:0x0"
          
tree.end

tree "ETH_PHY2__WOL"
base e:0x40083800
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY2_WOL_WOL_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_WOL_WOL_CONTROL_MAGIC_PACKET_EN ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_WOL_WOL_CONTROL_SECURE_ON_PW_EN ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY2_WOL_WOL_CONFIG, None RESET:0x10000"
         bitfld.long 0x00 8. " ETH_PHY2_WOL_WOL_CONFIG_SFD_SWAP ,None RESET:0x0"
          
         hexmask.long 0x00 9.--10. 1. " ETH_PHY2_WOL_WOL_CONFIG_DATA_SWAP ,None RESET:0x0"
          
         bitfld.long 0x00 16. " ETH_PHY2_WOL_WOL_CONFIG_CRC_GATE ,None RESET:0x1"
          
rgroup.long 0x8++0x3
    line.long 0x00 "ETH_PHY2_WOL_WOL_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_WOL_WOL_STATUS_WOL_MAGIC_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_WOL_WOL_STATUS_WOL_SECURE_ON_HACK ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_WOL_WOL_STATUS_WOL_NIBBLE_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY2_WOL_WOL_STATUS_WOL_CRC_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY2_WOL_WOL_STATUS_WOL_SFD_ERROR ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY2_WOL_WOL_MAC_ADDR0, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY2_WOL_WOL_MAC_ADDR0_OCTET0 ,None RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY2_WOL_WOL_MAC_ADDR0_OCTET1 ,None RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY2_WOL_WOL_MAC_ADDR0_OCTET2 ,None RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " ETH_PHY2_WOL_WOL_MAC_ADDR0_OCTET3 ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY2_WOL_WOL_MAC_ADDR1, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY2_WOL_WOL_MAC_ADDR1_OCTET4 ,None RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY2_WOL_WOL_MAC_ADDR1_OCTET5 ,None RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "ETH_PHY2_WOL_WOL_SEC_PW0, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY2_WOL_WOL_SEC_PW0_OCTET0 ,None RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY2_WOL_WOL_SEC_PW0_OCTET1 ,None RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY2_WOL_WOL_SEC_PW0_OCTET2 ,None RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " ETH_PHY2_WOL_WOL_SEC_PW0_OCTET3 ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "ETH_PHY2_WOL_WOL_SEC_PW1, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY2_WOL_WOL_SEC_PW1_OCTET4 ,None RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY2_WOL_WOL_SEC_PW1_OCTET5 ,None RESET:0x0"
          
tree.end

tree "ETH_PHY2__PRBS"
base e:0x40083a00
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY2_PRBS_PRBS_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_PRBS_PRBS_CONTROL_PRBS_GEN_EN ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_PRBS_PRBS_CONTROL_PRBS_CRC_CHECK_EN ,None RESET:0x0"
          
         bitfld.long 0x00 16. " ETH_PHY2_PRBS_PRBS_CONTROL_PRBS_CHECK_EN ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY2_PRBS_PRBS_CONFIG0, None RESET:0x610"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY2_PRBS_PRBS_CONFIG0_PRBS_IPG_LEN ,None RESET:0x10"
          
         bitfld.long 0x00 8. " ETH_PHY2_PRBS_PRBS_CONFIG0_PRBS_PAYLOAD_SEL ,None RESET:0x0"
          
         hexmask.long 0x00 9.--10. 1. " ETH_PHY2_PRBS_PRBS_CONFIG0_PRBS_PAYLOAD_CRC ,None RESET:0x3"
          
         bitfld.long 0x00 16. " ETH_PHY2_PRBS_PRBS_CONFIG0_PRBS_FORCE_ERROR ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "ETH_PHY2_PRBS_PRBS_CONFIG1, None RESET:0x400000"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_PRBS_PRBS_CONFIG1_FRAMES ,None RESET:0x0"
          
         hexmask.long 0x00 16.--29. 1. " ETH_PHY2_PRBS_PRBS_CONFIG1_LEN ,None RESET:0x40"
          
group.long  0xc++0x3
    line.long 0x00 "ETH_PHY2_PRBS_PRBS_CONFIG2, None RESET:0x1000000"
         bitfld.long 0x00 0. " ETH_PHY2_PRBS_PRBS_CONFIG2_PRBS_ERROR_RESET ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_PRBS_PRBS_CONFIG2_PRBS_CRC_ERROR_RESET ,None RESET:0x0"
          
         bitfld.long 0x00 16. " ETH_PHY2_PRBS_PRBS_CONFIG2_PRBS_FRAME_RESET ,None RESET:0x0"
          
         hexmask.long 0x00 23.--24. 1. " ETH_PHY2_PRBS_PRBS_CONFIG2_PRBS_LOCK_LOSS_SEL ,None RESET:0x2"
          
         hexmask.long 0x00 30.--31. 1. " ETH_PHY2_PRBS_PRBS_CONFIG2_PRBS_ERROR_THRESHOLD ,None RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "ETH_PHY2_PRBS_PRBS_STATUS1, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_PRBS_PRBS_STATUS1_PRBS_GEN_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_PRBS_PRBS_STATUS1_PRBS_CHECKER_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ETH_PHY2_PRBS_PRBS_STATUS1_PRBS_CHECKER_LOSS ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_PRBS_PRBS_STATUS1_PRBS_ERROR_CNT_OVF ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ETH_PHY2_PRBS_PRBS_STATUS1_PRBS_CRC_ERROR_CNT_OVF ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ETH_PHY2_PRBS_PRBS_STATUS1_PRBS_FRAME_CNT_OVF ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETH_PHY2_PRBS_PRBS_STATUS2, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_PRBS_PRBS_STATUS2_PRBS15_ERRORS ,None RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETH_PHY2_PRBS_PRBS_STATUS2_CRC_ERRORS ,None RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY2_PRBS_PRBS_STATUS3, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_PRBS_PRBS_STATUS3_RX_FRAME_COUNT ,None RESET:0x0"
          
tree.end

tree "ETH_PHY2__MAC_VALIDATE"
base e:0x40083b00
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY2_MAC_VALIDATE_MAC_PACKET_VALIDATE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_MAC_VALIDATE_MAC_PACKET_VALIDATE_RX_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_MAC_VALIDATE_MAC_PACKET_VALIDATE_TX_ENABLE ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETH_PHY2_MAC_VALIDATE_MAC_PACKET_VALIDATE_CONFIG, None RESET:0x105dc01"
         bitfld.long 0x00 0. " ETH_PHY2_MAC_VALIDATE_MAC_PACKET_VALIDATE_CONFIG_PAYLOAD_LEN_CHECK ,None RESET:0x1"
          
         hexmask.long 0x00 8.--21. 1. " ETH_PHY2_MAC_VALIDATE_MAC_PACKET_VALIDATE_CONFIG_MTU_SIZE ,None RESET:0x5dc"
          
         bitfld.long 0x00 24. " ETH_PHY2_MAC_VALIDATE_MAC_PACKET_VALIDATE_CONFIG_RELAX_PREAMBLE_CHECK ,None RESET:0x1"
          
group.long  0x8++0x3
    line.long 0x00 "ETH_PHY2_MAC_VALIDATE_RX_MII_DECODE_CONFIG, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY2_MAC_VALIDATE_RX_MII_DECODE_CONFIG_SWAP_DATA ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_MAC_VALIDATE_RX_MII_DECODE_CONFIG_SWAP_SFD ,None RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "ETH_PHY2_MAC_VALIDATE_RX_MAC_PACKET_ERROR, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_MAC_VALIDATE_RX_MAC_PACKET_ERROR_RX_INVALID_PACKET ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_MAC_VALIDATE_RX_MAC_PACKET_ERROR_RX_CRC_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_MAC_VALIDATE_RX_MAC_PACKET_ERROR_RX_PAYLOAD_LEN_ERROR ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ETH_PHY2_MAC_VALIDATE_TX_MII_DECODE_CONFIG, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETH_PHY2_MAC_VALIDATE_TX_MII_DECODE_CONFIG_SWAP_DATA ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ETH_PHY2_MAC_VALIDATE_TX_MII_DECODE_CONFIG_SWAP_SFD ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETH_PHY2_MAC_VALIDATE_TX_MAC_PACKET_ERROR, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_MAC_VALIDATE_TX_MAC_PACKET_ERROR_TX_INVALID_PACKET ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_MAC_VALIDATE_TX_MAC_PACKET_ERROR_TX_CRC_ERROR ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_MAC_VALIDATE_TX_MAC_PACKET_ERROR_TX_PAYLOAD_LEN_ERROR ,None RESET:0x0"
          
tree.end

tree "ETH_PHY2__IEEE_AUTONEG"
base e:0x40086000
width 80.
rgroup.long 0x8++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_AN_DEVICE_IDENTIFIER_1, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICE_IDENTIFIER_1_OUI ,None RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_AN_DEVICE_IDENTIFIER_2, None RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICE_IDENTIFIER_2_REVISION ,None RESET:0x0"
          
         hexmask.long 0x00 4.--9. 1. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICE_IDENTIFIER_2_MODEL ,None RESET:0x0"
          
         hexmask.long 0x00 10.--15. 1. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICE_IDENTIFIER_2_OUI ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1, None RESET:0x8a"
         bitfld.long 0x00 0. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_CLAUSE_22_REGISTERS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 1. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_PMD_PMA_PRESENT ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 2. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_WIS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 3. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_PCS_PRESENT ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 4. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_PHY_XS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 5. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_DTE_XS_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 6. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_TC_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 7. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_AUTO_NEGOTIATION_PRESENT ,None RESET:0x1" "TRUE-1"
          
         hexmask.long 0x00 8.--11. 1. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_SEPARATED_PMA_PRESENT ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_OFDM ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_1_POWER_UNIT_PRESENT ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_2, None RESET:0x0"
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_2_CLAUSE_22_EXTENSION_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 14. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_2_VENDOR_SPECIFIC_DEVICE_1_PRESENT ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 15. " ETH_PHY2_IEEE_AUTONEG_AN_DEVICES_IN_PACKAGE_2_VENDOR_SPECIFIC_DEVICE_2_PRESENT ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x38++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_AN_PACKAGE_IDENTIFIER_1, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_IEEE_AUTONEG_AN_PACKAGE_IDENTIFIER_1_OUI ,None RESET:0x0"
          
rgroup.long 0x3c++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_AN_PACKAGE_IDENTIFIER_2, None RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " ETH_PHY2_IEEE_AUTONEG_AN_PACKAGE_IDENTIFIER_2_REVISION ,None RESET:0x0"
          
         hexmask.long 0x00 4.--9. 1. " ETH_PHY2_IEEE_AUTONEG_AN_PACKAGE_IDENTIFIER_2_MODEL ,None RESET:0x0"
          
         hexmask.long 0x00 10.--15. 1. " ETH_PHY2_IEEE_AUTONEG_AN_PACKAGE_IDENTIFIER_2_OUI ,None RESET:0x0"
          
group.long  0x200++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_CONTROL, None RESET:0x0"
         bitfld.long 0x00 9. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_CONTROL_RESTART_AUTO_NEGOTIATION ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_CONTROL_AUTO_NEGOTIATION_ENABLE ,None RESET:0x0"
          
         bitfld.long 0x00 15. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_CONTROL_AN_RESET ,None RESET:0x0"
          
rgroup.long 0x204++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_STATUS, None RESET:0x8"
         bitfld.long 0x00 2. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_STATUS_LINK_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_STATUS_AUTO_NEGOTIATION_ABILITY ,None RESET:0x1" "TRUE-1"
          
         bitfld.long 0x00 4. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_STATUS_REMOTE_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_STATUS_AUTO_NEGOTIATION_COMPLETE ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_STATUS_PAGE_RECEIVED ,None RESET:0x0"
          
group.long  0x208++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1, None RESET:0x1"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1_SELECTOR_FIELD ,None RESET:0x1"
          
         hexmask.long 0x00 5.--9. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1_ECHOED_NONCE ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1_PAUSE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1_FORCE_MASTER ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1_REMOTE_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 14. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1_ACKNOWLEDGE ,None RESET:0x0" "FALSE-0"
          
         bitfld.long 0x00 15. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_1_NEXT_PAGE ,None RESET:0x0"
          
group.long  0x20c++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_2, None RESET:0xa0"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_2_TRANSMITTED_NONCE ,None RESET:0x0"
          
         hexmask.long 0x00 5.--15. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_2_TECHNOLOGY_ABILITY ,None RESET:0x5"
          
group.long  0x210++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_3, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_ADVERTISEMENT_3_TECHNOLOGY_ABILITY ,None RESET:0x0"
          
rgroup.long 0x214++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1, None RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1_SELECTOR_FIELD ,None RESET:0x0"
          
         hexmask.long 0x00 5.--9. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1_ECHOED_NONCE ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1_PAUSE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1_FORCE_MASTER ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1_REMOTE_FAULT ,None RESET:0x0"
          
         bitfld.long 0x00 14. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1_ACKNOWLEDGE ,None RESET:0x0"
          
         bitfld.long 0x00 15. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_1_NEXT_PAGE ,None RESET:0x0"
          
rgroup.long 0x218++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_2, None RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_2_TRANSMITTED_NONCE ,None RESET:0x0"
          
         hexmask.long 0x00 5.--15. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_2_TECHNOLOGY_ABILITY ,None RESET:0x0"
          
rgroup.long 0x21c++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_3, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_BASE_PAGE_ABILITY_3_TECHNOLOGY_ABILITY ,None RESET:0x0"
          
group.long  0x220++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_1, None RESET:0x2001"
         hexmask.long 0x00 0.--10. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_1_MESSAGE_UNFORMATTED_CODE_FIELD ,None RESET:0x1"
          
         bitfld.long 0x00 11. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_1_TOGGLE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_1_ACKNOWLEDGE_2 ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_1_MESSAGE_PAGE ,None RESET:0x1"
          
         bitfld.long 0x00 15. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_1_NEXT_PAGE ,None RESET:0x0"
          
group.long  0x224++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_2, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_2_UNFORMATTED_CODE_FIELD_1 ,None RESET:0x0"
          
group.long  0x228++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_3, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_NEXT_PAGE_TRANSMIT_3_UNFORMATTED_CODE_FIELD_2 ,None RESET:0x0"
          
rgroup.long 0x22c++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_1, None RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_1_MESSAGE_UNFORMATTED_CODE_FIELD ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_1_TOGGLE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_1_ACKNOWLEDGE_2 ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_1_MESSAGE_PAGE ,None RESET:0x0"
          
         bitfld.long 0x00 15. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_1_NEXT_PAGE ,None RESET:0x0"
          
rgroup.long 0x230++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_2, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_2_UNFORMATTED_CODE_FIELD_1 ,None RESET:0x0"
          
rgroup.long 0x234++0x3
    line.long 0x00 "ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_3, None RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETH_PHY2_IEEE_AUTONEG_BASE_T1_AN_LP_NEXT_PAGE_ABILITY_3_UNFORMATTED_CODE_FIELD_2 ,None RESET:0x0"
          
tree.end

tree "ETH_PHY2__VENDOR_AUTONEG"
base e:0x40087000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETH_PHY2_VENDOR_AUTONEG_AUTONEG_CONFIG, None RESET:0x0"
         bitfld.long 0x00 1. " ETH_PHY2_VENDOR_AUTONEG_AUTONEG_CONFIG_PRNG_SEED ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ETH_PHY2_VENDOR_AUTONEG_AUTONEG_CONFIG_PHY_CONFIG ,None RESET:0x0" "FALSE-0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "ETH_PHY2_VENDOR_AUTONEG_AUTONEG_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_VENDOR_AUTONEG_AUTONEG_STATUS_CONFIG_AS_MASTER ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_VENDOR_AUTONEG_AUTONEG_STATUS_MS_CONFIG_FAULT ,None RESET:0x0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "ETH_PHY2_VENDOR_AUTONEG_AUTONEG_PMA_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_VENDOR_AUTONEG_AUTONEG_PMA_STATUS_LINK_STATUS_E100T1 ,None RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "ETH_PHY2_VENDOR_AUTONEG_AUTONEG_MODE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_VENDOR_AUTONEG_AUTONEG_MODE_LINK_CONTROL_E100T1 ,None RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "ETH_PHY2_VENDOR_AUTONEG_AUTONEG_PAUSE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_VENDOR_AUTONEG_AUTONEG_PAUSE_TRANSMIT ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ETH_PHY2_VENDOR_AUTONEG_AUTONEG_PAUSE_RECEIVE ,None RESET:0x0"
          
group.long  0x14++0x3
