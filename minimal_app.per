         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B2S1_SEQUENCEREG0B2S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x62++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B2S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B2S2_SEQUENCEREG0B2S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B3S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B3S0_SEQUENCEREG0B3S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x66++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B3S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B3S1_SEQUENCEREG0B3S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x68++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B3S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B3S2_SEQUENCEREG0B3S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x6a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B4S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B4S0_SEQUENCEREG0B4S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x6c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B4S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B4S1_SEQUENCEREG0B4S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x6e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B4S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B4S2_SEQUENCEREG0B4S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x70++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B5S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B5S0_SEQUENCEREG0B5S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x72++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B5S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B5S1_SEQUENCEREG0B5S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x74++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B5S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B5S2_SEQUENCEREG0B5S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x76++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B6S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B6S0_SEQUENCEREG0B6S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x78++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B6S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B6S1_SEQUENCEREG0B6S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x7a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B6S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B6S2_SEQUENCEREG0B6S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x7c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B7S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B7S0_SEQUENCEREG0B7S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x7e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B7S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B7S1_SEQUENCEREG0B7S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B7S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B7S2_SEQUENCEREG0B7S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B8S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B8S0_SEQUENCEREG0B8S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B8S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B8S1_SEQUENCEREG0B8S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B8S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B8S2_SEQUENCEREG0B8S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x88++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B9S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B9S0_SEQUENCEREG0B9S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x8a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B9S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B9S1_SEQUENCEREG0B9S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x8c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B9S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B9S2_SEQUENCEREG0B9S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x8e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B10S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B10S0_SEQUENCEREG0B10S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x90++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B10S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B10S1_SEQUENCEREG0B10S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x92++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B10S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B10S2_SEQUENCEREG0B10S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x94++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B11S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B11S0_SEQUENCEREG0B11S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x96++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B11S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B11S1_SEQUENCEREG0B11S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x98++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B11S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B11S2_SEQUENCEREG0B11S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x9a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B12S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B12S0_SEQUENCEREG0B12S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x9c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B12S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B12S1_SEQUENCEREG0B12S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x9e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B12S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B12S2_SEQUENCEREG0B12S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xa0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B13S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B13S0_SEQUENCEREG0B13S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xa2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B13S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B13S1_SEQUENCEREG0B13S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xa4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B13S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B13S2_SEQUENCEREG0B13S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xa6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B14S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B14S0_SEQUENCEREG0B14S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xa8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B14S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B14S1_SEQUENCEREG0B14S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xaa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B14S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B14S2_SEQUENCEREG0B14S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B15S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B15S0_SEQUENCEREG0B15S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xae++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B15S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B15S1_SEQUENCEREG0B15S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xb0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B15S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B15S2_SEQUENCEREG0B15S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xb2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B16S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B16S0_SEQUENCEREG0B16S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xb4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B16S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B16S1_SEQUENCEREG0B16S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xb6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B16S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B16S2_SEQUENCEREG0B16S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xb8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B17S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B17S0_SEQUENCEREG0B17S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xba++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B17S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B17S1_SEQUENCEREG0B17S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xbc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B17S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B17S2_SEQUENCEREG0B17S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xbe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B18S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B18S0_SEQUENCEREG0B18S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xc0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B18S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B18S1_SEQUENCEREG0B18S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xc2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B18S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B18S2_SEQUENCEREG0B18S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xc4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B19S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B19S0_SEQUENCEREG0B19S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xc6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B19S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B19S1_SEQUENCEREG0B19S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xc8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B19S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B19S2_SEQUENCEREG0B19S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xca++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B20S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B20S0_SEQUENCEREG0B20S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xcc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B20S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B20S1_SEQUENCEREG0B20S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xce++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B20S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B20S2_SEQUENCEREG0B20S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xd0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B21S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B21S0_SEQUENCEREG0B21S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xd2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B21S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B21S1_SEQUENCEREG0B21S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xd4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B21S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B21S2_SEQUENCEREG0B21S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xd6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B22S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B22S0_SEQUENCEREG0B22S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xd8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B22S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B22S1_SEQUENCEREG0B22S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xda++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B22S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B22S2_SEQUENCEREG0B22S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xdc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B23S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B23S0_SEQUENCEREG0B23S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xde++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B23S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B23S1_SEQUENCEREG0B23S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xe0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B23S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B23S2_SEQUENCEREG0B23S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xe2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B24S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B24S0_SEQUENCEREG0B24S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xe4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B24S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B24S1_SEQUENCEREG0B24S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xe6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B24S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B24S2_SEQUENCEREG0B24S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xe8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B25S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B25S0_SEQUENCEREG0B25S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xea++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B25S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B25S1_SEQUENCEREG0B25S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xec++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B25S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B25S2_SEQUENCEREG0B25S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xee++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B26S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B26S0_SEQUENCEREG0B26S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xf0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B26S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B26S1_SEQUENCEREG0B26S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xf2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B26S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B26S2_SEQUENCEREG0B26S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xf4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B27S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B27S0_SEQUENCEREG0B27S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xf6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B27S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B27S1_SEQUENCEREG0B27S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xf8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B27S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B27S2_SEQUENCEREG0B27S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xfa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B28S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B28S0_SEQUENCEREG0B28S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xfc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B28S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B28S1_SEQUENCEREG0B28S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xfe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B28S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B28S2_SEQUENCEREG0B28S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B29S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B29S0_SEQUENCEREG0B29S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B29S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B29S1_SEQUENCEREG0B29S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x104++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B29S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B29S2_SEQUENCEREG0B29S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x106++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B30S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B30S0_SEQUENCEREG0B30S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x108++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B30S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B30S1_SEQUENCEREG0B30S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x10a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B30S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B30S2_SEQUENCEREG0B30S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x10c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B31S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B31S0_SEQUENCEREG0B31S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x10e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B31S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B31S1_SEQUENCEREG0B31S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x110++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B31S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B31S2_SEQUENCEREG0B31S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x112++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B32S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B32S0_SEQUENCEREG0B32S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x114++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B32S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B32S1_SEQUENCEREG0B32S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x116++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B32S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B32S2_SEQUENCEREG0B32S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x118++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B33S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B33S0_SEQUENCEREG0B33S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x11a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B33S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B33S1_SEQUENCEREG0B33S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x11c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B33S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B33S2_SEQUENCEREG0B33S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x11e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B34S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B34S0_SEQUENCEREG0B34S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x120++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B34S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B34S1_SEQUENCEREG0B34S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x122++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B34S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B34S2_SEQUENCEREG0B34S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x124++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B35S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B35S0_SEQUENCEREG0B35S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x126++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B35S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B35S1_SEQUENCEREG0B35S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x128++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B35S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B35S2_SEQUENCEREG0B35S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x12a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B36S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B36S0_SEQUENCEREG0B36S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x12c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B36S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B36S1_SEQUENCEREG0B36S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x12e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B36S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B36S2_SEQUENCEREG0B36S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x130++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B37S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B37S0_SEQUENCEREG0B37S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x132++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B37S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B37S1_SEQUENCEREG0B37S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x134++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B37S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B37S2_SEQUENCEREG0B37S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x136++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B38S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B38S0_SEQUENCEREG0B38S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x138++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B38S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B38S1_SEQUENCEREG0B38S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x13a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B38S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B38S2_SEQUENCEREG0B38S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x13c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B39S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B39S0_SEQUENCEREG0B39S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x13e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B39S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B39S1_SEQUENCEREG0B39S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x140++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B39S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B39S2_SEQUENCEREG0B39S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x142++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B40S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B40S0_SEQUENCEREG0B40S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x144++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B40S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B40S1_SEQUENCEREG0B40S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x146++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B40S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B40S2_SEQUENCEREG0B40S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x148++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B41S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B41S0_SEQUENCEREG0B41S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x14a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B41S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B41S1_SEQUENCEREG0B41S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x14c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B41S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B41S2_SEQUENCEREG0B41S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x14e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B42S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B42S0_SEQUENCEREG0B42S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x150++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B42S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B42S1_SEQUENCEREG0B42S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x152++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B42S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B42S2_SEQUENCEREG0B42S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x154++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B43S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B43S0_SEQUENCEREG0B43S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x156++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B43S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B43S1_SEQUENCEREG0B43S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x158++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B43S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B43S2_SEQUENCEREG0B43S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x15a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B44S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B44S0_SEQUENCEREG0B44S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x15c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B44S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B44S1_SEQUENCEREG0B44S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x15e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B44S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B44S2_SEQUENCEREG0B44S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x160++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B45S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B45S0_SEQUENCEREG0B45S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x162++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B45S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B45S1_SEQUENCEREG0B45S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x164++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B45S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B45S2_SEQUENCEREG0B45S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x166++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B46S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B46S0_SEQUENCEREG0B46S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x168++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B46S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B46S1_SEQUENCEREG0B46S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x16a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B46S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B46S2_SEQUENCEREG0B46S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x16c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B47S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B47S0_SEQUENCEREG0B47S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x16e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B47S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B47S1_SEQUENCEREG0B47S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x170++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B47S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B47S2_SEQUENCEREG0B47S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x172++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B48S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B48S0_SEQUENCEREG0B48S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x174++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B48S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B48S1_SEQUENCEREG0B48S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x176++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B48S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B48S2_SEQUENCEREG0B48S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x178++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B49S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B49S0_SEQUENCEREG0B49S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x17a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B49S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B49S1_SEQUENCEREG0B49S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x17c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B49S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B49S2_SEQUENCEREG0B49S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x17e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B50S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B50S0_SEQUENCEREG0B50S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B50S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B50S1_SEQUENCEREG0B50S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B50S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B50S2_SEQUENCEREG0B50S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B51S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B51S0_SEQUENCEREG0B51S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B51S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B51S1_SEQUENCEREG0B51S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x188++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B51S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B51S2_SEQUENCEREG0B51S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x18a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B52S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B52S0_SEQUENCEREG0B52S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x18c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B52S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B52S1_SEQUENCEREG0B52S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x18e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B52S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B52S2_SEQUENCEREG0B52S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x190++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B53S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B53S0_SEQUENCEREG0B53S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x192++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B53S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B53S1_SEQUENCEREG0B53S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x194++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B53S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B53S2_SEQUENCEREG0B53S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x196++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B54S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B54S0_SEQUENCEREG0B54S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x198++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B54S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B54S1_SEQUENCEREG0B54S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x19a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B54S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B54S2_SEQUENCEREG0B54S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x19c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B55S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B55S0_SEQUENCEREG0B55S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x19e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B55S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B55S1_SEQUENCEREG0B55S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B55S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B55S2_SEQUENCEREG0B55S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B56S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B56S0_SEQUENCEREG0B56S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B56S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B56S1_SEQUENCEREG0B56S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B56S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B56S2_SEQUENCEREG0B56S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1a8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B57S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B57S0_SEQUENCEREG0B57S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1aa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B57S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B57S1_SEQUENCEREG0B57S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1ac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B57S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B57S2_SEQUENCEREG0B57S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1ae++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B58S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B58S0_SEQUENCEREG0B58S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1b0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B58S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B58S1_SEQUENCEREG0B58S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1b2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B58S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B58S2_SEQUENCEREG0B58S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1b4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B59S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B59S0_SEQUENCEREG0B59S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1b6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B59S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B59S1_SEQUENCEREG0B59S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1b8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B59S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B59S2_SEQUENCEREG0B59S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1ba++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B60S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B60S0_SEQUENCEREG0B60S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1bc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B60S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B60S1_SEQUENCEREG0B60S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1be++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B60S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B60S2_SEQUENCEREG0B60S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1c0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B61S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B61S0_SEQUENCEREG0B61S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1c2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B61S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B61S1_SEQUENCEREG0B61S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1c4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B61S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B61S2_SEQUENCEREG0B61S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1c6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B62S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B62S0_SEQUENCEREG0B62S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1c8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B62S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B62S1_SEQUENCEREG0B62S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1ca++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B62S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B62S2_SEQUENCEREG0B62S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1cc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B63S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B63S0_SEQUENCEREG0B63S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1ce++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B63S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B63S1_SEQUENCEREG0B63S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1d0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B63S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B63S2_SEQUENCEREG0B63S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1d2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B64S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B64S0_SEQUENCEREG0B64S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1d4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B64S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B64S1_SEQUENCEREG0B64S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1d6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B64S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B64S2_SEQUENCEREG0B64S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1d8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B65S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B65S0_SEQUENCEREG0B65S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1da++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B65S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B65S1_SEQUENCEREG0B65S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1dc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B65S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B65S2_SEQUENCEREG0B65S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1de++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B66S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B66S0_SEQUENCEREG0B66S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1e0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B66S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B66S1_SEQUENCEREG0B66S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1e2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B66S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B66S2_SEQUENCEREG0B66S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1e4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B67S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B67S0_SEQUENCEREG0B67S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1e6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B67S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B67S1_SEQUENCEREG0B67S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1e8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B67S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B67S2_SEQUENCEREG0B67S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1ea++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B68S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B68S0_SEQUENCEREG0B68S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1ec++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B68S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B68S1_SEQUENCEREG0B68S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1ee++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B68S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B68S2_SEQUENCEREG0B68S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1f0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B69S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B69S0_SEQUENCEREG0B69S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1f2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B69S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B69S1_SEQUENCEREG0B69S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1f4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B69S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B69S2_SEQUENCEREG0B69S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1f6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B70S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B70S0_SEQUENCEREG0B70S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1f8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B70S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B70S1_SEQUENCEREG0B70S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1fa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B70S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B70S2_SEQUENCEREG0B70S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1fc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B71S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B71S0_SEQUENCEREG0B71S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1fe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B71S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B71S1_SEQUENCEREG0B71S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x200++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B71S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B71S2_SEQUENCEREG0B71S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x202++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B72S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B72S0_SEQUENCEREG0B72S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x204++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B72S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B72S1_SEQUENCEREG0B72S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x206++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B72S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B72S2_SEQUENCEREG0B72S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x208++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B73S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B73S0_SEQUENCEREG0B73S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x20a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B73S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B73S1_SEQUENCEREG0B73S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x20c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B73S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B73S2_SEQUENCEREG0B73S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x20e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B74S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B74S0_SEQUENCEREG0B74S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x210++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B74S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B74S1_SEQUENCEREG0B74S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x212++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B74S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B74S2_SEQUENCEREG0B74S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x214++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B75S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B75S0_SEQUENCEREG0B75S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x216++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B75S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B75S1_SEQUENCEREG0B75S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x218++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B75S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B75S2_SEQUENCEREG0B75S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x21a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B76S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B76S0_SEQUENCEREG0B76S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x21c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B76S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B76S1_SEQUENCEREG0B76S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x21e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B76S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B76S2_SEQUENCEREG0B76S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x220++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B77S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B77S0_SEQUENCEREG0B77S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x222++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B77S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B77S1_SEQUENCEREG0B77S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x224++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B77S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B77S2_SEQUENCEREG0B77S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x226++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B78S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B78S0_SEQUENCEREG0B78S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x228++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B78S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B78S1_SEQUENCEREG0B78S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x22a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B78S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B78S2_SEQUENCEREG0B78S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x22c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B79S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B79S0_SEQUENCEREG0B79S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x22e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B79S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B79S1_SEQUENCEREG0B79S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x230++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B79S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B79S2_SEQUENCEREG0B79S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x232++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B80S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B80S0_SEQUENCEREG0B80S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x234++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B80S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B80S1_SEQUENCEREG0B80S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x236++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B80S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B80S2_SEQUENCEREG0B80S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x238++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B81S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B81S0_SEQUENCEREG0B81S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x23a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B81S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B81S1_SEQUENCEREG0B81S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x23c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B81S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B81S2_SEQUENCEREG0B81S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x23e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B82S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B82S0_SEQUENCEREG0B82S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x240++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B82S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B82S1_SEQUENCEREG0B82S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x242++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B82S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B82S2_SEQUENCEREG0B82S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x244++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B83S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B83S0_SEQUENCEREG0B83S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x246++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B83S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B83S1_SEQUENCEREG0B83S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x248++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B83S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B83S2_SEQUENCEREG0B83S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x24a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B84S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B84S0_SEQUENCEREG0B84S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x24c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B84S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B84S1_SEQUENCEREG0B84S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x24e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B84S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B84S2_SEQUENCEREG0B84S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x250++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B85S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B85S0_SEQUENCEREG0B85S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x252++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B85S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B85S1_SEQUENCEREG0B85S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x254++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B85S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B85S2_SEQUENCEREG0B85S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x256++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B86S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B86S0_SEQUENCEREG0B86S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x258++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B86S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B86S1_SEQUENCEREG0B86S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x25a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B86S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B86S2_SEQUENCEREG0B86S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x25c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B87S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B87S0_SEQUENCEREG0B87S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x25e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B87S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B87S1_SEQUENCEREG0B87S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x260++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B87S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B87S2_SEQUENCEREG0B87S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x262++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B88S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B88S0_SEQUENCEREG0B88S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x264++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B88S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B88S1_SEQUENCEREG0B88S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x266++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B88S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B88S2_SEQUENCEREG0B88S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x268++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B89S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B89S0_SEQUENCEREG0B89S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x26a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B89S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B89S1_SEQUENCEREG0B89S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x26c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B89S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B89S2_SEQUENCEREG0B89S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x26e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B90S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B90S0_SEQUENCEREG0B90S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x270++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B90S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B90S1_SEQUENCEREG0B90S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x272++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B90S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B90S2_SEQUENCEREG0B90S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x274++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B91S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B91S0_SEQUENCEREG0B91S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x276++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B91S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B91S1_SEQUENCEREG0B91S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x278++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B91S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B91S2_SEQUENCEREG0B91S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x27a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B92S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B92S0_SEQUENCEREG0B92S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x27c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B92S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B92S1_SEQUENCEREG0B92S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x27e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B92S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B92S2_SEQUENCEREG0B92S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x280++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B93S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B93S0_SEQUENCEREG0B93S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x282++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B93S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B93S1_SEQUENCEREG0B93S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x284++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B93S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B93S2_SEQUENCEREG0B93S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x286++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B94S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B94S0_SEQUENCEREG0B94S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x288++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B94S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B94S1_SEQUENCEREG0B94S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x28a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B94S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B94S2_SEQUENCEREG0B94S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x28c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B95S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B95S0_SEQUENCEREG0B95S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x28e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B95S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B95S1_SEQUENCEREG0B95S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x290++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B95S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B95S2_SEQUENCEREG0B95S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x292++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B96S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B96S0_SEQUENCEREG0B96S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x294++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B96S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B96S1_SEQUENCEREG0B96S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x296++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B96S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B96S2_SEQUENCEREG0B96S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x298++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B97S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B97S0_SEQUENCEREG0B97S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x29a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B97S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B97S1_SEQUENCEREG0B97S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x29c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B97S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B97S2_SEQUENCEREG0B97S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x29e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B98S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B98S0_SEQUENCEREG0B98S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B98S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B98S1_SEQUENCEREG0B98S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B98S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B98S2_SEQUENCEREG0B98S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B99S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B99S0_SEQUENCEREG0B99S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B99S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B99S1_SEQUENCEREG0B99S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2a8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B99S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B99S2_SEQUENCEREG0B99S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2aa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B100S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B100S0_SEQUENCEREG0B100S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2ac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B100S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B100S1_SEQUENCEREG0B100S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2ae++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B100S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B100S2_SEQUENCEREG0B100S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2b0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B101S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B101S0_SEQUENCEREG0B101S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2b2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B101S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B101S1_SEQUENCEREG0B101S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2b4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B101S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B101S2_SEQUENCEREG0B101S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2b6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B102S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B102S0_SEQUENCEREG0B102S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2b8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B102S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B102S1_SEQUENCEREG0B102S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2ba++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B102S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B102S2_SEQUENCEREG0B102S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2bc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B103S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B103S0_SEQUENCEREG0B103S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2be++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B103S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B103S1_SEQUENCEREG0B103S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2c0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B103S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B103S2_SEQUENCEREG0B103S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2c2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B104S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B104S0_SEQUENCEREG0B104S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2c4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B104S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B104S1_SEQUENCEREG0B104S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2c6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B104S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B104S2_SEQUENCEREG0B104S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2c8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B105S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B105S0_SEQUENCEREG0B105S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2ca++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B105S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B105S1_SEQUENCEREG0B105S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2cc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B105S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B105S2_SEQUENCEREG0B105S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2ce++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B106S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B106S0_SEQUENCEREG0B106S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2d0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B106S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B106S1_SEQUENCEREG0B106S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2d2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B106S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B106S2_SEQUENCEREG0B106S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2d4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B107S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B107S0_SEQUENCEREG0B107S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2d6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B107S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B107S1_SEQUENCEREG0B107S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2d8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B107S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B107S2_SEQUENCEREG0B107S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2da++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B108S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B108S0_SEQUENCEREG0B108S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2dc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B108S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B108S1_SEQUENCEREG0B108S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2de++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B108S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B108S2_SEQUENCEREG0B108S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2e0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B109S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B109S0_SEQUENCEREG0B109S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2e2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B109S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B109S1_SEQUENCEREG0B109S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2e4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B109S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B109S2_SEQUENCEREG0B109S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2e6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B110S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B110S0_SEQUENCEREG0B110S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2e8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B110S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B110S1_SEQUENCEREG0B110S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2ea++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B110S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B110S2_SEQUENCEREG0B110S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2ec++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B111S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B111S0_SEQUENCEREG0B111S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2ee++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B111S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B111S1_SEQUENCEREG0B111S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2f0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B111S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B111S2_SEQUENCEREG0B111S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2f2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B112S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B112S0_SEQUENCEREG0B112S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2f4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B112S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B112S1_SEQUENCEREG0B112S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2f6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B112S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B112S2_SEQUENCEREG0B112S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2f8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B113S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B113S0_SEQUENCEREG0B113S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2fa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B113S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B113S1_SEQUENCEREG0B113S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2fc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B113S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B113S2_SEQUENCEREG0B113S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2fe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B114S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B114S0_SEQUENCEREG0B114S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x300++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B114S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B114S1_SEQUENCEREG0B114S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x302++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B114S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B114S2_SEQUENCEREG0B114S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x304++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B115S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B115S0_SEQUENCEREG0B115S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x306++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B115S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B115S1_SEQUENCEREG0B115S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x308++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B115S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B115S2_SEQUENCEREG0B115S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x30a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B116S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B116S0_SEQUENCEREG0B116S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x30c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B116S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B116S1_SEQUENCEREG0B116S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x30e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B116S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B116S2_SEQUENCEREG0B116S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x310++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B117S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B117S0_SEQUENCEREG0B117S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x312++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B117S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B117S1_SEQUENCEREG0B117S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x314++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B117S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B117S2_SEQUENCEREG0B117S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x316++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B118S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B118S0_SEQUENCEREG0B118S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x318++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B118S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B118S1_SEQUENCEREG0B118S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x31a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B118S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B118S2_SEQUENCEREG0B118S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x31c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B119S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B119S0_SEQUENCEREG0B119S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x31e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B119S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B119S1_SEQUENCEREG0B119S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x320++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B119S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B119S2_SEQUENCEREG0B119S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x322++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B120S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B120S0_SEQUENCEREG0B120S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x324++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B120S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B120S1_SEQUENCEREG0B120S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x326++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B120S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B120S2_SEQUENCEREG0B120S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x328++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B121S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B121S0_SEQUENCEREG0B121S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x32a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B121S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B121S1_SEQUENCEREG0B121S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x32c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B121S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B121S2_SEQUENCEREG0B121S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x402++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR1_P0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR1_P0_SEQ0BGPR1_P0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x404++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR2_P0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR2_P0_SEQ0BGPR2_P0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x406++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR3_P0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR3_P0_SEQ0BGPR3_P0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x408++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR4_P0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR4_P0_SEQ0BGPR4_P0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x40a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR5_P0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR5_P0_SEQ0BGPR5_P0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x40c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR6_P0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR6_P0_SEQ0BGPR6_P0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x40e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR7_P0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR7_P0_SEQ0BGPR7_P0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x410++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR8_P0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BGPR8_P0_SEQ0BGPR8_P0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x5fe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BFIXEDADDRBITS, Reserved for PHY Initialization Engine (PIE) image use. RESET:0xf"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BFIXEDADDRBITS_RFU_SEQ0BFIXEDADDRBITS ,None RESET:0xf"
          
tree.end
    

tree "LPDDR4_PUB__DWC_DDRPHYA_DRTUB0"
base e:0x42180000
width 80.
rgroup.long 0x8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_DCTSHADOWREGS, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_DCTSHADOWREGS_RFU_DCTSHADOWREGS ,None RESET:0x0"
          
rgroup.long 0x60++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_DCTWRITEONLYSHADOW, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_DCTWRITEONLYSHADOW_DCTWRITEONLYSHADOW ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_UCTWRITEONLY, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_UCTWRITEONLY_UCTWRITEONLY ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x66++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_UCTWRITEPROT, Reserved for PHY training firmware use. RESET:0x1"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_UCTWRITEPROT_UCTWRITEPROT ,Reserved for PHY training firmware use. RESET:0x1"
          
group.long  0x68++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_UCTDATWRITEONLY, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_UCTDATWRITEONLY_UCTDATWRITEONLY ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x6a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_UCTDATWRITEPROT, Reserved for PHY training firmware use. RESET:0x1"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_UCTDATWRITEPROT_UCTDATWRITEPROT ,Reserved for PHY training firmware use. RESET:0x1"
          
group.long  0x6c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_UCTLERR, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_UCTLERR_UCTLERR ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_UCCLKHCLKENABLES, UcClk/Hclk Enables. [UcClk and Hclk run at either DFICLK or are gated] RESET:0x3"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_UCCLKHCLKENABLES_UCCLKEN ,When training has completed (and assuming no further need for the microcontroller), the enable should be set to 0 to reduce power. RESET:0x1"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_UCCLKHCLKENABLES_HCLKEN ,When training has completed (and assuming no further need for the training hardware), the enable should be set to 0 to reduce power. RESET:0x1"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_CURPSTATE0B, PIE current Pstate value RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_CURPSTATE0B_CURPSTATE0B ,PIE current Pstate value. This register is used to select values for writing by the Pstate sequencer and is written in the beginning of the Pstate switch. It can also be used to reference which Pstate the sequencer thinks it's in. RESET:0x0"
          
group.long  0x12a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_CLRWAKEUPSTICKY, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_CLRWAKEUPSTICKY_CLRWAKEUPSTICKY ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x12c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_WAKEUPMASK, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_WAKEUPMASK_WAKEUPMASK ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x1da++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_CUSTPUBREV, Customer settable PUB version number RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_CUSTPUBREV_CUSTPUBREV ,The customer settable PUB version number. The value is derived from the `define DWC_DDRPHY_CUST_PUBREV RESET:0x0"
          
rgroup.long 0x1dc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_PUBREV, The hardware version of this PUB, excluding the PHY RESET:0x2450"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_PUBREV_PUBMNR ,Indicates minor update of the PUB. RESET:0x5"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_PUBREV_PUBMDR ,Indicates moderate revision of the PUB. RESET:0x4"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DRTUB0_PUBREV_PUBMJR ,Indicates major revision of the PUB. RESET:0x2"
          
tree.end
    

tree "LPDDR4_PUB__DWC_DDRPHYA_APBONLY0"
base e:0x421a0000
width 80.
group.long  0x0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_MICROCONTMUXSEL, PMU Config Mux Select RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_MICROCONTMUXSEL_MICROCONTMUXSEL ,This register controls access to the PHY configuration registers. - 1 : MicroController/PHY Init Engine has control of csr bus. - 0 : Access to CSR bus available via APB interface, according to the APB Interface Access Rules described in the PUB databook RESET:0x0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_UCTSHADOWREGS, This is used for the mailbox protocol between the firmware and the system. See section 3.4.1 of the training firmware AppNote for details on the protocol. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_UCTSHADOWREGS_UCTWRITEPROTSHADOW ,When set to 0, the PMU has a message for the user RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_UCTSHADOWREGS_UCTDATWRITEPROTSHADOW ,Reserved for future use. RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_DCTWRITEONLY, Reserved for future use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_DCTWRITEONLY_DCTWRITEONLY ,Reserved for future use. RESET:0x0"
          
group.long  0x62++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_DCTWRITEPROT, DCT downstream mailbox protocol CSR. RESET:0x1"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_DCTWRITEPROT_DCTWRITEPROT ,By setting this register to 0, the user acknowledges the receipt of the message. RESET:0x1"
          
rgroup.long 0x64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_UCTWRITEONLYSHADOW, Read-only view of the csr UctDatWriteOnly RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_UCTWRITEONLYSHADOW_UCTWRITEONLYSHADOW ,Used to pass the message ID for major messages. Also used to pass the lower 16 bits for streaming messages. RESET:0x0"
          
rgroup.long 0x68++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_UCTDATWRITEONLYSHADOW, Read-only view of the csr UctDatWriteOnly RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_UCTDATWRITEONLYSHADOW_UCTDATWRITEONLYSHADOW ,Used to pass the upper 16 bits for streaming messages. Not used in passing major messages. RESET:0x0"
          
group.long  0x6a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_NEVERGATECSRCLOCK, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_NEVERGATECSRCLOCK_NEVERGATECSRCLOCK ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x6e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_DFICFGRDDATAVALIDTICKS, Number of DfiClk ticks required for valid csr Rd Data. RESET:0x6"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_DFICFGRDDATAVALIDTICKS_DFICFGRDDATAVALIDTICKS ,Roundtrip delay of a register read access. This value must not be changed from its reset value. RESET:0x6"
          
group.long  0x132++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_MICRORESET, Controls reset and clock shutdown on the local microcontroller. RESET:0x1"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_MICRORESET_STALLTOMICRO ,This field is programmable as follows:  - Set this bit to stall the microcontroller by hardware.  - Clear this bit to allow the microcontroller to continue executing from its current   program counter location. Typically, this bit is used at power up to hold the program counter at the boot vector while BIOS loads the microcontroller program code. While stalled, the microcontroller clocks are gated off for power reduction. RESET:0x1"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_MICRORESET_TESTWAKEUP ,Reserved. Must always be set to 0. RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_MICRORESET_RSVDMICRO ,RSVD RESET:0x0"
          
         bitfld.long 0x00 3. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_MICRORESET_RESETTOMICRO ,This field is programmable as follows:  - Set this bit to apply synchronous reset to the microcontroller.  - Clear this bit to release reset to the microcontroller. Note: This reset initializes the program counter to begin execution from the boot vector. This reset also clears the interrupt sticky bits. RESET:0x0"
          
group.long  0x1ce++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_SEQUENCEROVERRIDE, Reserved for PHY training firmware use. RESET:0x80"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_SEQUENCEROVERRIDE_RFU_SEQUENCEROVERRIDE ,None RESET:0x80"
          
rgroup.long 0x1f4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_DFIINITCOMPLETESHADOW, dfi_init_complete - Controller Read-only Shadow RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_APBONLY0_DFIINITCOMPLETESHADOW_DFIINITCOMPLETESHADOW ,This csr presents a read-only view (a shadow) of the Register DfiInitComplete which is used by the sequencer to control the state of dfi_init_complete. The value in this Register is not affected by the BlockSeq0BAck field of the SequencerOverride register. While the Register MicroContMuxSel is set, access to this Shadow register will not steal config bus bandwidth from the micro controller. That is polling won't have a performance penalty. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_ANIB0_P1"
base e:0x42200000
width 80.
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P1_ATXDLY_P1, Address/Command Delay, per pstate. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P1_ATXDLY_P1_ATXDLY_P1 ,Trained for LPDDR3/4 to generate timed address and command signals to the DRAMs, per ACX4. For DDR3/DDR4, it is recommended that address and command ACX4 have it ATxDly=0x00 The four signals generated by an ACX4 will have common timing.  - ATxDly[6] is the coarse delay, ie one unit of delay is 1 UI.  - ATxDly[5] is reserved.  - ATxDly[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32. The target ACX4 used for memory clock generation, must have its ATxDly configured to 0x00. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_ANIB1_P1"
base e:0x42202000
width 80.
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P1_ATXDLY_P1, Address/Command Delay, per pstate. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P1_ATXDLY_P1_ATXDLY_P1 ,Trained for LPDDR3/4 to generate timed address and command signals to the DRAMs, per ACX4. For DDR3/DDR4, it is recommended that address and command ACX4 have it ATxDly=0x00 The four signals generated by an ACX4 will have common timing.  - ATxDly[6] is the coarse delay, ie one unit of delay is 1 UI.  - ATxDly[5] is reserved.  - ATxDly[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32. The target ACX4 used for memory clock generation, must have its ATxDly configured to 0x00. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_ANIB2_P1"
base e:0x42204000
width 80.
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P1_ATXDLY_P1, Address/Command Delay, per pstate. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P1_ATXDLY_P1_ATXDLY_P1 ,Trained for LPDDR3/4 to generate timed address and command signals to the DRAMs, per ACX4. For DDR3/DDR4, it is recommended that address and command ACX4 have it ATxDly=0x00 The four signals generated by an ACX4 will have common timing.  - ATxDly[6] is the coarse delay, ie one unit of delay is 1 UI.  - ATxDly[5] is reserved.  - ATxDly[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32. The target ACX4 used for memory clock generation, must have its ATxDly configured to 0x00. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_DBYTE0_P1"
base e:0x42220000
width 80.
group.long  0x6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_USEDQSENREPLICA_P1, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_USEDQSENREPLICA_P1_USEDQSENREPLICA_P1 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DFIMRL_P1, DFI MaxReadLatency RESET:0x6"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DFIMRL_P1_DFIMRL_P1 ,This Max Read Latency CSR is to be trained to ensure the rx-data fifo is not read until after all dbytes have their read data valid. This is the value, in units of two mem clocks, between dfi_rddata_en and dfi_rddata_valid A unit change in the LSB is a change in MRL of two mem clocks. RESET:0x6"
          
group.long  0x82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL0_B0_P1, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL0_B0_P1_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL0_B0_P1_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DQDQSRCVCNTRL_B0_P1, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DQDQSRCVCNTRL_B0_P1_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DQDQSRCVCNTRL_B0_P1_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DQDQSRCVCNTRL_B0_P1_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DQDQSRCVCNTRL_B0_P1_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DQDQSRCVCNTRL_B0_P1_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x90++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXEQUALIZATIONMODE_P1, Tx DQ driver equalization is a technique for improving the write-data eye at the DRAMs. The driver can drive with full strength (configured with DrvStrenFSHiDqP and DrvStrenFSLoDqN0 or with weak strength (configured with DrvStrenEQHiDqP and DrvStrenEQLoDqN) depending on the dq value sequence.  - TxEqMode = 00 Off; drive with full strength only  - TxEqMode = 01 Mode0 drive with full strength.or weak strength depending on  present logical value and the previous logical value.  - TxEqMode = 10 Mode1 drive with full strength.or weak strength depending on  present logical value and the next logical value. Mode1 is a lower power mode.  - TxEqMode = 11 reserved RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXEQUALIZATIONMODE_P1_TXEQMODE ,Tx dq driver equalization mode controls. FFE, de-emphasis DDR43 PHY ONLY RESET:0x0"
          
group.long  0x92++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL1_B0_P1, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL1_B0_P1_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL1_B0_P1_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x96++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL2_B0_P1, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL2_B0_P1_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL2_B0_P1_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x98++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DQDQSRCVCNTRL2_P1, Control for an aggressive power-saving feature to powerdown dq and dqs receiver cells dynamically. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DQDQSRCVCNTRL2_P1_ENRXAGRESSIVEPDR ,reserved RESET:0x0"
          
group.long  0x9a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXODTDRVSTREN_B0_P1, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXODTDRVSTREN_B0_P1_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXODTDRVSTREN_B0_P1_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
group.long  0xbe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXSLEWRATE_B0_P1, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXSLEWRATE_B0_P1_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXSLEWRATE_B0_P1_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXSLEWRATE_B0_P1_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG0_U0_P1, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG0_U0_P1_RXENDLYTG0_U0_P1 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG1_U0_P1, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG1_U0_P1_RXENDLYTG1_U0_P1 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x104++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG2_U0_P1, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG2_U0_P1_RXENDLYTG2_U0_P1 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x106++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG3_U0_P1, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG3_U0_P1_RXENDLYTG3_U0_P1 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x118++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG0_U0_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG0_U0_P1_RXCLKDLYTG0_U0_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x11a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG1_U0_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG1_U0_P1_RXCLKDLYTG1_U0_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x11c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG2_U0_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG2_U0_P1_RXCLKDLYTG2_U0_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x11e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG3_U0_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG3_U0_P1_RXCLKDLYTG3_U0_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x120++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG0_U0_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG0_U0_P1_RXCLKCDLYTG0_U0_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x122++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG1_U0_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG1_U0_P1_RXCLKCDLYTG1_U0_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x124++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG2_U0_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG2_U0_P1_RXCLKCDLYTG2_U0_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x126++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG3_U0_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG3_U0_P1_RXCLKCDLYTG3_U0_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x15c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_PPTDQSCNTINVTRNTG0_P1, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_PPTDQSCNTINVTRNTG0_P1_PPTDQSCNTINVTRNTG0_P1 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x15e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_PPTDQSCNTINVTRNTG1_P1, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_PPTDQSCNTINVTRNTG1_P1_PPTDQSCNTINVTRNTG1_P1 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R0_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R0_P1_TXDQDLYTG0_R0_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R0_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R0_P1_TXDQDLYTG1_R0_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R0_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R0_P1_TXDQDLYTG2_R0_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R0_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R0_P1_TXDQDLYTG3_R0_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG0_U0_P1, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG0_U0_P1_TXDQSDLYTG0_U0_P1 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x1a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG1_U0_P1, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG1_U0_P1_TXDQSDLYTG1_U0_P1 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x1a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG2_U0_P1, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG2_U0_P1_TXDQSDLYTG2_U0_P1 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x1a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG3_U0_P1, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG3_U0_P1_TXDQSDLYTG3_U0_P1 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x282++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL0_B1_P1, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL0_B1_P1_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL0_B1_P1_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x286++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DQDQSRCVCNTRL_B1_P1, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DQDQSRCVCNTRL_B1_P1_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DQDQSRCVCNTRL_B1_P1_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DQDQSRCVCNTRL_B1_P1_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DQDQSRCVCNTRL_B1_P1_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_DQDQSRCVCNTRL_B1_P1_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x292++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL1_B1_P1, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL1_B1_P1_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL1_B1_P1_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x296++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL2_B1_P1, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL2_B1_P1_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXIMPEDANCECTRL2_B1_P1_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x29a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXODTDRVSTREN_B1_P1, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXODTDRVSTREN_B1_P1_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXODTDRVSTREN_B1_P1_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
group.long  0x2be++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXSLEWRATE_B1_P1, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXSLEWRATE_B1_P1_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXSLEWRATE_B1_P1_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXSLEWRATE_B1_P1_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0x300++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG0_U1_P1, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG0_U1_P1_RXENDLYTG0_U1_P1 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x302++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG1_U1_P1, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG1_U1_P1_RXENDLYTG1_U1_P1 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x304++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG2_U1_P1, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG2_U1_P1_RXENDLYTG2_U1_P1 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x306++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG3_U1_P1, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXENDLYTG3_U1_P1_RXENDLYTG3_U1_P1 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x318++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG0_U1_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG0_U1_P1_RXCLKDLYTG0_U1_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x31a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG1_U1_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG1_U1_P1_RXCLKDLYTG1_U1_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x31c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG2_U1_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG2_U1_P1_RXCLKDLYTG2_U1_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x31e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG3_U1_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKDLYTG3_U1_P1_RXCLKDLYTG3_U1_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x320++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG0_U1_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG0_U1_P1_RXCLKCDLYTG0_U1_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x322++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG1_U1_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG1_U1_P1_RXCLKCDLYTG1_U1_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x324++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG2_U1_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG2_U1_P1_RXCLKCDLYTG2_U1_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x326++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG3_U1_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_RXCLKCDLYTG3_U1_P1_RXCLKCDLYTG3_U1_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x380++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R1_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R1_P1_TXDQDLYTG0_R1_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x382++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R1_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R1_P1_TXDQDLYTG1_R1_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x384++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R1_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R1_P1_TXDQDLYTG2_R1_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x386++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R1_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R1_P1_TXDQDLYTG3_R1_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x3a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG0_U1_P1, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG0_U1_P1_TXDQSDLYTG0_U1_P1 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x3a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG1_U1_P1, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG1_U1_P1_TXDQSDLYTG1_U1_P1 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x3a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG2_U1_P1, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG2_U1_P1_TXDQSDLYTG2_U1_P1 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x3a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG3_U1_P1, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQSDLYTG3_U1_P1_TXDQSDLYTG3_U1_P1 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x580++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R2_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R2_P1_TXDQDLYTG0_R2_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x582++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R2_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R2_P1_TXDQDLYTG1_R2_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x584++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R2_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R2_P1_TXDQDLYTG2_R2_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x586++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R2_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R2_P1_TXDQDLYTG3_R2_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x780++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R3_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R3_P1_TXDQDLYTG0_R3_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x782++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R3_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R3_P1_TXDQDLYTG1_R3_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x784++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R3_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R3_P1_TXDQDLYTG2_R3_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x786++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R3_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R3_P1_TXDQDLYTG3_R3_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x980++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R4_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R4_P1_TXDQDLYTG0_R4_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x982++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R4_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R4_P1_TXDQDLYTG1_R4_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x984++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R4_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R4_P1_TXDQDLYTG2_R4_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x986++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R4_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R4_P1_TXDQDLYTG3_R4_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xb80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R5_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R5_P1_TXDQDLYTG0_R5_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xb82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R5_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R5_P1_TXDQDLYTG1_R5_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xb84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R5_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R5_P1_TXDQDLYTG2_R5_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xb86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R5_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R5_P1_TXDQDLYTG3_R5_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xd80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R6_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R6_P1_TXDQDLYTG0_R6_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xd82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R6_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R6_P1_TXDQDLYTG1_R6_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xd84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R6_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R6_P1_TXDQDLYTG2_R6_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xd86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R6_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R6_P1_TXDQDLYTG3_R6_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xf80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R7_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R7_P1_TXDQDLYTG0_R7_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xf82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R7_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R7_P1_TXDQDLYTG1_R7_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xf84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R7_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R7_P1_TXDQDLYTG2_R7_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xf86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R7_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R7_P1_TXDQDLYTG3_R7_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R8_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG0_R8_P1_TXDQDLYTG0_R8_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x1182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R8_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG1_R8_P1_TXDQDLYTG1_R8_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x1184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R8_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG2_R8_P1_TXDQDLYTG2_R8_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x1186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R8_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P1_TXDQDLYTG3_R8_P1_TXDQDLYTG3_R8_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_DBYTE1_P1"
base e:0x42222000
width 80.
group.long  0x6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_USEDQSENREPLICA_P1, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_USEDQSENREPLICA_P1_USEDQSENREPLICA_P1 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DFIMRL_P1, DFI MaxReadLatency RESET:0x6"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DFIMRL_P1_DFIMRL_P1 ,This Max Read Latency CSR is to be trained to ensure the rx-data fifo is not read until after all dbytes have their read data valid. This is the value, in units of two mem clocks, between dfi_rddata_en and dfi_rddata_valid A unit change in the LSB is a change in MRL of two mem clocks. RESET:0x6"
          
group.long  0x82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL0_B0_P1, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL0_B0_P1_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL0_B0_P1_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DQDQSRCVCNTRL_B0_P1, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DQDQSRCVCNTRL_B0_P1_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DQDQSRCVCNTRL_B0_P1_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DQDQSRCVCNTRL_B0_P1_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DQDQSRCVCNTRL_B0_P1_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DQDQSRCVCNTRL_B0_P1_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x90++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXEQUALIZATIONMODE_P1, Tx DQ driver equalization is a technique for improving the write-data eye at the DRAMs. The driver can drive with full strength (configured with DrvStrenFSHiDqP and DrvStrenFSLoDqN0 or with weak strength (configured with DrvStrenEQHiDqP and DrvStrenEQLoDqN) depending on the dq value sequence.  - TxEqMode = 00 Off; drive with full strength only  - TxEqMode = 01 Mode0 drive with full strength.or weak strength depending on  present logical value and the previous logical value.  - TxEqMode = 10 Mode1 drive with full strength.or weak strength depending on  present logical value and the next logical value. Mode1 is a lower power mode.  - TxEqMode = 11 reserved RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXEQUALIZATIONMODE_P1_TXEQMODE ,Tx dq driver equalization mode controls. FFE, de-emphasis DDR43 PHY ONLY RESET:0x0"
          
group.long  0x92++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL1_B0_P1, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL1_B0_P1_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL1_B0_P1_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x96++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL2_B0_P1, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL2_B0_P1_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL2_B0_P1_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x98++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DQDQSRCVCNTRL2_P1, Control for an aggressive power-saving feature to powerdown dq and dqs receiver cells dynamically. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DQDQSRCVCNTRL2_P1_ENRXAGRESSIVEPDR ,reserved RESET:0x0"
          
group.long  0x9a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXODTDRVSTREN_B0_P1, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXODTDRVSTREN_B0_P1_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXODTDRVSTREN_B0_P1_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
group.long  0xbe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXSLEWRATE_B0_P1, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXSLEWRATE_B0_P1_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXSLEWRATE_B0_P1_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXSLEWRATE_B0_P1_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG0_U0_P1, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG0_U0_P1_RXENDLYTG0_U0_P1 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG1_U0_P1, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG1_U0_P1_RXENDLYTG1_U0_P1 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x104++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG2_U0_P1, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG2_U0_P1_RXENDLYTG2_U0_P1 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x106++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG3_U0_P1, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG3_U0_P1_RXENDLYTG3_U0_P1 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x118++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG0_U0_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG0_U0_P1_RXCLKDLYTG0_U0_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x11a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG1_U0_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG1_U0_P1_RXCLKDLYTG1_U0_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x11c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG2_U0_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG2_U0_P1_RXCLKDLYTG2_U0_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x11e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG3_U0_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG3_U0_P1_RXCLKDLYTG3_U0_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x120++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG0_U0_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG0_U0_P1_RXCLKCDLYTG0_U0_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x122++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG1_U0_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG1_U0_P1_RXCLKCDLYTG1_U0_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x124++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG2_U0_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG2_U0_P1_RXCLKCDLYTG2_U0_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x126++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG3_U0_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG3_U0_P1_RXCLKCDLYTG3_U0_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x15c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_PPTDQSCNTINVTRNTG0_P1, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_PPTDQSCNTINVTRNTG0_P1_PPTDQSCNTINVTRNTG0_P1 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x15e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_PPTDQSCNTINVTRNTG1_P1, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_PPTDQSCNTINVTRNTG1_P1_PPTDQSCNTINVTRNTG1_P1 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R0_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R0_P1_TXDQDLYTG0_R0_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R0_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R0_P1_TXDQDLYTG1_R0_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R0_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R0_P1_TXDQDLYTG2_R0_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R0_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R0_P1_TXDQDLYTG3_R0_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG0_U0_P1, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG0_U0_P1_TXDQSDLYTG0_U0_P1 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x1a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG1_U0_P1, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG1_U0_P1_TXDQSDLYTG1_U0_P1 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x1a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG2_U0_P1, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG2_U0_P1_TXDQSDLYTG2_U0_P1 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x1a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG3_U0_P1, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG3_U0_P1_TXDQSDLYTG3_U0_P1 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x282++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL0_B1_P1, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL0_B1_P1_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL0_B1_P1_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x286++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DQDQSRCVCNTRL_B1_P1, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DQDQSRCVCNTRL_B1_P1_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DQDQSRCVCNTRL_B1_P1_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DQDQSRCVCNTRL_B1_P1_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DQDQSRCVCNTRL_B1_P1_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_DQDQSRCVCNTRL_B1_P1_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x292++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL1_B1_P1, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL1_B1_P1_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL1_B1_P1_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x296++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL2_B1_P1, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL2_B1_P1_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXIMPEDANCECTRL2_B1_P1_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x29a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXODTDRVSTREN_B1_P1, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXODTDRVSTREN_B1_P1_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXODTDRVSTREN_B1_P1_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
group.long  0x2be++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXSLEWRATE_B1_P1, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXSLEWRATE_B1_P1_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXSLEWRATE_B1_P1_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXSLEWRATE_B1_P1_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0x300++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG0_U1_P1, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG0_U1_P1_RXENDLYTG0_U1_P1 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x302++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG1_U1_P1, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG1_U1_P1_RXENDLYTG1_U1_P1 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x304++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG2_U1_P1, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG2_U1_P1_RXENDLYTG2_U1_P1 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x306++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG3_U1_P1, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXENDLYTG3_U1_P1_RXENDLYTG3_U1_P1 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x318++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG0_U1_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG0_U1_P1_RXCLKDLYTG0_U1_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x31a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG1_U1_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG1_U1_P1_RXCLKDLYTG1_U1_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x31c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG2_U1_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG2_U1_P1_RXCLKDLYTG2_U1_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x31e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG3_U1_P1, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKDLYTG3_U1_P1_RXCLKDLYTG3_U1_P1 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x320++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG0_U1_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG0_U1_P1_RXCLKCDLYTG0_U1_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x322++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG1_U1_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG1_U1_P1_RXCLKCDLYTG1_U1_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x324++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG2_U1_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG2_U1_P1_RXCLKCDLYTG2_U1_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x326++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG3_U1_P1, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_RXCLKCDLYTG3_U1_P1_RXCLKCDLYTG3_U1_P1 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x380++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R1_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R1_P1_TXDQDLYTG0_R1_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x382++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R1_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R1_P1_TXDQDLYTG1_R1_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x384++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R1_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R1_P1_TXDQDLYTG2_R1_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x386++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R1_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R1_P1_TXDQDLYTG3_R1_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x3a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG0_U1_P1, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG0_U1_P1_TXDQSDLYTG0_U1_P1 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x3a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG1_U1_P1, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG1_U1_P1_TXDQSDLYTG1_U1_P1 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x3a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG2_U1_P1, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG2_U1_P1_TXDQSDLYTG2_U1_P1 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x3a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG3_U1_P1, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQSDLYTG3_U1_P1_TXDQSDLYTG3_U1_P1 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x580++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R2_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R2_P1_TXDQDLYTG0_R2_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x582++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R2_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R2_P1_TXDQDLYTG1_R2_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x584++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R2_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R2_P1_TXDQDLYTG2_R2_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x586++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R2_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R2_P1_TXDQDLYTG3_R2_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x780++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R3_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R3_P1_TXDQDLYTG0_R3_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x782++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R3_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R3_P1_TXDQDLYTG1_R3_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x784++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R3_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R3_P1_TXDQDLYTG2_R3_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x786++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R3_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R3_P1_TXDQDLYTG3_R3_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x980++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R4_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R4_P1_TXDQDLYTG0_R4_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x982++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R4_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R4_P1_TXDQDLYTG1_R4_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x984++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R4_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R4_P1_TXDQDLYTG2_R4_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x986++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R4_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R4_P1_TXDQDLYTG3_R4_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xb80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R5_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R5_P1_TXDQDLYTG0_R5_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xb82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R5_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R5_P1_TXDQDLYTG1_R5_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xb84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R5_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R5_P1_TXDQDLYTG2_R5_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xb86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R5_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R5_P1_TXDQDLYTG3_R5_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xd80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R6_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R6_P1_TXDQDLYTG0_R6_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xd82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R6_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R6_P1_TXDQDLYTG1_R6_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xd84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R6_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R6_P1_TXDQDLYTG2_R6_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xd86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R6_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R6_P1_TXDQDLYTG3_R6_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xf80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R7_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R7_P1_TXDQDLYTG0_R7_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xf82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R7_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R7_P1_TXDQDLYTG1_R7_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xf84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R7_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R7_P1_TXDQDLYTG2_R7_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xf86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R7_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R7_P1_TXDQDLYTG3_R7_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R8_P1, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG0_R8_P1_TXDQDLYTG0_R8_P1 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x1182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R8_P1, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG1_R8_P1_TXDQDLYTG1_R8_P1 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x1184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R8_P1, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG2_R8_P1_TXDQDLYTG2_R8_P1 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x1186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R8_P1, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P1_TXDQDLYTG3_R8_P1_TXDQDLYTG3_R8_P1 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_MASTER0_P1"
base e:0x42240000
width 80.
group.long  0x10++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_CALUCLKINFO_P1, Informs the impedance calibration engine about frequency of DfiClk RESET:0x320"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_CALUCLKINFO_P1_CALUCLKTICKSPER1US ,Must be programmed to the number of DfiClks in 1us (rounded up), with minimum value of 24. - if (DfiClk < 24MHz) CalUclkInfo = 24 - else CalUclkInfo = (number of DfiClks in 1us) RESET:0x320"
          
group.long  0x16++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_SEQ0BDLY0_P1, PHY Initialization Engine (PIE) Delay Register 0 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_SEQ0BDLY0_P1_SEQ0BDLY0_P1 ,PHY Initialization Engine (PIE) Delay Register 0. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_SEQ0BDLY1_P1, PHY Initialization Engine (PIE) Delay Register 1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_SEQ0BDLY1_P1_SEQ0BDLY1_P1 ,PHY Initialization Engine (PIE) Delay Register 1. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x1a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_SEQ0BDLY2_P1, PHY Initialization Engine (PIE) Delay Register 2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_SEQ0BDLY2_P1_SEQ0BDLY2_P1 ,PHY Initialization Engine (PIE) Delay Register 2. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_SEQ0BDLY3_P1, PHY Initialization Engine (PIE) Delay Register 3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_SEQ0BDLY3_P1_SEQ0BDLY3_P1 ,PHY Initialization Engine (PIE) Delay Register 3. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PPTTRAINSETUP_P1, For LPDDR3/4 some tracking is required periodically using the DFI PHY MASTER interface. This register control the interval. Setting the register to 0 completely disables the PHY Master Interface. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PPTTRAINSETUP_P1_PHYMSTRTRAININTERVAL ,Bits 3:0 of this register specifies the time between the end of one training and the start of the next. Note that, to account for the delay to receive the acknowledge from the MC, the dfi_phymstr_req signal is asserted in advance so that the effective update (after acknowledge from the MC) occurs inside the interval defined by PhyMstrTrainInterval.  - 4'b0000 Disable PHY Master Interface  - 4'b0001 PHY MASTER Request Interval = 524288 MEMCLKs  - 4'b0010 PHY MASTER Request Interval = 1048576 MEMCLKs  - 4'b0011 PHY MASTER Request Interval = 2097152 MEMCLKs  - 4'b0100 PHY MASTER Request Interval = 4194304 MEMCLKs  - 4'b0101 PHY MASTER Request Interval = 8388608 MEMCLKs  - 4'b0110 PHY MASTER Request Interval = 16777216 MEMCLKs  - 4'b0111 PHY MASTER Request Interval = 33554432 MEMCLKs  - 4'b1000 PHY MASTER Request Interval = 67108864 MEMCLKs  - 4'b1001 PHY MASTER Request Interval = 134217728 MEMCLKs  - 4'b1010 PHY MASTER Request Interval = 268435456 MEMCLKs  - 4'b1011 - 4'b1111 PHY MASTER Request Interval = undefined RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PPTTRAINSETUP_P1_PHYMSTRMAXREQTOACK ,The value in bits 6:4 of this register specify the max time from tdfi_phymstr_req asserted to tdfi_phymstr_ack asserted. If the request is not acknowledged by this time, dfi_error will be asserted.  - 3'b000 Disable PHY Master Interface  - 3'b001 set tPHYMSTR_resp. = 512 MEMCLKs  - 3'b010 set tPHYMSTR_resp. = 1024 MEMCLKs  - 3'b011 set tPHYMSTR_resp. = 2048 MEMCLKs  - 3'b100 set tPHYMSTR_resp. = 4096 MEMCLKs  - 3'b101 set tPHYMSTR_resp. = 8192 MEMCLKs  - 3'b110 set tPHYMSTR_resp. = 32768 MEMCLKs  - 3'b111 set tPHYMSTR_resp. = undefined  Note: The above are nominal values. The actual values are reduced by (2 + (DWC_DDRPHY_PIPE_DFI_MISC * MEMCLK/DfiCtlClk)) * 2  Note: This signal interacts with dfi_phyupd_req. See Section Collisions Between PHY Update and DFI LP of the PUB Databook. RESET:0x0"
          
group.long  0x22++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PPTTRAINSETUP2_P1, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x2"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PPTTRAINSETUP2_P1_RFU_PPTTRAINSETUP2_P1 ,None RESET:0x2"
          
group.long  0x32++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_TRISTATEMODECA_P1, This register is used to control the PHY Dynamic Address/Command Tristate Feature, and the stopped MEMCLK state. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_TRISTATEMODECA_P1_DISDYNADRTRI ,When DisDynAdrTri=1, Dynamic Tristating is disabled. Dynamic Tristating is on by default. Dynamic Tristating should be disabled (DisDynAdrTri=1) for these modes:  - DR3/2T if the controller cannot follow the 2T PHY tristate protocol.  - DDR4/2T/2N if the controller cannot follow the 2T PHY tristate protocol.  - LPDDR4 When DisDynAdrTri=0 (default),  - In DDR4 mode, The following SDRAM pins can be dynamically tristated: A,BA,BG,ACT_n  - In LPDDR3 mode, The following SDRAM pins can be dynamically tristated: CA[*]  - In 1T mode, the PHY will tristate the relevant pins when all ranks are DESelected  - In 2T mode (or geardown), the PHY will tristate the relevant pins when:  -- DDR3 -- All ranks DESelected (all CS_L==1) AND [RAS_n,CAS_n,WE_n,BA0] = [1,1,1,0]  -- DDR4 -- All ranks DESelected (all CS_L==1) AND [RAS_n,CAS_n,WE_n,BA0,ACT_n] = [1,1,1,0,1]  - When in this mode, the controller should avoid sending the above patterns with any rank selected. [e.g. NOPs sent by the controller should have BA0 set to a non-zero value] RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_TRISTATEMODECA_P1_DDR2TMODE ,Must be set to 1 for Dynamic Tristate to work when CA bus is 2T or Geardown mode. This CSR bit has no effect when DisDynAdrTri==1 RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_TRISTATEMODECA_P1_CKDISVAL ,The PHY provides 4 memory clocks, n=0..3.  - When the toggling of memory clock CK_t[n] is disabled with dfi_clk_disable[n]=1, the memory clock CK_t[n] is driven with Register CkDisVal[1].  - When the toggling of memory clock CK_c[n] is disabled with dfi_clk_disable[n]=1, the memory clock CK_c[n] is driven with ~(Register CkDisVal[0]) (ie inverted).  Note that the non-toggling differential memory clock [CK_t[n],CK_c[n]] may be driven with any combination, LL,LH,HL,HH; the default [CK_t[n],CK_c[n]]=LH. RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_HWTMRL_P1, HWT MaxReadLatency. RESET:0x6"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_HWTMRL_P1_HWTMRL_P1 ,This MASTER copy of MRL is used by the PHY training firmware only. RESET:0x6"
          
group.long  0x48++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DQSPREAMBLECONTROL_P1, For improved robustness in operating with DRAM timing drift, this register provides controls for the width of the write DQS preamble and postamble, and controls for the anticipated width of DQS preamble for reads. RESET:0x8"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DQSPREAMBLECONTROL_P1_TWOTCKRXDQSPRE ,Widens the RxDqsEn window to allow larger drift in the incoming read DQS to take advantage of the larger/wider preamble generated by the DRAMSs when the D4 DRAMS are configured with DDR4 MR4 A11 Read Preamble=1 for causing a 2nCK read preamble. For LPDDR4, set to 1 for static read preamble, set to 0 for toggling read preamble.  Note the nominal trained-to-center point will be earlier relative to the first strobing edge of DQS than when not in this mode. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DQSPREAMBLECONTROL_P1_TWOTCKTXDQSPRE ,For LPDDR4, all write operations are 2nCK such that this control must be set to 1. RESET:0x0"
          
         hexmask.long 0x00 2.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DQSPREAMBLECONTROL_P1_POSITIONDFEINIT ,For DDR4 phy only when receive DFE is enabled.  - PositionDfeInit[2] is reserved  - PositionDfeInit[1]=1 causes DfeInit to be asserted at the nominal time  - PositionDfeInit[0] is reserved PositionDfeInit=3'b010 is the nominal, recommended value for leading edge used by receiver, other values are reserved. RESET:0x2"
          
         bitfld.long 0x00 5. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DQSPREAMBLECONTROL_P1_LP4TGLTWOTCKTXDQSPRE ,Used in LPDDR4 mode to modify the early preamble when Register TwoTckTxDqsPre=1 - 0: level first-memclk preamble - 1: toggling first-memclk preamble RESET:0x0"
          
         bitfld.long 0x00 6. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DQSPREAMBLECONTROL_P1_LP4POSTAMBLEEXT ,In LPDDR4 mode must be set to extend the write postamble. - 0: half-memclk postamble, as in D4 - 1: one-and-one-half-memclk postamble; see LPDDR4 Spec MR3, OP[1] WR PST, vendor-specific function. RESET:0x0"
          
         bitfld.long 0x00 7. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DQSPREAMBLECONTROL_P1_LP4STTCPREBRIDGERXEN ,Used in LPDDR4 static-preamble mode to bridge the RxEn between two reads to the same timing group when the bubble is 1 memclk. LPDDR4 static-preamble mode is set in the DRAMs with MR1, OP[3]=0. RESET:0x0"
          
         bitfld.long 0x00 8. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DQSPREAMBLECONTROL_P1_WDQSEXTENSION ,When set, DQS_T and DQS_C will be driven differentially to 0 and 1, respectively, before and after a write burst, except during a memory read transaction. See DesignWare Cores LPDDR4 MultiPHY: WDQS Extension Application Note. Use of WDQSEXTENSION requires POdtTailWidth=3 and POdtStartDelay=00 RESET:0x0"
          
group.long  0x5a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DMIPINPRESENT_P1, This Register is used to instruct the PHY whether to enable the Read-DBI function on Lane8 of each DBYTE. Only the LPDDR4 and DDR4 Protocols support the Read-DBI feature. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DMIPINPRESENT_P1_RDDBIENABLED ,This bit must be set to 1'b1 if Read-DBI is enabled in a connected DDR4 or LPDDR4 device. If set, the following DRAM MR should also be set [DDR4.MR5.A12=1 or LPDDR4.MR3.OP[7]=1] RESET:0x0"
          
group.long  0x5c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_ARDPTRINITVAL_P1, Address/Command FIFO ReadPointer Initial Value RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_ARDPTRINITVAL_P1_ARDPTRINITVAL_P1 ,This is the initial Pointer Offset for the free-running FIFOs in the DBYTE and ACX4 hardips. The units of this register are in UI. The pointer separation should be chosen to compensate for all sources of skew and drift of the PHY DFICLK and PCLK networks. See 'ARdPtrInitVal Impacts From Construction Skews' of the PUB databook. This CSR must be programmed in Step C of the PHY Initialization sequence RESET:0x0"
          
group.long  0xac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PROCODTTIMECTL_P1, Controls timing of ProcOdt for DQ and DQS termination during reads. The enabling and disabling of ProcOdt can be shifted with a granularity of 1UI.  If WDQSEXTENSION is enabled, this register should be set to 0x03. Otherwise, use the recommended settings based on MEMCLK frequency and TwoTckRxDqsPre. This will ensure that ProcOdt is enabled before the DQS preamble begins and is not disabled until after the DQS postamble ends.  Recommended configuration if Register TwoTckRxDqsPre==1:  - 0000MHz < memclk-freq <= 0933 ; Register POdtStartDelay= 2 ; Register POdtTailWidth=2  - 0933MHz < memclk-freq <= 1200 ; Register POdtStartDelay= 0 ; Register POdtTailWidth=2  - 1200MHz < memclk-freq <= NA ; Register POdtStartDelay= 0 ; Register POdtTailWidth=3  Recommended configuration if TwoTckRxDqsPre==0:  - 0000MHz < memclk-freq <= 933 ; Register POdtStartDelay= 2 ; Register POdtTailWidth=2  - 0933MHz < memclk-freq <= 1200 ; Register POdtStartDelay= 1 ; Register POdtTailWidth=2  - 1200MHz < memclk-freq <= NA ; Register POdtStartDelay= 1 ; Register POdtTailWidth=3 See related CSR TxOdtDrvStren. RESET:0x1f"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PROCODTTIMECTL_P1_PODTTAILWIDTH ,controls the length of the tail of ProcOdt, units of UI - POdtTailWidth controls the time from closing the window to receive DQS to ProcODT deassertion, and can be set with values ranging from 0 to 3. - The aforementioned timing is defined as (3 + POdtTailWidth + POdtTailWidthExt - csrTwiTckDqsPre) UIs. - It is recommended to use this csr as the main timing configuration unit, with default value of 3. Note that this might not be the optimal value, since it is technology dependent. Refer to the PHY Databook for optimal settings. RESET:0x3"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PROCODTTIMECTL_P1_PODTSTARTDELAY ,controls the start of ProcOdt, units of UI  - 3 delay start 2 UI, maximum delay of start of ProcOdt  - 2 delay start 1 UI,  - 1 delay start 0 UI, default  - 0 early by 1 UI, The time from ProcODT assertion to opening the window to receive DQS is than (10 - POdtStartDelay) UI. It may be up to 4 pclk smaller if small 	  coarse delays are used (used only at the lowest clock frequencies) RESET:0x3"
          
         hexmask.long 0x00 4.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PROCODTTIMECTL_P1_PODTTAILWIDTHEXT ,controls the length of the tail of ProcOdt, units of UI - POdtTailWidthExt controls the time from closing the window to receive DQS to ProcODT deassertion, and can be set with values ranging from 0 to 3. - The aforementioned timing is defines as (3 + POdtTailWidth + POdtTailWidthExt - csrTwiTckDqsPre) UIs. - It is recommended to use this csr as an extension to POdtTailWidth, and has a default value of 1. Note that this might not be the optimal value, since it is technology dependent. Refer to the PHY Databook for optimal settings. RESET:0x1"
          
group.long  0xf8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DLLGAINCTL_P1, Controls for the DllGain sequencing for locking and maintaining lock of the LCDL delay cells. - The DllGain sequencer will start locking with the DllGainIV. - As the end of locking approaches, the DllGain will be incremented in stages until, at the end of locking, the DllGain is the terminal values DllGainTV. - 2^(5-DllGain) is fractional change in the DAC code MstPhase1UI[8:0] of Dll per pclk. - Firmware uses values for DllGainIV, DllGainTV, and LcdlSeed0 that are optimized for minimum locking time. These controls are not to be configured by the user. RESET:0xa1"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DLLGAINCTL_P1_DLLGAINIV ,Initial value of DllGain. RESET:0x1"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DLLGAINCTL_P1_DLLGAINTV ,Terminal value of DllGain, ie the value in effect when locking is done and the value used for maintaining lock, ie tracking pclk variation. DllGainTV must be greater than or equal to DllGainIV. The maximum value is 10. RESET:0xa"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DLLGAINCTL_P1_DLLSEEDSEL ,Reserved, must be configured to be 0. RESET:0x0"
          
group.long  0xfa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DLLLOCKPARAM_P1, Reserved for PHY training firmware use. RESET:0x17c1"
         hexmask.long 0x00 0.--12. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DLLLOCKPARAM_P1_RFU_DLLLOCKPARAM_P1 ,None RESET:0x17c1"
          
group.long  0x160++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DFIRDDATACSDESTMAP_P1, This CSR must be default values in LPDDR3 and LPDDR4 modes. Maps dfi_rddata_cs_n (read chip-select asserted low) to destination dimm timing group. RESET:0xe4"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DFIRDDATACSDESTMAP_P1_DFIRDDESTM0 ,Maps dfi_rddata_cs_n_p0[0] to dest DfiRdDestm0 timing.  For example, if 0 dfi_rddata_cs_n_p0[0] will use Register Rx[En,Clk]DlyTg0 timing. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DFIRDDATACSDESTMAP_P1_DFIRDDESTM1 ,Maps dfi_rddata_cs_n_p0[1] to dest DfiRdDestm1 timing.  For example, if 1 dfi_rddata_cs_n[_p01] will use Register Rx[En,Clk]DlyTg1 timing. RESET:0x1"
          
         hexmask.long 0x00 4.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DFIRDDATACSDESTMAP_P1_DFIRDDESTM2 ,Maps dfi_rddata_cs_n_p0[2] to dest DfiRdDestm2 timing.  For example, if 2 dfi_rddata_cs_n_p0[2] will use Register Rx[En,Clk]DlyTg2 timing. RESET:0x2"
          
         hexmask.long 0x00 6.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DFIRDDATACSDESTMAP_P1_DFIRDDESTM3 ,Maps dfi_rddata_cs_n_p0[3] to dest DfiRdDestm3 timing.  For example, if 3 dfi_rddata_cs_n_p0[3] will use Register Rx[En,Clk]DlyTg3 timing. RESET:0x3"
          
group.long  0x164++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_VREFINGLOBAL_P1, This Register controls the PHY global VREF generator, and the PHY analog pad BP_VREF. The mission mode function of the PHY VREF generator is to generate VrefDQ for the PHY RX function. This register is written and configured by the PHY training firmware for mission mode function. RESET:0x200"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_VREFINGLOBAL_P1_GLOBALVREFINSEL ,GlobalVrefInSel[1:0] controls the mode of the PHY VREF DAC and the BP_VREF pin  - 2'b00 - PHY Vref DAC Range0 -- BP_VREF = Hi-Z  - 2'b01 - Reserved Encoding  - 2'b10 - PHY Vref DAC Range0 -- BP_VREF connected to PLL Analog Bus  - 2'b11 - PHY Vref DAC Range0 -- BP_VREF connected to PHY Vref DAC GlobalVrefInSel[2] controls the DAC range for internal Vref generation RESET:0x0"
          
         hexmask.long 0x00 3.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_VREFINGLOBAL_P1_GLOBALVREFINDAC ,DAC code for internal Vref generation. The DAC has two ranges; the range is set by GlobalVrefInSel[2]  - RANGE0 : [GlobalVrefInSel[2] = 0]  -- DAC Output Voltage = GlobalVrefInDAC == 6'h00 ? Hi-Z : 0.345*VDDQ + (0.005*GlobalVrefInDAC)*VDDQ  - RANGE1 : [GlobalVrefInSel[2] = 1]  -- DAC Output Voltage = GlobalVrefInDAC == 6'h00 ? Hi-Z : (0.005*(GlobalVrefInDAC-1))*VDDQ RESET:0x40"
          
         hexmask.long 0x00 10.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_VREFINGLOBAL_P1_GLOBALVREFINTRIM ,RSVD RESET:0x0"
          
         bitfld.long 0x00 14. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_VREFINGLOBAL_P1_GLOBALVREFINMODE ,RSVD RESET:0x0"
          
group.long  0x168++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DFIWRDATACSDESTMAP_P1, This CSR must be default values in LPDDR3 and LPDDR4 modes Maps dfi_wrdata_cs_n (write chip-select asserted low) to destination dimm timing group. The full dfi interface has 72 values of dfi_wrdata_cs_n, with 8 per byte. Byte db (0..8) uses values dfi_wrdata_cs_n[(db*8 + 7):(db*8 + 0)] and this register, which is per byte, to determine the timing-control registers to use for the asserted chip-select. For simplicity, the subfield description does not include the byte offset for dfi_wrdata_cs_n.  Note: The example values below are the default/reset values. If this register is written to all zeroes, then all writes will use Register Tx[Dq,Dqs]Dlyd0 timing. RESET:0xe4"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DFIWRDATACSDESTMAP_P1_DFIWRDESTM0 ,Maps dfi_wrdata_cs_n_p0[0] to dest DfiWrDestm0 timing  For example, if 0 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg0 timing. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DFIWRDATACSDESTMAP_P1_DFIWRDESTM1 ,Maps dfi_wrdata_cs_n_p0[1] to dest DfiWrDestm1 timing  For example, if 1 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg1 timing. RESET:0x1"
          
         hexmask.long 0x00 4.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DFIWRDATACSDESTMAP_P1_DFIWRDESTM2 ,Maps dfi_wrdata_cs_n_p0[2] to dest DfiWrDestm2 timing  For example, if 2 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg2 timing. RESET:0x2"
          
         hexmask.long 0x00 6.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DFIWRDATACSDESTMAP_P1_DFIWRDESTM3 ,Maps dfi_wrdata_cs_n_p0[3] to dest DfiWrDestm3 timing (use Register Tx[Dq,Dqs]DlyTg3)  For example, if 3 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg3 timing. RESET:0x3"
          
group.long  0x18a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PLLCTRL2_P1, This csr is to be programmed by bios or other means to set PLL charge-pump settings in various PStates. See Technology specific PHY Databook for control setting programming. RESET:0x19"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PLLCTRL2_P1_PLLFREQSEL ,Adjusts the loop parameters to compensate for different VCO bias points, and input/output clock division ratios. RESET:0x19"
          
group.long  0x18e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PLLCTRL1_P1, This csr is to be programmed by bios or other means to set PLL charge-pump settings in various PStates. See Technology specific PHY Databook for control setting programming. RESET:0x20"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PLLCTRL1_P1_PLLCPINTCTRL ,connects directly to cp_int_cntrl<4:0> in PLL. Charge pump integrating current control. RESET:0x0"
          
         hexmask.long 0x00 5.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PLLCTRL1_P1_PLLCPPROPCTRL ,connects directly to cp_prop_cntrl<3:0> of PLL. Charge pump proportional current control. RESET:0x1"
          
group.long  0x194++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PLLTESTMODE_P1, Additional controls for PLL CP/VCO modes of operation RESET:0x124"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PLLTESTMODE_P1_PLLTESTMODE_P1 ,It is required to use default values for this CSR unless directed otherwise by Synopsys. Directly connected to testmode[15:0] pin of PLL RESET:0x124"
          
group.long  0x198++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PLLCTRL4_P1, This csr is to be programmed by bios or other means to set PLL charge-pump settings in various PStates. Refer to Technology specific PHY Databook for control setting programming. RESET:0x17f"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PLLCTRL4_P1_PLLCPINTGSCTRL ,connects directly to cp_int_gs_cntrl<4:0> in PLL. Charge pump integrating current control for fast relock and gearshift. RESET:0x1f"
          
         hexmask.long 0x00 5.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_PLLCTRL4_P1_PLLCPPROPGSCTRL ,connects directly to cp_prop_gs_cntrl<3:0> of PLL. Charge pump proportional current control for fast relock and gearshift. RESET:0xb"
          
group.long  0x1f4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DFIFREQRATIO_P1, DFI Frequency Ratio RESET:0x1"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P1_DFIFREQRATIO_P1_DFIFREQRATIO_P1 ,Specifies the ratio DfiCtlClk:MemClk.  - 00 = 1:1 mode  - 01 = 1:2 mode  - 1x = 1:4 mode When DWC_DDRPHY_FIXED_DFICTLCLK_RATIO is defined, this register is ignored and 1:2 mode is selected. RESET:0x1"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_ACSM0_P1"
base e:0x42280000
width 80.
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X0_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X0_P1_ACSMPLAYBACK0X0_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X0_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X0_P1_ACSMPLAYBACK1X0_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x104++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X1_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X1_P1_ACSMPLAYBACK0X1_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x106++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X1_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X1_P1_ACSMPLAYBACK1X1_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x108++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X2_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X2_P1_ACSMPLAYBACK0X2_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x10a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X2_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X2_P1_ACSMPLAYBACK1X2_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x10c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X3_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X3_P1_ACSMPLAYBACK0X3_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x10e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X3_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X3_P1_ACSMPLAYBACK1X3_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x110++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X4_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X4_P1_ACSMPLAYBACK0X4_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x112++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X4_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X4_P1_ACSMPLAYBACK1X4_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x114++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X5_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X5_P1_ACSMPLAYBACK0X5_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x116++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X5_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X5_P1_ACSMPLAYBACK1X5_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x118++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X6_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X6_P1_ACSMPLAYBACK0X6_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x11a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X6_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X6_P1_ACSMPLAYBACK1X6_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x11c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X7_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK0X7_P1_ACSMPLAYBACK0X7_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x11e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X7_P1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P1_ACSMPLAYBACK1X7_P1_ACSMPLAYBACK1X7_P1 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_INITENG0_P1"
base e:0x42320000
width 80.
group.long  0x402++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR1_P1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR1_P1_SEQ0BGPR1_P1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x404++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR2_P1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR2_P1_SEQ0BGPR2_P1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x406++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR3_P1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR3_P1_SEQ0BGPR3_P1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x408++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR4_P1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR4_P1_SEQ0BGPR4_P1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x40a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR5_P1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR5_P1_SEQ0BGPR5_P1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x40c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR6_P1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR6_P1_SEQ0BGPR6_P1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x40e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR7_P1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR7_P1_SEQ0BGPR7_P1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x410++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR8_P1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P1_SEQ0BGPR8_P1_SEQ0BGPR8_P1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_ANIB0_P2"
base e:0x42400000
width 80.
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P2_ATXDLY_P2, Address/Command Delay, per pstate. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P2_ATXDLY_P2_ATXDLY_P2 ,Trained for LPDDR3/4 to generate timed address and command signals to the DRAMs, per ACX4. For DDR3/DDR4, it is recommended that address and command ACX4 have it ATxDly=0x00 The four signals generated by an ACX4 will have common timing.  - ATxDly[6] is the coarse delay, ie one unit of delay is 1 UI.  - ATxDly[5] is reserved.  - ATxDly[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32. The target ACX4 used for memory clock generation, must have its ATxDly configured to 0x00. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_ANIB1_P2"
base e:0x42402000
width 80.
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P2_ATXDLY_P2, Address/Command Delay, per pstate. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P2_ATXDLY_P2_ATXDLY_P2 ,Trained for LPDDR3/4 to generate timed address and command signals to the DRAMs, per ACX4. For DDR3/DDR4, it is recommended that address and command ACX4 have it ATxDly=0x00 The four signals generated by an ACX4 will have common timing.  - ATxDly[6] is the coarse delay, ie one unit of delay is 1 UI.  - ATxDly[5] is reserved.  - ATxDly[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32. The target ACX4 used for memory clock generation, must have its ATxDly configured to 0x00. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_ANIB2_P2"
base e:0x42404000
width 80.
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P2_ATXDLY_P2, Address/Command Delay, per pstate. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P2_ATXDLY_P2_ATXDLY_P2 ,Trained for LPDDR3/4 to generate timed address and command signals to the DRAMs, per ACX4. For DDR3/DDR4, it is recommended that address and command ACX4 have it ATxDly=0x00 The four signals generated by an ACX4 will have common timing.  - ATxDly[6] is the coarse delay, ie one unit of delay is 1 UI.  - ATxDly[5] is reserved.  - ATxDly[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32. The target ACX4 used for memory clock generation, must have its ATxDly configured to 0x00. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_DBYTE0_P2"
base e:0x42420000
width 80.
group.long  0x6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_USEDQSENREPLICA_P2, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_USEDQSENREPLICA_P2_USEDQSENREPLICA_P2 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DFIMRL_P2, DFI MaxReadLatency RESET:0x6"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DFIMRL_P2_DFIMRL_P2 ,This Max Read Latency CSR is to be trained to ensure the rx-data fifo is not read until after all dbytes have their read data valid. This is the value, in units of two mem clocks, between dfi_rddata_en and dfi_rddata_valid A unit change in the LSB is a change in MRL of two mem clocks. RESET:0x6"
          
group.long  0x82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL0_B0_P2, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL0_B0_P2_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL0_B0_P2_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DQDQSRCVCNTRL_B0_P2, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DQDQSRCVCNTRL_B0_P2_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DQDQSRCVCNTRL_B0_P2_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DQDQSRCVCNTRL_B0_P2_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DQDQSRCVCNTRL_B0_P2_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DQDQSRCVCNTRL_B0_P2_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x90++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXEQUALIZATIONMODE_P2, Tx DQ driver equalization is a technique for improving the write-data eye at the DRAMs. The driver can drive with full strength (configured with DrvStrenFSHiDqP and DrvStrenFSLoDqN0 or with weak strength (configured with DrvStrenEQHiDqP and DrvStrenEQLoDqN) depending on the dq value sequence.  - TxEqMode = 00 Off; drive with full strength only  - TxEqMode = 01 Mode0 drive with full strength.or weak strength depending on  present logical value and the previous logical value.  - TxEqMode = 10 Mode1 drive with full strength.or weak strength depending on  present logical value and the next logical value. Mode1 is a lower power mode.  - TxEqMode = 11 reserved RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXEQUALIZATIONMODE_P2_TXEQMODE ,Tx dq driver equalization mode controls. FFE, de-emphasis DDR43 PHY ONLY RESET:0x0"
          
group.long  0x92++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL1_B0_P2, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL1_B0_P2_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL1_B0_P2_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x96++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL2_B0_P2, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL2_B0_P2_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL2_B0_P2_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x98++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DQDQSRCVCNTRL2_P2, Control for an aggressive power-saving feature to powerdown dq and dqs receiver cells dynamically. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DQDQSRCVCNTRL2_P2_ENRXAGRESSIVEPDR ,reserved RESET:0x0"
          
group.long  0x9a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXODTDRVSTREN_B0_P2, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXODTDRVSTREN_B0_P2_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXODTDRVSTREN_B0_P2_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
group.long  0xbe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXSLEWRATE_B0_P2, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXSLEWRATE_B0_P2_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXSLEWRATE_B0_P2_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXSLEWRATE_B0_P2_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG0_U0_P2, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG0_U0_P2_RXENDLYTG0_U0_P2 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG1_U0_P2, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG1_U0_P2_RXENDLYTG1_U0_P2 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x104++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG2_U0_P2, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG2_U0_P2_RXENDLYTG2_U0_P2 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x106++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG3_U0_P2, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG3_U0_P2_RXENDLYTG3_U0_P2 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x118++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG0_U0_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG0_U0_P2_RXCLKDLYTG0_U0_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x11a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG1_U0_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG1_U0_P2_RXCLKDLYTG1_U0_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x11c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG2_U0_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG2_U0_P2_RXCLKDLYTG2_U0_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x11e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG3_U0_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG3_U0_P2_RXCLKDLYTG3_U0_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x120++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG0_U0_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG0_U0_P2_RXCLKCDLYTG0_U0_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x122++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG1_U0_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG1_U0_P2_RXCLKCDLYTG1_U0_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x124++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG2_U0_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG2_U0_P2_RXCLKCDLYTG2_U0_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x126++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG3_U0_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG3_U0_P2_RXCLKCDLYTG3_U0_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x15c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_PPTDQSCNTINVTRNTG0_P2, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_PPTDQSCNTINVTRNTG0_P2_PPTDQSCNTINVTRNTG0_P2 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x15e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_PPTDQSCNTINVTRNTG1_P2, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_PPTDQSCNTINVTRNTG1_P2_PPTDQSCNTINVTRNTG1_P2 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R0_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R0_P2_TXDQDLYTG0_R0_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R0_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R0_P2_TXDQDLYTG1_R0_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R0_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R0_P2_TXDQDLYTG2_R0_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R0_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R0_P2_TXDQDLYTG3_R0_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG0_U0_P2, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG0_U0_P2_TXDQSDLYTG0_U0_P2 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x1a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG1_U0_P2, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG1_U0_P2_TXDQSDLYTG1_U0_P2 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x1a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG2_U0_P2, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG2_U0_P2_TXDQSDLYTG2_U0_P2 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x1a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG3_U0_P2, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG3_U0_P2_TXDQSDLYTG3_U0_P2 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x282++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL0_B1_P2, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL0_B1_P2_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL0_B1_P2_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x286++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DQDQSRCVCNTRL_B1_P2, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DQDQSRCVCNTRL_B1_P2_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DQDQSRCVCNTRL_B1_P2_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DQDQSRCVCNTRL_B1_P2_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DQDQSRCVCNTRL_B1_P2_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_DQDQSRCVCNTRL_B1_P2_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x292++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL1_B1_P2, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL1_B1_P2_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL1_B1_P2_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x296++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL2_B1_P2, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL2_B1_P2_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXIMPEDANCECTRL2_B1_P2_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x29a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXODTDRVSTREN_B1_P2, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXODTDRVSTREN_B1_P2_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXODTDRVSTREN_B1_P2_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
group.long  0x2be++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXSLEWRATE_B1_P2, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXSLEWRATE_B1_P2_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXSLEWRATE_B1_P2_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXSLEWRATE_B1_P2_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0x300++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG0_U1_P2, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG0_U1_P2_RXENDLYTG0_U1_P2 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x302++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG1_U1_P2, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG1_U1_P2_RXENDLYTG1_U1_P2 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x304++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG2_U1_P2, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG2_U1_P2_RXENDLYTG2_U1_P2 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x306++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG3_U1_P2, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXENDLYTG3_U1_P2_RXENDLYTG3_U1_P2 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x318++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG0_U1_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG0_U1_P2_RXCLKDLYTG0_U1_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x31a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG1_U1_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG1_U1_P2_RXCLKDLYTG1_U1_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x31c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG2_U1_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG2_U1_P2_RXCLKDLYTG2_U1_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x31e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG3_U1_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKDLYTG3_U1_P2_RXCLKDLYTG3_U1_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x320++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG0_U1_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG0_U1_P2_RXCLKCDLYTG0_U1_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x322++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG1_U1_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG1_U1_P2_RXCLKCDLYTG1_U1_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x324++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG2_U1_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG2_U1_P2_RXCLKCDLYTG2_U1_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x326++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG3_U1_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_RXCLKCDLYTG3_U1_P2_RXCLKCDLYTG3_U1_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x380++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R1_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R1_P2_TXDQDLYTG0_R1_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x382++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R1_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R1_P2_TXDQDLYTG1_R1_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x384++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R1_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R1_P2_TXDQDLYTG2_R1_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x386++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R1_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R1_P2_TXDQDLYTG3_R1_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x3a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG0_U1_P2, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG0_U1_P2_TXDQSDLYTG0_U1_P2 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x3a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG1_U1_P2, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG1_U1_P2_TXDQSDLYTG1_U1_P2 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x3a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG2_U1_P2, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG2_U1_P2_TXDQSDLYTG2_U1_P2 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x3a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG3_U1_P2, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQSDLYTG3_U1_P2_TXDQSDLYTG3_U1_P2 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x580++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R2_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R2_P2_TXDQDLYTG0_R2_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x582++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R2_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R2_P2_TXDQDLYTG1_R2_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x584++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R2_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R2_P2_TXDQDLYTG2_R2_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x586++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R2_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R2_P2_TXDQDLYTG3_R2_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x780++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R3_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R3_P2_TXDQDLYTG0_R3_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x782++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R3_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R3_P2_TXDQDLYTG1_R3_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x784++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R3_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R3_P2_TXDQDLYTG2_R3_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x786++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R3_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R3_P2_TXDQDLYTG3_R3_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x980++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R4_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R4_P2_TXDQDLYTG0_R4_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x982++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R4_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R4_P2_TXDQDLYTG1_R4_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x984++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R4_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R4_P2_TXDQDLYTG2_R4_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x986++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R4_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R4_P2_TXDQDLYTG3_R4_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xb80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R5_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R5_P2_TXDQDLYTG0_R5_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xb82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R5_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R5_P2_TXDQDLYTG1_R5_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xb84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R5_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R5_P2_TXDQDLYTG2_R5_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xb86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R5_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R5_P2_TXDQDLYTG3_R5_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xd80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R6_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R6_P2_TXDQDLYTG0_R6_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xd82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R6_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R6_P2_TXDQDLYTG1_R6_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xd84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R6_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R6_P2_TXDQDLYTG2_R6_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xd86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R6_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R6_P2_TXDQDLYTG3_R6_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xf80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R7_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R7_P2_TXDQDLYTG0_R7_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xf82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R7_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R7_P2_TXDQDLYTG1_R7_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xf84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R7_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R7_P2_TXDQDLYTG2_R7_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xf86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R7_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R7_P2_TXDQDLYTG3_R7_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R8_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG0_R8_P2_TXDQDLYTG0_R8_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x1182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R8_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG1_R8_P2_TXDQDLYTG1_R8_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x1184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R8_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG2_R8_P2_TXDQDLYTG2_R8_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x1186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R8_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P2_TXDQDLYTG3_R8_P2_TXDQDLYTG3_R8_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_DBYTE1_P2"
base e:0x42422000
width 80.
group.long  0x6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_USEDQSENREPLICA_P2, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_USEDQSENREPLICA_P2_USEDQSENREPLICA_P2 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DFIMRL_P2, DFI MaxReadLatency RESET:0x6"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DFIMRL_P2_DFIMRL_P2 ,This Max Read Latency CSR is to be trained to ensure the rx-data fifo is not read until after all dbytes have their read data valid. This is the value, in units of two mem clocks, between dfi_rddata_en and dfi_rddata_valid A unit change in the LSB is a change in MRL of two mem clocks. RESET:0x6"
          
group.long  0x82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL0_B0_P2, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL0_B0_P2_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL0_B0_P2_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DQDQSRCVCNTRL_B0_P2, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DQDQSRCVCNTRL_B0_P2_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DQDQSRCVCNTRL_B0_P2_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DQDQSRCVCNTRL_B0_P2_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DQDQSRCVCNTRL_B0_P2_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DQDQSRCVCNTRL_B0_P2_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x90++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXEQUALIZATIONMODE_P2, Tx DQ driver equalization is a technique for improving the write-data eye at the DRAMs. The driver can drive with full strength (configured with DrvStrenFSHiDqP and DrvStrenFSLoDqN0 or with weak strength (configured with DrvStrenEQHiDqP and DrvStrenEQLoDqN) depending on the dq value sequence.  - TxEqMode = 00 Off; drive with full strength only  - TxEqMode = 01 Mode0 drive with full strength.or weak strength depending on  present logical value and the previous logical value.  - TxEqMode = 10 Mode1 drive with full strength.or weak strength depending on  present logical value and the next logical value. Mode1 is a lower power mode.  - TxEqMode = 11 reserved RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXEQUALIZATIONMODE_P2_TXEQMODE ,Tx dq driver equalization mode controls. FFE, de-emphasis DDR43 PHY ONLY RESET:0x0"
          
group.long  0x92++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL1_B0_P2, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL1_B0_P2_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL1_B0_P2_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x96++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL2_B0_P2, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL2_B0_P2_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL2_B0_P2_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x98++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DQDQSRCVCNTRL2_P2, Control for an aggressive power-saving feature to powerdown dq and dqs receiver cells dynamically. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DQDQSRCVCNTRL2_P2_ENRXAGRESSIVEPDR ,reserved RESET:0x0"
          
group.long  0x9a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXODTDRVSTREN_B0_P2, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXODTDRVSTREN_B0_P2_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXODTDRVSTREN_B0_P2_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
group.long  0xbe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXSLEWRATE_B0_P2, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXSLEWRATE_B0_P2_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXSLEWRATE_B0_P2_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXSLEWRATE_B0_P2_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG0_U0_P2, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG0_U0_P2_RXENDLYTG0_U0_P2 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG1_U0_P2, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG1_U0_P2_RXENDLYTG1_U0_P2 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x104++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG2_U0_P2, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG2_U0_P2_RXENDLYTG2_U0_P2 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x106++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG3_U0_P2, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG3_U0_P2_RXENDLYTG3_U0_P2 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x118++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG0_U0_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG0_U0_P2_RXCLKDLYTG0_U0_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x11a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG1_U0_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG1_U0_P2_RXCLKDLYTG1_U0_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x11c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG2_U0_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG2_U0_P2_RXCLKDLYTG2_U0_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x11e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG3_U0_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG3_U0_P2_RXCLKDLYTG3_U0_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x120++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG0_U0_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG0_U0_P2_RXCLKCDLYTG0_U0_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x122++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG1_U0_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG1_U0_P2_RXCLKCDLYTG1_U0_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x124++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG2_U0_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG2_U0_P2_RXCLKCDLYTG2_U0_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x126++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG3_U0_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG3_U0_P2_RXCLKCDLYTG3_U0_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x15c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_PPTDQSCNTINVTRNTG0_P2, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_PPTDQSCNTINVTRNTG0_P2_PPTDQSCNTINVTRNTG0_P2 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x15e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_PPTDQSCNTINVTRNTG1_P2, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_PPTDQSCNTINVTRNTG1_P2_PPTDQSCNTINVTRNTG1_P2 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R0_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R0_P2_TXDQDLYTG0_R0_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R0_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R0_P2_TXDQDLYTG1_R0_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R0_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R0_P2_TXDQDLYTG2_R0_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R0_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R0_P2_TXDQDLYTG3_R0_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG0_U0_P2, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG0_U0_P2_TXDQSDLYTG0_U0_P2 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x1a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG1_U0_P2, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG1_U0_P2_TXDQSDLYTG1_U0_P2 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x1a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG2_U0_P2, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG2_U0_P2_TXDQSDLYTG2_U0_P2 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x1a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG3_U0_P2, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG3_U0_P2_TXDQSDLYTG3_U0_P2 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x282++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL0_B1_P2, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL0_B1_P2_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL0_B1_P2_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x286++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DQDQSRCVCNTRL_B1_P2, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DQDQSRCVCNTRL_B1_P2_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DQDQSRCVCNTRL_B1_P2_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DQDQSRCVCNTRL_B1_P2_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DQDQSRCVCNTRL_B1_P2_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_DQDQSRCVCNTRL_B1_P2_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x292++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL1_B1_P2, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL1_B1_P2_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL1_B1_P2_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x296++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL2_B1_P2, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL2_B1_P2_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXIMPEDANCECTRL2_B1_P2_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x29a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXODTDRVSTREN_B1_P2, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXODTDRVSTREN_B1_P2_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXODTDRVSTREN_B1_P2_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
group.long  0x2be++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXSLEWRATE_B1_P2, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXSLEWRATE_B1_P2_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXSLEWRATE_B1_P2_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXSLEWRATE_B1_P2_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0x300++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG0_U1_P2, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG0_U1_P2_RXENDLYTG0_U1_P2 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x302++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG1_U1_P2, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG1_U1_P2_RXENDLYTG1_U1_P2 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x304++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG2_U1_P2, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG2_U1_P2_RXENDLYTG2_U1_P2 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x306++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG3_U1_P2, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXENDLYTG3_U1_P2_RXENDLYTG3_U1_P2 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x318++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG0_U1_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG0_U1_P2_RXCLKDLYTG0_U1_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x31a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG1_U1_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG1_U1_P2_RXCLKDLYTG1_U1_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x31c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG2_U1_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG2_U1_P2_RXCLKDLYTG2_U1_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x31e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG3_U1_P2, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKDLYTG3_U1_P2_RXCLKDLYTG3_U1_P2 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x320++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG0_U1_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG0_U1_P2_RXCLKCDLYTG0_U1_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x322++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG1_U1_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG1_U1_P2_RXCLKCDLYTG1_U1_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x324++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG2_U1_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG2_U1_P2_RXCLKCDLYTG2_U1_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x326++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG3_U1_P2, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_RXCLKCDLYTG3_U1_P2_RXCLKCDLYTG3_U1_P2 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x380++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R1_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R1_P2_TXDQDLYTG0_R1_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x382++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R1_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R1_P2_TXDQDLYTG1_R1_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x384++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R1_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R1_P2_TXDQDLYTG2_R1_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x386++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R1_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R1_P2_TXDQDLYTG3_R1_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x3a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG0_U1_P2, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG0_U1_P2_TXDQSDLYTG0_U1_P2 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x3a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG1_U1_P2, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG1_U1_P2_TXDQSDLYTG1_U1_P2 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x3a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG2_U1_P2, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG2_U1_P2_TXDQSDLYTG2_U1_P2 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x3a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG3_U1_P2, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQSDLYTG3_U1_P2_TXDQSDLYTG3_U1_P2 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x580++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R2_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R2_P2_TXDQDLYTG0_R2_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x582++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R2_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R2_P2_TXDQDLYTG1_R2_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x584++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R2_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R2_P2_TXDQDLYTG2_R2_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x586++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R2_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R2_P2_TXDQDLYTG3_R2_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x780++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R3_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R3_P2_TXDQDLYTG0_R3_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x782++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R3_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R3_P2_TXDQDLYTG1_R3_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x784++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R3_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R3_P2_TXDQDLYTG2_R3_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x786++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R3_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R3_P2_TXDQDLYTG3_R3_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x980++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R4_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R4_P2_TXDQDLYTG0_R4_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x982++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R4_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R4_P2_TXDQDLYTG1_R4_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x984++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R4_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R4_P2_TXDQDLYTG2_R4_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x986++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R4_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R4_P2_TXDQDLYTG3_R4_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xb80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R5_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R5_P2_TXDQDLYTG0_R5_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xb82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R5_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R5_P2_TXDQDLYTG1_R5_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xb84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R5_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R5_P2_TXDQDLYTG2_R5_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xb86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R5_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R5_P2_TXDQDLYTG3_R5_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xd80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R6_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R6_P2_TXDQDLYTG0_R6_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xd82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R6_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R6_P2_TXDQDLYTG1_R6_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xd84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R6_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R6_P2_TXDQDLYTG2_R6_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xd86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R6_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R6_P2_TXDQDLYTG3_R6_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xf80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R7_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R7_P2_TXDQDLYTG0_R7_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xf82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R7_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R7_P2_TXDQDLYTG1_R7_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xf84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R7_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R7_P2_TXDQDLYTG2_R7_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xf86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R7_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R7_P2_TXDQDLYTG3_R7_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R8_P2, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG0_R8_P2_TXDQDLYTG0_R8_P2 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x1182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R8_P2, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG1_R8_P2_TXDQDLYTG1_R8_P2 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x1184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R8_P2, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG2_R8_P2_TXDQDLYTG2_R8_P2 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x1186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R8_P2, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P2_TXDQDLYTG3_R8_P2_TXDQDLYTG3_R8_P2 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_MASTER0_P2"
base e:0x42440000
width 80.
group.long  0x10++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_CALUCLKINFO_P2, Informs the impedance calibration engine about frequency of DfiClk RESET:0x320"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_CALUCLKINFO_P2_CALUCLKTICKSPER1US ,Must be programmed to the number of DfiClks in 1us (rounded up), with minimum value of 24. - if (DfiClk < 24MHz) CalUclkInfo = 24 - else CalUclkInfo = (number of DfiClks in 1us) RESET:0x320"
          
group.long  0x16++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_SEQ0BDLY0_P2, PHY Initialization Engine (PIE) Delay Register 0 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_SEQ0BDLY0_P2_SEQ0BDLY0_P2 ,PHY Initialization Engine (PIE) Delay Register 0. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_SEQ0BDLY1_P2, PHY Initialization Engine (PIE) Delay Register 1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_SEQ0BDLY1_P2_SEQ0BDLY1_P2 ,PHY Initialization Engine (PIE) Delay Register 1. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x1a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_SEQ0BDLY2_P2, PHY Initialization Engine (PIE) Delay Register 2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_SEQ0BDLY2_P2_SEQ0BDLY2_P2 ,PHY Initialization Engine (PIE) Delay Register 2. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_SEQ0BDLY3_P2, PHY Initialization Engine (PIE) Delay Register 3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_SEQ0BDLY3_P2_SEQ0BDLY3_P2 ,PHY Initialization Engine (PIE) Delay Register 3. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PPTTRAINSETUP_P2, For LPDDR3/4 some tracking is required periodically using the DFI PHY MASTER interface. This register control the interval. Setting the register to 0 completely disables the PHY Master Interface. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PPTTRAINSETUP_P2_PHYMSTRTRAININTERVAL ,Bits 3:0 of this register specifies the time between the end of one training and the start of the next. Note that, to account for the delay to receive the acknowledge from the MC, the dfi_phymstr_req signal is asserted in advance so that the effective update (after acknowledge from the MC) occurs inside the interval defined by PhyMstrTrainInterval.  - 4'b0000 Disable PHY Master Interface  - 4'b0001 PHY MASTER Request Interval = 524288 MEMCLKs  - 4'b0010 PHY MASTER Request Interval = 1048576 MEMCLKs  - 4'b0011 PHY MASTER Request Interval = 2097152 MEMCLKs  - 4'b0100 PHY MASTER Request Interval = 4194304 MEMCLKs  - 4'b0101 PHY MASTER Request Interval = 8388608 MEMCLKs  - 4'b0110 PHY MASTER Request Interval = 16777216 MEMCLKs  - 4'b0111 PHY MASTER Request Interval = 33554432 MEMCLKs  - 4'b1000 PHY MASTER Request Interval = 67108864 MEMCLKs  - 4'b1001 PHY MASTER Request Interval = 134217728 MEMCLKs  - 4'b1010 PHY MASTER Request Interval = 268435456 MEMCLKs  - 4'b1011 - 4'b1111 PHY MASTER Request Interval = undefined RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PPTTRAINSETUP_P2_PHYMSTRMAXREQTOACK ,The value in bits 6:4 of this register specify the max time from tdfi_phymstr_req asserted to tdfi_phymstr_ack asserted. If the request is not acknowledged by this time, dfi_error will be asserted.  - 3'b000 Disable PHY Master Interface  - 3'b001 set tPHYMSTR_resp. = 512 MEMCLKs  - 3'b010 set tPHYMSTR_resp. = 1024 MEMCLKs  - 3'b011 set tPHYMSTR_resp. = 2048 MEMCLKs  - 3'b100 set tPHYMSTR_resp. = 4096 MEMCLKs  - 3'b101 set tPHYMSTR_resp. = 8192 MEMCLKs  - 3'b110 set tPHYMSTR_resp. = 32768 MEMCLKs  - 3'b111 set tPHYMSTR_resp. = undefined  Note: The above are nominal values. The actual values are reduced by (2 + (DWC_DDRPHY_PIPE_DFI_MISC * MEMCLK/DfiCtlClk)) * 2  Note: This signal interacts with dfi_phyupd_req. See Section Collisions Between PHY Update and DFI LP of the PUB Databook. RESET:0x0"
          
group.long  0x22++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PPTTRAINSETUP2_P2, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x2"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PPTTRAINSETUP2_P2_RFU_PPTTRAINSETUP2_P2 ,None RESET:0x2"
          
group.long  0x32++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_TRISTATEMODECA_P2, This register is used to control the PHY Dynamic Address/Command Tristate Feature, and the stopped MEMCLK state. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_TRISTATEMODECA_P2_DISDYNADRTRI ,When DisDynAdrTri=1, Dynamic Tristating is disabled. Dynamic Tristating is on by default. Dynamic Tristating should be disabled (DisDynAdrTri=1) for these modes:  - DR3/2T if the controller cannot follow the 2T PHY tristate protocol.  - DDR4/2T/2N if the controller cannot follow the 2T PHY tristate protocol.  - LPDDR4 When DisDynAdrTri=0 (default),  - In DDR4 mode, The following SDRAM pins can be dynamically tristated: A,BA,BG,ACT_n  - In LPDDR3 mode, The following SDRAM pins can be dynamically tristated: CA[*]  - In 1T mode, the PHY will tristate the relevant pins when all ranks are DESelected  - In 2T mode (or geardown), the PHY will tristate the relevant pins when:  -- DDR3 -- All ranks DESelected (all CS_L==1) AND [RAS_n,CAS_n,WE_n,BA0] = [1,1,1,0]  -- DDR4 -- All ranks DESelected (all CS_L==1) AND [RAS_n,CAS_n,WE_n,BA0,ACT_n] = [1,1,1,0,1]  - When in this mode, the controller should avoid sending the above patterns with any rank selected. [e.g. NOPs sent by the controller should have BA0 set to a non-zero value] RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_TRISTATEMODECA_P2_DDR2TMODE ,Must be set to 1 for Dynamic Tristate to work when CA bus is 2T or Geardown mode. This CSR bit has no effect when DisDynAdrTri==1 RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_TRISTATEMODECA_P2_CKDISVAL ,The PHY provides 4 memory clocks, n=0..3.  - When the toggling of memory clock CK_t[n] is disabled with dfi_clk_disable[n]=1, the memory clock CK_t[n] is driven with Register CkDisVal[1].  - When the toggling of memory clock CK_c[n] is disabled with dfi_clk_disable[n]=1, the memory clock CK_c[n] is driven with ~(Register CkDisVal[0]) (ie inverted).  Note that the non-toggling differential memory clock [CK_t[n],CK_c[n]] may be driven with any combination, LL,LH,HL,HH; the default [CK_t[n],CK_c[n]]=LH. RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_HWTMRL_P2, HWT MaxReadLatency. RESET:0x6"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_HWTMRL_P2_HWTMRL_P2 ,This MASTER copy of MRL is used by the PHY training firmware only. RESET:0x6"
          
group.long  0x48++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DQSPREAMBLECONTROL_P2, For improved robustness in operating with DRAM timing drift, this register provides controls for the width of the write DQS preamble and postamble, and controls for the anticipated width of DQS preamble for reads. RESET:0x8"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DQSPREAMBLECONTROL_P2_TWOTCKRXDQSPRE ,Widens the RxDqsEn window to allow larger drift in the incoming read DQS to take advantage of the larger/wider preamble generated by the DRAMSs when the D4 DRAMS are configured with DDR4 MR4 A11 Read Preamble=1 for causing a 2nCK read preamble. For LPDDR4, set to 1 for static read preamble, set to 0 for toggling read preamble.  Note the nominal trained-to-center point will be earlier relative to the first strobing edge of DQS than when not in this mode. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DQSPREAMBLECONTROL_P2_TWOTCKTXDQSPRE ,For LPDDR4, all write operations are 2nCK such that this control must be set to 1. RESET:0x0"
          
         hexmask.long 0x00 2.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DQSPREAMBLECONTROL_P2_POSITIONDFEINIT ,For DDR4 phy only when receive DFE is enabled.  - PositionDfeInit[2] is reserved  - PositionDfeInit[1]=1 causes DfeInit to be asserted at the nominal time  - PositionDfeInit[0] is reserved PositionDfeInit=3'b010 is the nominal, recommended value for leading edge used by receiver, other values are reserved. RESET:0x2"
          
         bitfld.long 0x00 5. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DQSPREAMBLECONTROL_P2_LP4TGLTWOTCKTXDQSPRE ,Used in LPDDR4 mode to modify the early preamble when Register TwoTckTxDqsPre=1 - 0: level first-memclk preamble - 1: toggling first-memclk preamble RESET:0x0"
          
         bitfld.long 0x00 6. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DQSPREAMBLECONTROL_P2_LP4POSTAMBLEEXT ,In LPDDR4 mode must be set to extend the write postamble. - 0: half-memclk postamble, as in D4 - 1: one-and-one-half-memclk postamble; see LPDDR4 Spec MR3, OP[1] WR PST, vendor-specific function. RESET:0x0"
          
         bitfld.long 0x00 7. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DQSPREAMBLECONTROL_P2_LP4STTCPREBRIDGERXEN ,Used in LPDDR4 static-preamble mode to bridge the RxEn between two reads to the same timing group when the bubble is 1 memclk. LPDDR4 static-preamble mode is set in the DRAMs with MR1, OP[3]=0. RESET:0x0"
          
         bitfld.long 0x00 8. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DQSPREAMBLECONTROL_P2_WDQSEXTENSION ,When set, DQS_T and DQS_C will be driven differentially to 0 and 1, respectively, before and after a write burst, except during a memory read transaction. See DesignWare Cores LPDDR4 MultiPHY: WDQS Extension Application Note. Use of WDQSEXTENSION requires POdtTailWidth=3 and POdtStartDelay=00 RESET:0x0"
          
group.long  0x5a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DMIPINPRESENT_P2, This Register is used to instruct the PHY whether to enable the Read-DBI function on Lane8 of each DBYTE. Only the LPDDR4 and DDR4 Protocols support the Read-DBI feature. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DMIPINPRESENT_P2_RDDBIENABLED ,This bit must be set to 1'b1 if Read-DBI is enabled in a connected DDR4 or LPDDR4 device. If set, the following DRAM MR should also be set [DDR4.MR5.A12=1 or LPDDR4.MR3.OP[7]=1] RESET:0x0"
          
group.long  0x5c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_ARDPTRINITVAL_P2, Address/Command FIFO ReadPointer Initial Value RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_ARDPTRINITVAL_P2_ARDPTRINITVAL_P2 ,This is the initial Pointer Offset for the free-running FIFOs in the DBYTE and ACX4 hardips. The units of this register are in UI. The pointer separation should be chosen to compensate for all sources of skew and drift of the PHY DFICLK and PCLK networks. See 'ARdPtrInitVal Impacts From Construction Skews' of the PUB databook. This CSR must be programmed in Step C of the PHY Initialization sequence RESET:0x0"
          
group.long  0xac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PROCODTTIMECTL_P2, Controls timing of ProcOdt for DQ and DQS termination during reads. The enabling and disabling of ProcOdt can be shifted with a granularity of 1UI.  If WDQSEXTENSION is enabled, this register should be set to 0x03. Otherwise, use the recommended settings based on MEMCLK frequency and TwoTckRxDqsPre. This will ensure that ProcOdt is enabled before the DQS preamble begins and is not disabled until after the DQS postamble ends.  Recommended configuration if Register TwoTckRxDqsPre==1:  - 0000MHz < memclk-freq <= 0933 ; Register POdtStartDelay= 2 ; Register POdtTailWidth=2  - 0933MHz < memclk-freq <= 1200 ; Register POdtStartDelay= 0 ; Register POdtTailWidth=2  - 1200MHz < memclk-freq <= NA ; Register POdtStartDelay= 0 ; Register POdtTailWidth=3  Recommended configuration if TwoTckRxDqsPre==0:  - 0000MHz < memclk-freq <= 933 ; Register POdtStartDelay= 2 ; Register POdtTailWidth=2  - 0933MHz < memclk-freq <= 1200 ; Register POdtStartDelay= 1 ; Register POdtTailWidth=2  - 1200MHz < memclk-freq <= NA ; Register POdtStartDelay= 1 ; Register POdtTailWidth=3 See related CSR TxOdtDrvStren. RESET:0x1f"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PROCODTTIMECTL_P2_PODTTAILWIDTH ,controls the length of the tail of ProcOdt, units of UI - POdtTailWidth controls the time from closing the window to receive DQS to ProcODT deassertion, and can be set with values ranging from 0 to 3. - The aforementioned timing is defined as (3 + POdtTailWidth + POdtTailWidthExt - csrTwiTckDqsPre) UIs. - It is recommended to use this csr as the main timing configuration unit, with default value of 3. Note that this might not be the optimal value, since it is technology dependent. Refer to the PHY Databook for optimal settings. RESET:0x3"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PROCODTTIMECTL_P2_PODTSTARTDELAY ,controls the start of ProcOdt, units of UI  - 3 delay start 2 UI, maximum delay of start of ProcOdt  - 2 delay start 1 UI,  - 1 delay start 0 UI, default  - 0 early by 1 UI, The time from ProcODT assertion to opening the window to receive DQS is than (10 - POdtStartDelay) UI. It may be up to 4 pclk smaller if small 	  coarse delays are used (used only at the lowest clock frequencies) RESET:0x3"
          
         hexmask.long 0x00 4.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PROCODTTIMECTL_P2_PODTTAILWIDTHEXT ,controls the length of the tail of ProcOdt, units of UI - POdtTailWidthExt controls the time from closing the window to receive DQS to ProcODT deassertion, and can be set with values ranging from 0 to 3. - The aforementioned timing is defines as (3 + POdtTailWidth + POdtTailWidthExt - csrTwiTckDqsPre) UIs. - It is recommended to use this csr as an extension to POdtTailWidth, and has a default value of 1. Note that this might not be the optimal value, since it is technology dependent. Refer to the PHY Databook for optimal settings. RESET:0x1"
          
group.long  0xf8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DLLGAINCTL_P2, Controls for the DllGain sequencing for locking and maintaining lock of the LCDL delay cells. - The DllGain sequencer will start locking with the DllGainIV. - As the end of locking approaches, the DllGain will be incremented in stages until, at the end of locking, the DllGain is the terminal values DllGainTV. - 2^(5-DllGain) is fractional change in the DAC code MstPhase1UI[8:0] of Dll per pclk. - Firmware uses values for DllGainIV, DllGainTV, and LcdlSeed0 that are optimized for minimum locking time. These controls are not to be configured by the user. RESET:0xa1"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DLLGAINCTL_P2_DLLGAINIV ,Initial value of DllGain. RESET:0x1"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DLLGAINCTL_P2_DLLGAINTV ,Terminal value of DllGain, ie the value in effect when locking is done and the value used for maintaining lock, ie tracking pclk variation. DllGainTV must be greater than or equal to DllGainIV. The maximum value is 10. RESET:0xa"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DLLGAINCTL_P2_DLLSEEDSEL ,Reserved, must be configured to be 0. RESET:0x0"
          
group.long  0xfa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DLLLOCKPARAM_P2, Reserved for PHY training firmware use. RESET:0x17c1"
         hexmask.long 0x00 0.--12. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DLLLOCKPARAM_P2_RFU_DLLLOCKPARAM_P2 ,None RESET:0x17c1"
          
group.long  0x160++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DFIRDDATACSDESTMAP_P2, This CSR must be default values in LPDDR3 and LPDDR4 modes. Maps dfi_rddata_cs_n (read chip-select asserted low) to destination dimm timing group. RESET:0xe4"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DFIRDDATACSDESTMAP_P2_DFIRDDESTM0 ,Maps dfi_rddata_cs_n_p0[0] to dest DfiRdDestm0 timing.  For example, if 0 dfi_rddata_cs_n_p0[0] will use Register Rx[En,Clk]DlyTg0 timing. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DFIRDDATACSDESTMAP_P2_DFIRDDESTM1 ,Maps dfi_rddata_cs_n_p0[1] to dest DfiRdDestm1 timing.  For example, if 1 dfi_rddata_cs_n[_p01] will use Register Rx[En,Clk]DlyTg1 timing. RESET:0x1"
          
         hexmask.long 0x00 4.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DFIRDDATACSDESTMAP_P2_DFIRDDESTM2 ,Maps dfi_rddata_cs_n_p0[2] to dest DfiRdDestm2 timing.  For example, if 2 dfi_rddata_cs_n_p0[2] will use Register Rx[En,Clk]DlyTg2 timing. RESET:0x2"
          
         hexmask.long 0x00 6.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DFIRDDATACSDESTMAP_P2_DFIRDDESTM3 ,Maps dfi_rddata_cs_n_p0[3] to dest DfiRdDestm3 timing.  For example, if 3 dfi_rddata_cs_n_p0[3] will use Register Rx[En,Clk]DlyTg3 timing. RESET:0x3"
          
group.long  0x164++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_VREFINGLOBAL_P2, This Register controls the PHY global VREF generator, and the PHY analog pad BP_VREF. The mission mode function of the PHY VREF generator is to generate VrefDQ for the PHY RX function. This register is written and configured by the PHY training firmware for mission mode function. RESET:0x200"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_VREFINGLOBAL_P2_GLOBALVREFINSEL ,GlobalVrefInSel[1:0] controls the mode of the PHY VREF DAC and the BP_VREF pin  - 2'b00 - PHY Vref DAC Range0 -- BP_VREF = Hi-Z  - 2'b01 - Reserved Encoding  - 2'b10 - PHY Vref DAC Range0 -- BP_VREF connected to PLL Analog Bus  - 2'b11 - PHY Vref DAC Range0 -- BP_VREF connected to PHY Vref DAC GlobalVrefInSel[2] controls the DAC range for internal Vref generation RESET:0x0"
          
         hexmask.long 0x00 3.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_VREFINGLOBAL_P2_GLOBALVREFINDAC ,DAC code for internal Vref generation. The DAC has two ranges; the range is set by GlobalVrefInSel[2]  - RANGE0 : [GlobalVrefInSel[2] = 0]  -- DAC Output Voltage = GlobalVrefInDAC == 6'h00 ? Hi-Z : 0.345*VDDQ + (0.005*GlobalVrefInDAC)*VDDQ  - RANGE1 : [GlobalVrefInSel[2] = 1]  -- DAC Output Voltage = GlobalVrefInDAC == 6'h00 ? Hi-Z : (0.005*(GlobalVrefInDAC-1))*VDDQ RESET:0x40"
          
         hexmask.long 0x00 10.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_VREFINGLOBAL_P2_GLOBALVREFINTRIM ,RSVD RESET:0x0"
          
         bitfld.long 0x00 14. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_VREFINGLOBAL_P2_GLOBALVREFINMODE ,RSVD RESET:0x0"
          
group.long  0x168++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DFIWRDATACSDESTMAP_P2, This CSR must be default values in LPDDR3 and LPDDR4 modes Maps dfi_wrdata_cs_n (write chip-select asserted low) to destination dimm timing group. The full dfi interface has 72 values of dfi_wrdata_cs_n, with 8 per byte. Byte db (0..8) uses values dfi_wrdata_cs_n[(db*8 + 7):(db*8 + 0)] and this register, which is per byte, to determine the timing-control registers to use for the asserted chip-select. For simplicity, the subfield description does not include the byte offset for dfi_wrdata_cs_n.  Note: The example values below are the default/reset values. If this register is written to all zeroes, then all writes will use Register Tx[Dq,Dqs]Dlyd0 timing. RESET:0xe4"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DFIWRDATACSDESTMAP_P2_DFIWRDESTM0 ,Maps dfi_wrdata_cs_n_p0[0] to dest DfiWrDestm0 timing  For example, if 0 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg0 timing. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DFIWRDATACSDESTMAP_P2_DFIWRDESTM1 ,Maps dfi_wrdata_cs_n_p0[1] to dest DfiWrDestm1 timing  For example, if 1 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg1 timing. RESET:0x1"
          
         hexmask.long 0x00 4.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DFIWRDATACSDESTMAP_P2_DFIWRDESTM2 ,Maps dfi_wrdata_cs_n_p0[2] to dest DfiWrDestm2 timing  For example, if 2 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg2 timing. RESET:0x2"
          
         hexmask.long 0x00 6.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DFIWRDATACSDESTMAP_P2_DFIWRDESTM3 ,Maps dfi_wrdata_cs_n_p0[3] to dest DfiWrDestm3 timing (use Register Tx[Dq,Dqs]DlyTg3)  For example, if 3 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg3 timing. RESET:0x3"
          
group.long  0x18a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PLLCTRL2_P2, This csr is to be programmed by bios or other means to set PLL charge-pump settings in various PStates. See Technology specific PHY Databook for control setting programming. RESET:0x19"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PLLCTRL2_P2_PLLFREQSEL ,Adjusts the loop parameters to compensate for different VCO bias points, and input/output clock division ratios. RESET:0x19"
          
group.long  0x18e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PLLCTRL1_P2, This csr is to be programmed by bios or other means to set PLL charge-pump settings in various PStates. See Technology specific PHY Databook for control setting programming. RESET:0x20"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PLLCTRL1_P2_PLLCPINTCTRL ,connects directly to cp_int_cntrl<4:0> in PLL. Charge pump integrating current control. RESET:0x0"
          
         hexmask.long 0x00 5.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PLLCTRL1_P2_PLLCPPROPCTRL ,connects directly to cp_prop_cntrl<3:0> of PLL. Charge pump proportional current control. RESET:0x1"
          
group.long  0x194++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PLLTESTMODE_P2, Additional controls for PLL CP/VCO modes of operation RESET:0x124"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PLLTESTMODE_P2_PLLTESTMODE_P2 ,It is required to use default values for this CSR unless directed otherwise by Synopsys. Directly connected to testmode[15:0] pin of PLL RESET:0x124"
          
group.long  0x198++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PLLCTRL4_P2, This csr is to be programmed by bios or other means to set PLL charge-pump settings in various PStates. Refer to Technology specific PHY Databook for control setting programming. RESET:0x17f"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PLLCTRL4_P2_PLLCPINTGSCTRL ,connects directly to cp_int_gs_cntrl<4:0> in PLL. Charge pump integrating current control for fast relock and gearshift. RESET:0x1f"
          
         hexmask.long 0x00 5.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_PLLCTRL4_P2_PLLCPPROPGSCTRL ,connects directly to cp_prop_gs_cntrl<3:0> of PLL. Charge pump proportional current control for fast relock and gearshift. RESET:0xb"
          
group.long  0x1f4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DFIFREQRATIO_P2, DFI Frequency Ratio RESET:0x1"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P2_DFIFREQRATIO_P2_DFIFREQRATIO_P2 ,Specifies the ratio DfiCtlClk:MemClk.  - 00 = 1:1 mode  - 01 = 1:2 mode  - 1x = 1:4 mode When DWC_DDRPHY_FIXED_DFICTLCLK_RATIO is defined, this register is ignored and 1:2 mode is selected. RESET:0x1"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_ACSM0_P2"
base e:0x42480000
width 80.
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X0_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X0_P2_ACSMPLAYBACK0X0_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X0_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X0_P2_ACSMPLAYBACK1X0_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x104++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X1_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X1_P2_ACSMPLAYBACK0X1_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x106++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X1_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X1_P2_ACSMPLAYBACK1X1_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x108++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X2_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X2_P2_ACSMPLAYBACK0X2_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x10a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X2_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X2_P2_ACSMPLAYBACK1X2_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x10c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X3_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X3_P2_ACSMPLAYBACK0X3_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x10e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X3_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X3_P2_ACSMPLAYBACK1X3_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x110++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X4_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X4_P2_ACSMPLAYBACK0X4_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x112++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X4_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X4_P2_ACSMPLAYBACK1X4_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x114++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X5_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X5_P2_ACSMPLAYBACK0X5_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x116++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X5_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X5_P2_ACSMPLAYBACK1X5_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x118++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X6_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X6_P2_ACSMPLAYBACK0X6_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x11a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X6_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X6_P2_ACSMPLAYBACK1X6_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x11c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X7_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK0X7_P2_ACSMPLAYBACK0X7_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x11e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X7_P2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P2_ACSMPLAYBACK1X7_P2_ACSMPLAYBACK1X7_P2 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_INITENG0_P2"
base e:0x42520000
width 80.
group.long  0x402++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR1_P2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR1_P2_SEQ0BGPR1_P2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x404++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR2_P2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR2_P2_SEQ0BGPR2_P2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x406++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR3_P2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR3_P2_SEQ0BGPR3_P2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x408++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR4_P2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR4_P2_SEQ0BGPR4_P2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x40a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR5_P2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR5_P2_SEQ0BGPR5_P2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x40c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR6_P2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR6_P2_SEQ0BGPR6_P2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x40e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR7_P2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR7_P2_SEQ0BGPR7_P2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x410++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR8_P2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P2_SEQ0BGPR8_P2_SEQ0BGPR8_P2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_ANIB0_P3"
base e:0x42600000
width 80.
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P3_ATXDLY_P3, Address/Command Delay, per pstate. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P3_ATXDLY_P3_ATXDLY_P3 ,Trained for LPDDR3/4 to generate timed address and command signals to the DRAMs, per ACX4. For DDR3/DDR4, it is recommended that address and command ACX4 have it ATxDly=0x00 The four signals generated by an ACX4 will have common timing.  - ATxDly[6] is the coarse delay, ie one unit of delay is 1 UI.  - ATxDly[5] is reserved.  - ATxDly[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32. The target ACX4 used for memory clock generation, must have its ATxDly configured to 0x00. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_ANIB1_P3"
base e:0x42602000
width 80.
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P3_ATXDLY_P3, Address/Command Delay, per pstate. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P3_ATXDLY_P3_ATXDLY_P3 ,Trained for LPDDR3/4 to generate timed address and command signals to the DRAMs, per ACX4. For DDR3/DDR4, it is recommended that address and command ACX4 have it ATxDly=0x00 The four signals generated by an ACX4 will have common timing.  - ATxDly[6] is the coarse delay, ie one unit of delay is 1 UI.  - ATxDly[5] is reserved.  - ATxDly[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32. The target ACX4 used for memory clock generation, must have its ATxDly configured to 0x00. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_ANIB2_P3"
base e:0x42604000
width 80.
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P3_ATXDLY_P3, Address/Command Delay, per pstate. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P3_ATXDLY_P3_ATXDLY_P3 ,Trained for LPDDR3/4 to generate timed address and command signals to the DRAMs, per ACX4. For DDR3/DDR4, it is recommended that address and command ACX4 have it ATxDly=0x00 The four signals generated by an ACX4 will have common timing.  - ATxDly[6] is the coarse delay, ie one unit of delay is 1 UI.  - ATxDly[5] is reserved.  - ATxDly[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32. The target ACX4 used for memory clock generation, must have its ATxDly configured to 0x00. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_DBYTE0_P3"
base e:0x42620000
width 80.
group.long  0x6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_USEDQSENREPLICA_P3, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_USEDQSENREPLICA_P3_USEDQSENREPLICA_P3 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DFIMRL_P3, DFI MaxReadLatency RESET:0x6"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DFIMRL_P3_DFIMRL_P3 ,This Max Read Latency CSR is to be trained to ensure the rx-data fifo is not read until after all dbytes have their read data valid. This is the value, in units of two mem clocks, between dfi_rddata_en and dfi_rddata_valid A unit change in the LSB is a change in MRL of two mem clocks. RESET:0x6"
          
group.long  0x82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL0_B0_P3, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL0_B0_P3_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL0_B0_P3_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DQDQSRCVCNTRL_B0_P3, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DQDQSRCVCNTRL_B0_P3_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DQDQSRCVCNTRL_B0_P3_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DQDQSRCVCNTRL_B0_P3_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DQDQSRCVCNTRL_B0_P3_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DQDQSRCVCNTRL_B0_P3_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x90++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXEQUALIZATIONMODE_P3, Tx DQ driver equalization is a technique for improving the write-data eye at the DRAMs. The driver can drive with full strength (configured with DrvStrenFSHiDqP and DrvStrenFSLoDqN0 or with weak strength (configured with DrvStrenEQHiDqP and DrvStrenEQLoDqN) depending on the dq value sequence.  - TxEqMode = 00 Off; drive with full strength only  - TxEqMode = 01 Mode0 drive with full strength.or weak strength depending on  present logical value and the previous logical value.  - TxEqMode = 10 Mode1 drive with full strength.or weak strength depending on  present logical value and the next logical value. Mode1 is a lower power mode.  - TxEqMode = 11 reserved RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXEQUALIZATIONMODE_P3_TXEQMODE ,Tx dq driver equalization mode controls. FFE, de-emphasis DDR43 PHY ONLY RESET:0x0"
          
group.long  0x92++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL1_B0_P3, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL1_B0_P3_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL1_B0_P3_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x96++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL2_B0_P3, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL2_B0_P3_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL2_B0_P3_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x98++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DQDQSRCVCNTRL2_P3, Control for an aggressive power-saving feature to powerdown dq and dqs receiver cells dynamically. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DQDQSRCVCNTRL2_P3_ENRXAGRESSIVEPDR ,reserved RESET:0x0"
          
group.long  0x9a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXODTDRVSTREN_B0_P3, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXODTDRVSTREN_B0_P3_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXODTDRVSTREN_B0_P3_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
group.long  0xbe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXSLEWRATE_B0_P3, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXSLEWRATE_B0_P3_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXSLEWRATE_B0_P3_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXSLEWRATE_B0_P3_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG0_U0_P3, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG0_U0_P3_RXENDLYTG0_U0_P3 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG1_U0_P3, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG1_U0_P3_RXENDLYTG1_U0_P3 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x104++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG2_U0_P3, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG2_U0_P3_RXENDLYTG2_U0_P3 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x106++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG3_U0_P3, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG3_U0_P3_RXENDLYTG3_U0_P3 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x118++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG0_U0_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG0_U0_P3_RXCLKDLYTG0_U0_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x11a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG1_U0_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG1_U0_P3_RXCLKDLYTG1_U0_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x11c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG2_U0_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG2_U0_P3_RXCLKDLYTG2_U0_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x11e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG3_U0_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG3_U0_P3_RXCLKDLYTG3_U0_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x120++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG0_U0_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG0_U0_P3_RXCLKCDLYTG0_U0_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x122++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG1_U0_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG1_U0_P3_RXCLKCDLYTG1_U0_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x124++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG2_U0_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG2_U0_P3_RXCLKCDLYTG2_U0_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x126++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG3_U0_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG3_U0_P3_RXCLKCDLYTG3_U0_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x15c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_PPTDQSCNTINVTRNTG0_P3, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_PPTDQSCNTINVTRNTG0_P3_PPTDQSCNTINVTRNTG0_P3 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x15e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_PPTDQSCNTINVTRNTG1_P3, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_PPTDQSCNTINVTRNTG1_P3_PPTDQSCNTINVTRNTG1_P3 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R0_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R0_P3_TXDQDLYTG0_R0_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R0_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R0_P3_TXDQDLYTG1_R0_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R0_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R0_P3_TXDQDLYTG2_R0_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R0_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R0_P3_TXDQDLYTG3_R0_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG0_U0_P3, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG0_U0_P3_TXDQSDLYTG0_U0_P3 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x1a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG1_U0_P3, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG1_U0_P3_TXDQSDLYTG1_U0_P3 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x1a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG2_U0_P3, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG2_U0_P3_TXDQSDLYTG2_U0_P3 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x1a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG3_U0_P3, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG3_U0_P3_TXDQSDLYTG3_U0_P3 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x282++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL0_B1_P3, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL0_B1_P3_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL0_B1_P3_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x286++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DQDQSRCVCNTRL_B1_P3, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DQDQSRCVCNTRL_B1_P3_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DQDQSRCVCNTRL_B1_P3_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DQDQSRCVCNTRL_B1_P3_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DQDQSRCVCNTRL_B1_P3_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_DQDQSRCVCNTRL_B1_P3_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x292++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL1_B1_P3, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL1_B1_P3_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL1_B1_P3_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x296++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL2_B1_P3, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL2_B1_P3_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXIMPEDANCECTRL2_B1_P3_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x29a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXODTDRVSTREN_B1_P3, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXODTDRVSTREN_B1_P3_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXODTDRVSTREN_B1_P3_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
group.long  0x2be++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXSLEWRATE_B1_P3, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXSLEWRATE_B1_P3_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXSLEWRATE_B1_P3_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXSLEWRATE_B1_P3_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0x300++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG0_U1_P3, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG0_U1_P3_RXENDLYTG0_U1_P3 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x302++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG1_U1_P3, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG1_U1_P3_RXENDLYTG1_U1_P3 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x304++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG2_U1_P3, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG2_U1_P3_RXENDLYTG2_U1_P3 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x306++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG3_U1_P3, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXENDLYTG3_U1_P3_RXENDLYTG3_U1_P3 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x318++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG0_U1_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG0_U1_P3_RXCLKDLYTG0_U1_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x31a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG1_U1_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG1_U1_P3_RXCLKDLYTG1_U1_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x31c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG2_U1_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG2_U1_P3_RXCLKDLYTG2_U1_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x31e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG3_U1_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKDLYTG3_U1_P3_RXCLKDLYTG3_U1_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x320++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG0_U1_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG0_U1_P3_RXCLKCDLYTG0_U1_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x322++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG1_U1_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG1_U1_P3_RXCLKCDLYTG1_U1_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x324++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG2_U1_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG2_U1_P3_RXCLKCDLYTG2_U1_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x326++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG3_U1_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_RXCLKCDLYTG3_U1_P3_RXCLKCDLYTG3_U1_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x380++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R1_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R1_P3_TXDQDLYTG0_R1_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x382++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R1_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R1_P3_TXDQDLYTG1_R1_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x384++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R1_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R1_P3_TXDQDLYTG2_R1_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x386++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R1_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R1_P3_TXDQDLYTG3_R1_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x3a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG0_U1_P3, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG0_U1_P3_TXDQSDLYTG0_U1_P3 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x3a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG1_U1_P3, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG1_U1_P3_TXDQSDLYTG1_U1_P3 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x3a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG2_U1_P3, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG2_U1_P3_TXDQSDLYTG2_U1_P3 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x3a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG3_U1_P3, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQSDLYTG3_U1_P3_TXDQSDLYTG3_U1_P3 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x580++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R2_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R2_P3_TXDQDLYTG0_R2_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x582++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R2_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R2_P3_TXDQDLYTG1_R2_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x584++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R2_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R2_P3_TXDQDLYTG2_R2_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x586++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R2_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R2_P3_TXDQDLYTG3_R2_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x780++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R3_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R3_P3_TXDQDLYTG0_R3_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x782++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R3_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R3_P3_TXDQDLYTG1_R3_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x784++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R3_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R3_P3_TXDQDLYTG2_R3_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x786++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R3_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R3_P3_TXDQDLYTG3_R3_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x980++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R4_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R4_P3_TXDQDLYTG0_R4_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x982++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R4_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R4_P3_TXDQDLYTG1_R4_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x984++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R4_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R4_P3_TXDQDLYTG2_R4_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x986++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R4_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R4_P3_TXDQDLYTG3_R4_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xb80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R5_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R5_P3_TXDQDLYTG0_R5_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xb82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R5_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R5_P3_TXDQDLYTG1_R5_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xb84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R5_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R5_P3_TXDQDLYTG2_R5_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xb86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R5_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R5_P3_TXDQDLYTG3_R5_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xd80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R6_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R6_P3_TXDQDLYTG0_R6_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xd82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R6_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R6_P3_TXDQDLYTG1_R6_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xd84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R6_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R6_P3_TXDQDLYTG2_R6_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xd86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R6_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R6_P3_TXDQDLYTG3_R6_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xf80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R7_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R7_P3_TXDQDLYTG0_R7_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xf82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R7_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R7_P3_TXDQDLYTG1_R7_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xf84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R7_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R7_P3_TXDQDLYTG2_R7_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xf86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R7_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R7_P3_TXDQDLYTG3_R7_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R8_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG0_R8_P3_TXDQDLYTG0_R8_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x1182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R8_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG1_R8_P3_TXDQDLYTG1_R8_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x1184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R8_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG2_R8_P3_TXDQDLYTG2_R8_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x1186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R8_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P3_TXDQDLYTG3_R8_P3_TXDQDLYTG3_R8_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_DBYTE1_P3"
base e:0x42622000
width 80.
group.long  0x6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_USEDQSENREPLICA_P3, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_USEDQSENREPLICA_P3_USEDQSENREPLICA_P3 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DFIMRL_P3, DFI MaxReadLatency RESET:0x6"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DFIMRL_P3_DFIMRL_P3 ,This Max Read Latency CSR is to be trained to ensure the rx-data fifo is not read until after all dbytes have their read data valid. This is the value, in units of two mem clocks, between dfi_rddata_en and dfi_rddata_valid A unit change in the LSB is a change in MRL of two mem clocks. RESET:0x6"
          
group.long  0x82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL0_B0_P3, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL0_B0_P3_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL0_B0_P3_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DQDQSRCVCNTRL_B0_P3, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DQDQSRCVCNTRL_B0_P3_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DQDQSRCVCNTRL_B0_P3_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DQDQSRCVCNTRL_B0_P3_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DQDQSRCVCNTRL_B0_P3_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DQDQSRCVCNTRL_B0_P3_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x90++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXEQUALIZATIONMODE_P3, Tx DQ driver equalization is a technique for improving the write-data eye at the DRAMs. The driver can drive with full strength (configured with DrvStrenFSHiDqP and DrvStrenFSLoDqN0 or with weak strength (configured with DrvStrenEQHiDqP and DrvStrenEQLoDqN) depending on the dq value sequence.  - TxEqMode = 00 Off; drive with full strength only  - TxEqMode = 01 Mode0 drive with full strength.or weak strength depending on  present logical value and the previous logical value.  - TxEqMode = 10 Mode1 drive with full strength.or weak strength depending on  present logical value and the next logical value. Mode1 is a lower power mode.  - TxEqMode = 11 reserved RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXEQUALIZATIONMODE_P3_TXEQMODE ,Tx dq driver equalization mode controls. FFE, de-emphasis DDR43 PHY ONLY RESET:0x0"
          
group.long  0x92++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL1_B0_P3, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL1_B0_P3_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL1_B0_P3_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x96++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL2_B0_P3, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL2_B0_P3_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL2_B0_P3_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x98++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DQDQSRCVCNTRL2_P3, Control for an aggressive power-saving feature to powerdown dq and dqs receiver cells dynamically. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DQDQSRCVCNTRL2_P3_ENRXAGRESSIVEPDR ,reserved RESET:0x0"
          
group.long  0x9a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXODTDRVSTREN_B0_P3, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXODTDRVSTREN_B0_P3_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXODTDRVSTREN_B0_P3_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
group.long  0xbe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXSLEWRATE_B0_P3, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXSLEWRATE_B0_P3_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXSLEWRATE_B0_P3_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXSLEWRATE_B0_P3_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG0_U0_P3, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG0_U0_P3_RXENDLYTG0_U0_P3 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG1_U0_P3, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG1_U0_P3_RXENDLYTG1_U0_P3 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x104++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG2_U0_P3, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG2_U0_P3_RXENDLYTG2_U0_P3 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x106++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG3_U0_P3, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG3_U0_P3_RXENDLYTG3_U0_P3 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x118++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG0_U0_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG0_U0_P3_RXCLKDLYTG0_U0_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x11a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG1_U0_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG1_U0_P3_RXCLKDLYTG1_U0_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x11c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG2_U0_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG2_U0_P3_RXCLKDLYTG2_U0_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x11e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG3_U0_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG3_U0_P3_RXCLKDLYTG3_U0_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x120++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG0_U0_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG0_U0_P3_RXCLKCDLYTG0_U0_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x122++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG1_U0_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG1_U0_P3_RXCLKCDLYTG1_U0_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x124++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG2_U0_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG2_U0_P3_RXCLKCDLYTG2_U0_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x126++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG3_U0_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG3_U0_P3_RXCLKCDLYTG3_U0_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x15c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_PPTDQSCNTINVTRNTG0_P3, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_PPTDQSCNTINVTRNTG0_P3_PPTDQSCNTINVTRNTG0_P3 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x15e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_PPTDQSCNTINVTRNTG1_P3, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_PPTDQSCNTINVTRNTG1_P3_PPTDQSCNTINVTRNTG1_P3 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R0_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R0_P3_TXDQDLYTG0_R0_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R0_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R0_P3_TXDQDLYTG1_R0_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R0_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R0_P3_TXDQDLYTG2_R0_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R0_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R0_P3_TXDQDLYTG3_R0_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG0_U0_P3, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG0_U0_P3_TXDQSDLYTG0_U0_P3 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x1a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG1_U0_P3, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG1_U0_P3_TXDQSDLYTG1_U0_P3 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x1a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG2_U0_P3, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG2_U0_P3_TXDQSDLYTG2_U0_P3 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x1a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG3_U0_P3, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG3_U0_P3_TXDQSDLYTG3_U0_P3 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x282++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL0_B1_P3, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL0_B1_P3_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL0_B1_P3_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x286++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DQDQSRCVCNTRL_B1_P3, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DQDQSRCVCNTRL_B1_P3_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DQDQSRCVCNTRL_B1_P3_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DQDQSRCVCNTRL_B1_P3_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DQDQSRCVCNTRL_B1_P3_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_DQDQSRCVCNTRL_B1_P3_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x292++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL1_B1_P3, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL1_B1_P3_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL1_B1_P3_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x296++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL2_B1_P3, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL2_B1_P3_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXIMPEDANCECTRL2_B1_P3_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x29a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXODTDRVSTREN_B1_P3, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXODTDRVSTREN_B1_P3_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXODTDRVSTREN_B1_P3_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
group.long  0x2be++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXSLEWRATE_B1_P3, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXSLEWRATE_B1_P3_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXSLEWRATE_B1_P3_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXSLEWRATE_B1_P3_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0x300++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG0_U1_P3, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG0_U1_P3_RXENDLYTG0_U1_P3 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x302++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG1_U1_P3, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG1_U1_P3_RXENDLYTG1_U1_P3 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x304++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG2_U1_P3, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG2_U1_P3_RXENDLYTG2_U1_P3 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x306++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG3_U1_P3, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXENDLYTG3_U1_P3_RXENDLYTG3_U1_P3 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x318++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG0_U1_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG0_U1_P3_RXCLKDLYTG0_U1_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x31a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG1_U1_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG1_U1_P3_RXCLKDLYTG1_U1_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x31c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG2_U1_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG2_U1_P3_RXCLKDLYTG2_U1_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x31e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG3_U1_P3, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKDLYTG3_U1_P3_RXCLKDLYTG3_U1_P3 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x320++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG0_U1_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG0_U1_P3_RXCLKCDLYTG0_U1_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x322++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG1_U1_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG1_U1_P3_RXCLKCDLYTG1_U1_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x324++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG2_U1_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG2_U1_P3_RXCLKCDLYTG2_U1_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x326++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG3_U1_P3, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_RXCLKCDLYTG3_U1_P3_RXCLKCDLYTG3_U1_P3 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x380++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R1_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R1_P3_TXDQDLYTG0_R1_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x382++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R1_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R1_P3_TXDQDLYTG1_R1_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x384++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R1_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R1_P3_TXDQDLYTG2_R1_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x386++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R1_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R1_P3_TXDQDLYTG3_R1_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x3a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG0_U1_P3, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG0_U1_P3_TXDQSDLYTG0_U1_P3 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x3a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG1_U1_P3, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG1_U1_P3_TXDQSDLYTG1_U1_P3 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x3a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG2_U1_P3, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG2_U1_P3_TXDQSDLYTG2_U1_P3 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x3a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG3_U1_P3, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQSDLYTG3_U1_P3_TXDQSDLYTG3_U1_P3 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x580++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R2_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R2_P3_TXDQDLYTG0_R2_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x582++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R2_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R2_P3_TXDQDLYTG1_R2_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x584++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R2_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R2_P3_TXDQDLYTG2_R2_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x586++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R2_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R2_P3_TXDQDLYTG3_R2_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x780++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R3_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R3_P3_TXDQDLYTG0_R3_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x782++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R3_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R3_P3_TXDQDLYTG1_R3_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x784++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R3_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R3_P3_TXDQDLYTG2_R3_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x786++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R3_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R3_P3_TXDQDLYTG3_R3_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x980++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R4_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R4_P3_TXDQDLYTG0_R4_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x982++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R4_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R4_P3_TXDQDLYTG1_R4_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x984++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R4_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R4_P3_TXDQDLYTG2_R4_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x986++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R4_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R4_P3_TXDQDLYTG3_R4_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xb80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R5_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R5_P3_TXDQDLYTG0_R5_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xb82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R5_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R5_P3_TXDQDLYTG1_R5_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xb84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R5_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R5_P3_TXDQDLYTG2_R5_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xb86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R5_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R5_P3_TXDQDLYTG3_R5_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xd80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R6_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R6_P3_TXDQDLYTG0_R6_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xd82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R6_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R6_P3_TXDQDLYTG1_R6_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xd84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R6_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R6_P3_TXDQDLYTG2_R6_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xd86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R6_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R6_P3_TXDQDLYTG3_R6_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xf80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R7_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R7_P3_TXDQDLYTG0_R7_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xf82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R7_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R7_P3_TXDQDLYTG1_R7_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xf84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R7_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R7_P3_TXDQDLYTG2_R7_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xf86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R7_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R7_P3_TXDQDLYTG3_R7_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R8_P3, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG0_R8_P3_TXDQDLYTG0_R8_P3 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x1182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R8_P3, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG1_R8_P3_TXDQDLYTG1_R8_P3 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x1184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R8_P3, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG2_R8_P3_TXDQDLYTG2_R8_P3 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x1186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R8_P3, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P3_TXDQDLYTG3_R8_P3_TXDQDLYTG3_R8_P3 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_MASTER0_P3"
base e:0x42640000
width 80.
group.long  0x10++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_CALUCLKINFO_P3, Informs the impedance calibration engine about frequency of DfiClk RESET:0x320"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_CALUCLKINFO_P3_CALUCLKTICKSPER1US ,Must be programmed to the number of DfiClks in 1us (rounded up), with minimum value of 24. - if (DfiClk < 24MHz) CalUclkInfo = 24 - else CalUclkInfo = (number of DfiClks in 1us) RESET:0x320"
          
group.long  0x16++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_SEQ0BDLY0_P3, PHY Initialization Engine (PIE) Delay Register 0 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_SEQ0BDLY0_P3_SEQ0BDLY0_P3 ,PHY Initialization Engine (PIE) Delay Register 0. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_SEQ0BDLY1_P3, PHY Initialization Engine (PIE) Delay Register 1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_SEQ0BDLY1_P3_SEQ0BDLY1_P3 ,PHY Initialization Engine (PIE) Delay Register 1. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x1a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_SEQ0BDLY2_P3, PHY Initialization Engine (PIE) Delay Register 2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_SEQ0BDLY2_P3_SEQ0BDLY2_P3 ,PHY Initialization Engine (PIE) Delay Register 2. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_SEQ0BDLY3_P3, PHY Initialization Engine (PIE) Delay Register 3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_SEQ0BDLY3_P3_SEQ0BDLY3_P3 ,PHY Initialization Engine (PIE) Delay Register 3. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PPTTRAINSETUP_P3, For LPDDR3/4 some tracking is required periodically using the DFI PHY MASTER interface. This register control the interval. Setting the register to 0 completely disables the PHY Master Interface. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PPTTRAINSETUP_P3_PHYMSTRTRAININTERVAL ,Bits 3:0 of this register specifies the time between the end of one training and the start of the next. Note that, to account for the delay to receive the acknowledge from the MC, the dfi_phymstr_req signal is asserted in advance so that the effective update (after acknowledge from the MC) occurs inside the interval defined by PhyMstrTrainInterval.  - 4'b0000 Disable PHY Master Interface  - 4'b0001 PHY MASTER Request Interval = 524288 MEMCLKs  - 4'b0010 PHY MASTER Request Interval = 1048576 MEMCLKs  - 4'b0011 PHY MASTER Request Interval = 2097152 MEMCLKs  - 4'b0100 PHY MASTER Request Interval = 4194304 MEMCLKs  - 4'b0101 PHY MASTER Request Interval = 8388608 MEMCLKs  - 4'b0110 PHY MASTER Request Interval = 16777216 MEMCLKs  - 4'b0111 PHY MASTER Request Interval = 33554432 MEMCLKs  - 4'b1000 PHY MASTER Request Interval = 67108864 MEMCLKs  - 4'b1001 PHY MASTER Request Interval = 134217728 MEMCLKs  - 4'b1010 PHY MASTER Request Interval = 268435456 MEMCLKs  - 4'b1011 - 4'b1111 PHY MASTER Request Interval = undefined RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PPTTRAINSETUP_P3_PHYMSTRMAXREQTOACK ,The value in bits 6:4 of this register specify the max time from tdfi_phymstr_req asserted to tdfi_phymstr_ack asserted. If the request is not acknowledged by this time, dfi_error will be asserted.  - 3'b000 Disable PHY Master Interface  - 3'b001 set tPHYMSTR_resp. = 512 MEMCLKs  - 3'b010 set tPHYMSTR_resp. = 1024 MEMCLKs  - 3'b011 set tPHYMSTR_resp. = 2048 MEMCLKs  - 3'b100 set tPHYMSTR_resp. = 4096 MEMCLKs  - 3'b101 set tPHYMSTR_resp. = 8192 MEMCLKs  - 3'b110 set tPHYMSTR_resp. = 32768 MEMCLKs  - 3'b111 set tPHYMSTR_resp. = undefined  Note: The above are nominal values. The actual values are reduced by (2 + (DWC_DDRPHY_PIPE_DFI_MISC * MEMCLK/DfiCtlClk)) * 2  Note: This signal interacts with dfi_phyupd_req. See Section Collisions Between PHY Update and DFI LP of the PUB Databook. RESET:0x0"
          
group.long  0x22++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PPTTRAINSETUP2_P3, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x2"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PPTTRAINSETUP2_P3_RFU_PPTTRAINSETUP2_P3 ,None RESET:0x2"
          
group.long  0x32++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_TRISTATEMODECA_P3, This register is used to control the PHY Dynamic Address/Command Tristate Feature, and the stopped MEMCLK state. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_TRISTATEMODECA_P3_DISDYNADRTRI ,When DisDynAdrTri=1, Dynamic Tristating is disabled. Dynamic Tristating is on by default. Dynamic Tristating should be disabled (DisDynAdrTri=1) for these modes:  - DR3/2T if the controller cannot follow the 2T PHY tristate protocol.  - DDR4/2T/2N if the controller cannot follow the 2T PHY tristate protocol.  - LPDDR4 When DisDynAdrTri=0 (default),  - In DDR4 mode, The following SDRAM pins can be dynamically tristated: A,BA,BG,ACT_n  - In LPDDR3 mode, The following SDRAM pins can be dynamically tristated: CA[*]  - In 1T mode, the PHY will tristate the relevant pins when all ranks are DESelected  - In 2T mode (or geardown), the PHY will tristate the relevant pins when:  -- DDR3 -- All ranks DESelected (all CS_L==1) AND [RAS_n,CAS_n,WE_n,BA0] = [1,1,1,0]  -- DDR4 -- All ranks DESelected (all CS_L==1) AND [RAS_n,CAS_n,WE_n,BA0,ACT_n] = [1,1,1,0,1]  - When in this mode, the controller should avoid sending the above patterns with any rank selected. [e.g. NOPs sent by the controller should have BA0 set to a non-zero value] RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_TRISTATEMODECA_P3_DDR2TMODE ,Must be set to 1 for Dynamic Tristate to work when CA bus is 2T or Geardown mode. This CSR bit has no effect when DisDynAdrTri==1 RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_TRISTATEMODECA_P3_CKDISVAL ,The PHY provides 4 memory clocks, n=0..3.  - When the toggling of memory clock CK_t[n] is disabled with dfi_clk_disable[n]=1, the memory clock CK_t[n] is driven with Register CkDisVal[1].  - When the toggling of memory clock CK_c[n] is disabled with dfi_clk_disable[n]=1, the memory clock CK_c[n] is driven with ~(Register CkDisVal[0]) (ie inverted).  Note that the non-toggling differential memory clock [CK_t[n],CK_c[n]] may be driven with any combination, LL,LH,HL,HH; the default [CK_t[n],CK_c[n]]=LH. RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_HWTMRL_P3, HWT MaxReadLatency. RESET:0x6"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_HWTMRL_P3_HWTMRL_P3 ,This MASTER copy of MRL is used by the PHY training firmware only. RESET:0x6"
          
group.long  0x48++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DQSPREAMBLECONTROL_P3, For improved robustness in operating with DRAM timing drift, this register provides controls for the width of the write DQS preamble and postamble, and controls for the anticipated width of DQS preamble for reads. RESET:0x8"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DQSPREAMBLECONTROL_P3_TWOTCKRXDQSPRE ,Widens the RxDqsEn window to allow larger drift in the incoming read DQS to take advantage of the larger/wider preamble generated by the DRAMSs when the D4 DRAMS are configured with DDR4 MR4 A11 Read Preamble=1 for causing a 2nCK read preamble. For LPDDR4, set to 1 for static read preamble, set to 0 for toggling read preamble.  Note the nominal trained-to-center point will be earlier relative to the first strobing edge of DQS than when not in this mode. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DQSPREAMBLECONTROL_P3_TWOTCKTXDQSPRE ,For LPDDR4, all write operations are 2nCK such that this control must be set to 1. RESET:0x0"
          
         hexmask.long 0x00 2.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DQSPREAMBLECONTROL_P3_POSITIONDFEINIT ,For DDR4 phy only when receive DFE is enabled.  - PositionDfeInit[2] is reserved  - PositionDfeInit[1]=1 causes DfeInit to be asserted at the nominal time  - PositionDfeInit[0] is reserved PositionDfeInit=3'b010 is the nominal, recommended value for leading edge used by receiver, other values are reserved. RESET:0x2"
          
         bitfld.long 0x00 5. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DQSPREAMBLECONTROL_P3_LP4TGLTWOTCKTXDQSPRE ,Used in LPDDR4 mode to modify the early preamble when Register TwoTckTxDqsPre=1 - 0: level first-memclk preamble - 1: toggling first-memclk preamble RESET:0x0"
          
         bitfld.long 0x00 6. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DQSPREAMBLECONTROL_P3_LP4POSTAMBLEEXT ,In LPDDR4 mode must be set to extend the write postamble. - 0: half-memclk postamble, as in D4 - 1: one-and-one-half-memclk postamble; see LPDDR4 Spec MR3, OP[1] WR PST, vendor-specific function. RESET:0x0"
          
         bitfld.long 0x00 7. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DQSPREAMBLECONTROL_P3_LP4STTCPREBRIDGERXEN ,Used in LPDDR4 static-preamble mode to bridge the RxEn between two reads to the same timing group when the bubble is 1 memclk. LPDDR4 static-preamble mode is set in the DRAMs with MR1, OP[3]=0. RESET:0x0"
          
         bitfld.long 0x00 8. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DQSPREAMBLECONTROL_P3_WDQSEXTENSION ,When set, DQS_T and DQS_C will be driven differentially to 0 and 1, respectively, before and after a write burst, except during a memory read transaction. See DesignWare Cores LPDDR4 MultiPHY: WDQS Extension Application Note. Use of WDQSEXTENSION requires POdtTailWidth=3 and POdtStartDelay=00 RESET:0x0"
          
group.long  0x5a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DMIPINPRESENT_P3, This Register is used to instruct the PHY whether to enable the Read-DBI function on Lane8 of each DBYTE. Only the LPDDR4 and DDR4 Protocols support the Read-DBI feature. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DMIPINPRESENT_P3_RDDBIENABLED ,This bit must be set to 1'b1 if Read-DBI is enabled in a connected DDR4 or LPDDR4 device. If set, the following DRAM MR should also be set [DDR4.MR5.A12=1 or LPDDR4.MR3.OP[7]=1] RESET:0x0"
          
group.long  0x5c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_ARDPTRINITVAL_P3, Address/Command FIFO ReadPointer Initial Value RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_ARDPTRINITVAL_P3_ARDPTRINITVAL_P3 ,This is the initial Pointer Offset for the free-running FIFOs in the DBYTE and ACX4 hardips. The units of this register are in UI. The pointer separation should be chosen to compensate for all sources of skew and drift of the PHY DFICLK and PCLK networks. See 'ARdPtrInitVal Impacts From Construction Skews' of the PUB databook. This CSR must be programmed in Step C of the PHY Initialization sequence RESET:0x0"
          
group.long  0xac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PROCODTTIMECTL_P3, Controls timing of ProcOdt for DQ and DQS termination during reads. The enabling and disabling of ProcOdt can be shifted with a granularity of 1UI.  If WDQSEXTENSION is enabled, this register should be set to 0x03. Otherwise, use the recommended settings based on MEMCLK frequency and TwoTckRxDqsPre. This will ensure that ProcOdt is enabled before the DQS preamble begins and is not disabled until after the DQS postamble ends.  Recommended configuration if Register TwoTckRxDqsPre==1:  - 0000MHz < memclk-freq <= 0933 ; Register POdtStartDelay= 2 ; Register POdtTailWidth=2  - 0933MHz < memclk-freq <= 1200 ; Register POdtStartDelay= 0 ; Register POdtTailWidth=2  - 1200MHz < memclk-freq <= NA ; Register POdtStartDelay= 0 ; Register POdtTailWidth=3  Recommended configuration if TwoTckRxDqsPre==0:  - 0000MHz < memclk-freq <= 933 ; Register POdtStartDelay= 2 ; Register POdtTailWidth=2  - 0933MHz < memclk-freq <= 1200 ; Register POdtStartDelay= 1 ; Register POdtTailWidth=2  - 1200MHz < memclk-freq <= NA ; Register POdtStartDelay= 1 ; Register POdtTailWidth=3 See related CSR TxOdtDrvStren. RESET:0x1f"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PROCODTTIMECTL_P3_PODTTAILWIDTH ,controls the length of the tail of ProcOdt, units of UI - POdtTailWidth controls the time from closing the window to receive DQS to ProcODT deassertion, and can be set with values ranging from 0 to 3. - The aforementioned timing is defined as (3 + POdtTailWidth + POdtTailWidthExt - csrTwiTckDqsPre) UIs. - It is recommended to use this csr as the main timing configuration unit, with default value of 3. Note that this might not be the optimal value, since it is technology dependent. Refer to the PHY Databook for optimal settings. RESET:0x3"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PROCODTTIMECTL_P3_PODTSTARTDELAY ,controls the start of ProcOdt, units of UI  - 3 delay start 2 UI, maximum delay of start of ProcOdt  - 2 delay start 1 UI,  - 1 delay start 0 UI, default  - 0 early by 1 UI, The time from ProcODT assertion to opening the window to receive DQS is than (10 - POdtStartDelay) UI. It may be up to 4 pclk smaller if small 	  coarse delays are used (used only at the lowest clock frequencies) RESET:0x3"
          
         hexmask.long 0x00 4.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PROCODTTIMECTL_P3_PODTTAILWIDTHEXT ,controls the length of the tail of ProcOdt, units of UI - POdtTailWidthExt controls the time from closing the window to receive DQS to ProcODT deassertion, and can be set with values ranging from 0 to 3. - The aforementioned timing is defines as (3 + POdtTailWidth + POdtTailWidthExt - csrTwiTckDqsPre) UIs. - It is recommended to use this csr as an extension to POdtTailWidth, and has a default value of 1. Note that this might not be the optimal value, since it is technology dependent. Refer to the PHY Databook for optimal settings. RESET:0x1"
          
group.long  0xf8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DLLGAINCTL_P3, Controls for the DllGain sequencing for locking and maintaining lock of the LCDL delay cells. - The DllGain sequencer will start locking with the DllGainIV. - As the end of locking approaches, the DllGain will be incremented in stages until, at the end of locking, the DllGain is the terminal values DllGainTV. - 2^(5-DllGain) is fractional change in the DAC code MstPhase1UI[8:0] of Dll per pclk. - Firmware uses values for DllGainIV, DllGainTV, and LcdlSeed0 that are optimized for minimum locking time. These controls are not to be configured by the user. RESET:0xa1"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DLLGAINCTL_P3_DLLGAINIV ,Initial value of DllGain. RESET:0x1"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DLLGAINCTL_P3_DLLGAINTV ,Terminal value of DllGain, ie the value in effect when locking is done and the value used for maintaining lock, ie tracking pclk variation. DllGainTV must be greater than or equal to DllGainIV. The maximum value is 10. RESET:0xa"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DLLGAINCTL_P3_DLLSEEDSEL ,Reserved, must be configured to be 0. RESET:0x0"
          
group.long  0xfa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DLLLOCKPARAM_P3, Reserved for PHY training firmware use. RESET:0x17c1"
         hexmask.long 0x00 0.--12. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DLLLOCKPARAM_P3_RFU_DLLLOCKPARAM_P3 ,None RESET:0x17c1"
          
group.long  0x160++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DFIRDDATACSDESTMAP_P3, This CSR must be default values in LPDDR3 and LPDDR4 modes. Maps dfi_rddata_cs_n (read chip-select asserted low) to destination dimm timing group. RESET:0xe4"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DFIRDDATACSDESTMAP_P3_DFIRDDESTM0 ,Maps dfi_rddata_cs_n_p0[0] to dest DfiRdDestm0 timing.  For example, if 0 dfi_rddata_cs_n_p0[0] will use Register Rx[En,Clk]DlyTg0 timing. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DFIRDDATACSDESTMAP_P3_DFIRDDESTM1 ,Maps dfi_rddata_cs_n_p0[1] to dest DfiRdDestm1 timing.  For example, if 1 dfi_rddata_cs_n[_p01] will use Register Rx[En,Clk]DlyTg1 timing. RESET:0x1"
          
         hexmask.long 0x00 4.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DFIRDDATACSDESTMAP_P3_DFIRDDESTM2 ,Maps dfi_rddata_cs_n_p0[2] to dest DfiRdDestm2 timing.  For example, if 2 dfi_rddata_cs_n_p0[2] will use Register Rx[En,Clk]DlyTg2 timing. RESET:0x2"
          
         hexmask.long 0x00 6.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DFIRDDATACSDESTMAP_P3_DFIRDDESTM3 ,Maps dfi_rddata_cs_n_p0[3] to dest DfiRdDestm3 timing.  For example, if 3 dfi_rddata_cs_n_p0[3] will use Register Rx[En,Clk]DlyTg3 timing. RESET:0x3"
          
group.long  0x164++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_VREFINGLOBAL_P3, This Register controls the PHY global VREF generator, and the PHY analog pad BP_VREF. The mission mode function of the PHY VREF generator is to generate VrefDQ for the PHY RX function. This register is written and configured by the PHY training firmware for mission mode function. RESET:0x200"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_VREFINGLOBAL_P3_GLOBALVREFINSEL ,GlobalVrefInSel[1:0] controls the mode of the PHY VREF DAC and the BP_VREF pin  - 2'b00 - PHY Vref DAC Range0 -- BP_VREF = Hi-Z  - 2'b01 - Reserved Encoding  - 2'b10 - PHY Vref DAC Range0 -- BP_VREF connected to PLL Analog Bus  - 2'b11 - PHY Vref DAC Range0 -- BP_VREF connected to PHY Vref DAC GlobalVrefInSel[2] controls the DAC range for internal Vref generation RESET:0x0"
          
         hexmask.long 0x00 3.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_VREFINGLOBAL_P3_GLOBALVREFINDAC ,DAC code for internal Vref generation. The DAC has two ranges; the range is set by GlobalVrefInSel[2]  - RANGE0 : [GlobalVrefInSel[2] = 0]  -- DAC Output Voltage = GlobalVrefInDAC == 6'h00 ? Hi-Z : 0.345*VDDQ + (0.005*GlobalVrefInDAC)*VDDQ  - RANGE1 : [GlobalVrefInSel[2] = 1]  -- DAC Output Voltage = GlobalVrefInDAC == 6'h00 ? Hi-Z : (0.005*(GlobalVrefInDAC-1))*VDDQ RESET:0x40"
          
         hexmask.long 0x00 10.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_VREFINGLOBAL_P3_GLOBALVREFINTRIM ,RSVD RESET:0x0"
          
         bitfld.long 0x00 14. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_VREFINGLOBAL_P3_GLOBALVREFINMODE ,RSVD RESET:0x0"
          
group.long  0x168++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DFIWRDATACSDESTMAP_P3, This CSR must be default values in LPDDR3 and LPDDR4 modes Maps dfi_wrdata_cs_n (write chip-select asserted low) to destination dimm timing group. The full dfi interface has 72 values of dfi_wrdata_cs_n, with 8 per byte. Byte db (0..8) uses values dfi_wrdata_cs_n[(db*8 + 7):(db*8 + 0)] and this register, which is per byte, to determine the timing-control registers to use for the asserted chip-select. For simplicity, the subfield description does not include the byte offset for dfi_wrdata_cs_n.  Note: The example values below are the default/reset values. If this register is written to all zeroes, then all writes will use Register Tx[Dq,Dqs]Dlyd0 timing. RESET:0xe4"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DFIWRDATACSDESTMAP_P3_DFIWRDESTM0 ,Maps dfi_wrdata_cs_n_p0[0] to dest DfiWrDestm0 timing  For example, if 0 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg0 timing. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DFIWRDATACSDESTMAP_P3_DFIWRDESTM1 ,Maps dfi_wrdata_cs_n_p0[1] to dest DfiWrDestm1 timing  For example, if 1 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg1 timing. RESET:0x1"
          
         hexmask.long 0x00 4.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DFIWRDATACSDESTMAP_P3_DFIWRDESTM2 ,Maps dfi_wrdata_cs_n_p0[2] to dest DfiWrDestm2 timing  For example, if 2 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg2 timing. RESET:0x2"
          
         hexmask.long 0x00 6.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DFIWRDATACSDESTMAP_P3_DFIWRDESTM3 ,Maps dfi_wrdata_cs_n_p0[3] to dest DfiWrDestm3 timing (use Register Tx[Dq,Dqs]DlyTg3)  For example, if 3 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg3 timing. RESET:0x3"
          
group.long  0x18a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PLLCTRL2_P3, This csr is to be programmed by bios or other means to set PLL charge-pump settings in various PStates. See Technology specific PHY Databook for control setting programming. RESET:0x19"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PLLCTRL2_P3_PLLFREQSEL ,Adjusts the loop parameters to compensate for different VCO bias points, and input/output clock division ratios. RESET:0x19"
          
group.long  0x18e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PLLCTRL1_P3, This csr is to be programmed by bios or other means to set PLL charge-pump settings in various PStates. See Technology specific PHY Databook for control setting programming. RESET:0x20"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PLLCTRL1_P3_PLLCPINTCTRL ,connects directly to cp_int_cntrl<4:0> in PLL. Charge pump integrating current control. RESET:0x0"
          
         hexmask.long 0x00 5.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PLLCTRL1_P3_PLLCPPROPCTRL ,connects directly to cp_prop_cntrl<3:0> of PLL. Charge pump proportional current control. RESET:0x1"
          
group.long  0x194++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PLLTESTMODE_P3, Additional controls for PLL CP/VCO modes of operation RESET:0x124"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PLLTESTMODE_P3_PLLTESTMODE_P3 ,It is required to use default values for this CSR unless directed otherwise by Synopsys. Directly connected to testmode[15:0] pin of PLL RESET:0x124"
          
group.long  0x198++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PLLCTRL4_P3, This csr is to be programmed by bios or other means to set PLL charge-pump settings in various PStates. Refer to Technology specific PHY Databook for control setting programming. RESET:0x17f"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PLLCTRL4_P3_PLLCPINTGSCTRL ,connects directly to cp_int_gs_cntrl<4:0> in PLL. Charge pump integrating current control for fast relock and gearshift. RESET:0x1f"
          
         hexmask.long 0x00 5.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_PLLCTRL4_P3_PLLCPPROPGSCTRL ,connects directly to cp_prop_gs_cntrl<3:0> of PLL. Charge pump proportional current control for fast relock and gearshift. RESET:0xb"
          
group.long  0x1f4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DFIFREQRATIO_P3, DFI Frequency Ratio RESET:0x1"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P3_DFIFREQRATIO_P3_DFIFREQRATIO_P3 ,Specifies the ratio DfiCtlClk:MemClk.  - 00 = 1:1 mode  - 01 = 1:2 mode  - 1x = 1:4 mode When DWC_DDRPHY_FIXED_DFICTLCLK_RATIO is defined, this register is ignored and 1:2 mode is selected. RESET:0x1"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_ACSM0_P3"
base e:0x42680000
width 80.
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X0_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X0_P3_ACSMPLAYBACK0X0_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X0_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X0_P3_ACSMPLAYBACK1X0_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x104++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X1_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X1_P3_ACSMPLAYBACK0X1_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x106++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X1_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X1_P3_ACSMPLAYBACK1X1_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x108++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X2_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X2_P3_ACSMPLAYBACK0X2_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x10a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X2_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X2_P3_ACSMPLAYBACK1X2_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x10c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X3_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X3_P3_ACSMPLAYBACK0X3_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x10e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X3_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X3_P3_ACSMPLAYBACK1X3_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x110++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X4_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X4_P3_ACSMPLAYBACK0X4_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x112++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X4_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X4_P3_ACSMPLAYBACK1X4_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x114++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X5_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X5_P3_ACSMPLAYBACK0X5_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x116++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X5_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X5_P3_ACSMPLAYBACK1X5_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x118++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X6_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X6_P3_ACSMPLAYBACK0X6_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x11a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X6_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X6_P3_ACSMPLAYBACK1X6_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x11c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X7_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK0X7_P3_ACSMPLAYBACK0X7_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x11e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X7_P3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P3_ACSMPLAYBACK1X7_P3_ACSMPLAYBACK1X7_P3 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
tree.end

tree "LPDDR4_PUB__DWC_DDRPHYA_INITENG0_P3"
base e:0x42720000
width 80.
group.long  0x402++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR1_P3, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR1_P3_SEQ0BGPR1_P3 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x404++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR2_P3, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR2_P3_SEQ0BGPR2_P3 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x406++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR3_P3, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR3_P3_SEQ0BGPR3_P3 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x408++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR4_P3, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR4_P3_SEQ0BGPR4_P3 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x40a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR5_P3, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR5_P3_SEQ0BGPR5_P3 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x40c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR6_P3, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR6_P3_SEQ0BGPR6_P3 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x40e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR7_P3, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR7_P3_SEQ0BGPR7_P3 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x410++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR8_P3, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P3_SEQ0BGPR8_P3_SEQ0BGPR8_P3 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
tree.end

tree "DDRRAM2"
base e:0x60000000
width 80.
tree.end
