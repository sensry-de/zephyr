    line.long 0x00 "ETH_PHY2_VENDOR_AUTONEG_AUTONEG_RX_TRANSLATION_THRESHOLD_ENABLE, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_VENDOR_AUTONEG_AUTONEG_RX_TRANSLATION_THRESHOLD_ENABLE_SLOPE_THRESHOLD_EN ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "ETH_PHY2_VENDOR_AUTONEG_AUTONEG_RX_TRANSLATION_THRESHOLD_CONFIG, None RESET:0x2d061416"
         hexmask.long 0x00 0.--7. 1. " ETH_PHY2_VENDOR_AUTONEG_AUTONEG_RX_TRANSLATION_THRESHOLD_CONFIG_QUIET_THRESHOLD_CNT ,None RESET:0x16"
          
         hexmask.long 0x00 8.--15. 1. " ETH_PHY2_VENDOR_AUTONEG_AUTONEG_RX_TRANSLATION_THRESHOLD_CONFIG_QUIET_THRESHOLD ,None RESET:0x14"
          
         hexmask.long 0x00 16.--23. 1. " ETH_PHY2_VENDOR_AUTONEG_AUTONEG_RX_TRANSLATION_THRESHOLD_CONFIG_SLOPE_THRESHOLD ,None RESET:0x6"
          
         hexmask.long 0x00 24.--31. 1. " ETH_PHY2_VENDOR_AUTONEG_AUTONEG_RX_TRANSLATION_THRESHOLD_CONFIG_TRANSITION_THRESHOLD ,None RESET:0x2d"
          
group.long  0x1c++0x3
    line.long 0x00 "ETH_PHY2_VENDOR_AUTONEG_AUTONEG_MR_NEXT_PAGE_LOADED, None RESET:0x0"
         bitfld.long 0x00 0. " ETH_PHY2_VENDOR_AUTONEG_AUTONEG_MR_NEXT_PAGE_LOADED_MR_NEXT_PAGE_LOADED ,None RESET:0x0"
          
tree.end

tree "ETHERNET_REG"
base e:0x400f8000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETHERNET_REG_TSN_SW_TX_RX_RST_N, TSN-SW TX/RX resets RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " ETHERNET_REG_TSN_SW_TX_RX_RST_N_TSN_SW_TX_RST_N ,Resets the tsn-sw tx port RESET:0x0"
          
         hexmask.long 0x00 3.--5. 1. " ETHERNET_REG_TSN_SW_TX_RX_RST_N_TSN_SW_RX_RST_N ,Resets the tsn-sw rx port RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "ETHERNET_REG_TSN_SW_STATUS, TSN-SW status signals RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_TSN_SW_STATUS_CLKSEL ,GMII clock selection and clock divider setting RESET:0x0"
          
         hexmask.long 0x00 1.--3. 1. " ETHERNET_REG_TSN_SW_STATUS_TSN_SW_TX_GMIIMODE ,MAC GMII mode (1 for 1G, 0 for 100M) RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " ETHERNET_REG_TSN_SW_STATUS_TSN_SW_RX_GMIIMODE ,MAC GMII mode (1 for 1G, 0 for 100M) RESET:0x0"
          
         bitfld.long 0x00 7. " ETHERNET_REG_TSN_SW_STATUS_PPS ,RTC pulse per second (debug only) RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_RESCAL_MIRROR_RREF, Resistor calibration current mirror direction select RESET:0x1"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_RESCAL_MIRROR_RREF_MIRROR_RREF ,Should be set to 0 according to docs (in si test is 1) RESET:0x1"
          
group.long  0xc++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_RESCAL_CURRENT_EN, Resistor calibration current enable RESET:0x1"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_RESCAL_CURRENT_EN_CURRENT_EN ,Should be set to 0 according to docs - in tb of siliconally it is 1 RESET:0x1"
          
group.long  0x10++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY1_CRC_I, CRC check of config registers is started by setting crc_check_trigger_i to 1 RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY1_CRC_I_CRC_CHECK_TRIGGER ,CRC check trigger for config registers RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY1_CRC_O, Active 1 as long as register CRC check is executing RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY1_CRC_O_CRC_CHECK_ACTIVE ,Logic 1 when CRC register check active RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_CTRL_PHY1_CRC_O_LINK_STATUS ,Provides PHY link status RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_CTRL_PHY1_CRC_O_COMM_READY ,Provides PHY comm ready status value RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY1_SLEEP_I, Sleep/wakeup input signals RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY1_SLEEP_I_SLEEP_ABORT_REQ ,Abort initiated sleep request RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_CTRL_PHY1_SLEEP_I_WAKEUP_REQ ,Wakeup request to leave deep sleep state RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_CTRL_PHY1_SLEEP_I_SLEEP_REQ ,Sleep request to enter deep sleep state RESET:0x0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY1_SLEEP_O, Sleep/wakeup output pins RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY1_SLEEP_O_INHIBIT ,Inhibit indicator, when it is 0, then power switched power domains are turned off and the externally regulated ZBB can be switched off RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_CTRL_PHY1_SLEEP_O_WAKEUP_INDICATOR ,Wakeup indicator after sleep RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_CTRL_PHY1_SLEEP_O_SLEEP_INDICATOR ,Sleep indicator after sleep state RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_REG_CTRL_PHY1_SLEEP_O_SLEEP_FAIL_INDICATOR ,Sleep fail indicator while entering sleep state RESET:0x0"
          
         bitfld.long 0x00 4. " ETHERNET_REG_CTRL_PHY1_SLEEP_O_WUR ,Wakeup request RESET:0x0"
          
         bitfld.long 0x00 5. " ETHERNET_REG_CTRL_PHY1_SLEEP_O_PHY_SWITCH_OFF_SLEEP ,Indication from PHY to switch off because of sleep RESET:0x0"
          
         bitfld.long 0x00 6. " ETHERNET_REG_CTRL_PHY1_SLEEP_O_PHY_SWITCH_OFF_DISABLE ,Indication from PHY to switch off because of disable RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY1_STRAP_I, Strap input pins RESET:0x17"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY1_STRAP_I_STRAP_MASTER ,Select PHY mode: 0 -> slave, 1 -> master RESET:0x1"
          
         hexmask.long 0x00 1.--2. 1. " ETHERNET_REG_CTRL_PHY1_STRAP_I_STRAP_REF_CLK_FREQ ,Select reference clock frequency: 00 -> 100 MHz, 01 -> 50 MHz, 10 -> reserved, 11 -> 25 MHz RESET:0x3"
          
         bitfld.long 0x00 3. " ETHERNET_REG_CTRL_PHY1_STRAP_I_STRAP_SINGLE_PHY ,Set to 1 when only 1 PHY is instantiated, otherwise 0 RESET:0x0"
          
         hexmask.long 0x00 4.--5. 1. " ETHERNET_REG_CTRL_PHY1_STRAP_I_STRAP_DFT_REF_CLK_FREQ ,Selects the clock frequency for at-scan speed RESET:0x1"
          
         bitfld.long 0x00 6. " ETHERNET_REG_CTRL_PHY1_STRAP_I_STRAP_AUTO_INIT ,PHY autonomous initialization without writing to any register RESET:0x0"
          
         hexmask.long 0x00 7.--12. 1. " ETHERNET_REG_CTRL_PHY1_STRAP_I_STRAP_DEV_ID_MODEL ,Sets the values for read-only registers based on a certain mapping RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " ETHERNET_REG_CTRL_PHY1_STRAP_I_STRAP_DEV_ID_REVISION ,Sets the valies for read-only registers based on a certain mapping RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY1_PHY_SIGNALS_I, Pins starting with phy* RESET:0x6"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY1_PHY_SIGNALS_I_PHY_PT_MODE_EN ,Enable PHY production test mode RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_CTRL_PHY1_PHY_SIGNALS_I_PHY_REF_BUF_PD_N ,Reference clock buffer power down switch, setting to 0 powers down reference clock buffer RESET:0x1"
          
         bitfld.long 0x00 2. " ETHERNET_REG_CTRL_PHY1_PHY_SIGNALS_I_PHY_TX_DISABLE_N ,Energency PHY TX disable RESET:0x1"
          
rgroup.long 0x28++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY1_PHY_SIGNALS_O, Indicates whether PHY is ready for APB transactions RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY1_PHY_SIGNALS_O_PHY_REGFILE_READY ,When set, indicates whether regfile is ready for APB transactions RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY1_BOOT_CONTROL_INTERFACE_I, PHY boot control interface RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY1_BOOT_CONTROL_INTERFACE_I_PHY_DISABLE ,Full PHY disable (into disable mode) RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_CTRL_PHY1_BOOT_CONTROL_INTERFACE_I_LOC_WAKE ,Local wake-up indication RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_CTRL_PHY1_BOOT_CONTROL_INTERFACE_I_REM_WAKE ,Remote wakeup indication RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY1_STRAP_DEV_ID_OUI_I, Strap signal with 22 bits RESET:0x0"
         hexmask.long 0x00 0.--21. 1. " ETHERNET_REG_CTRL_PHY1_STRAP_DEV_ID_OUI_I_STRAP_DEV_ID_OUI ,Set the value for read-only device identifier related registers based on a certain mapping RESET:0x0"
          
rgroup.long 0x34++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY1_FRAMEINDICATOR_O, Frame indicators RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY1_FRAMEINDICATOR_O_TXPCS_SMD_INDICATOR ,Whenever PHY transmits preemtion SMD frame, a pulse is flagged RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_CTRL_PHY1_FRAMEINDICATOR_O_RXPCS_SMD_INDICATOR ,Whenever PHY receives preemtion SMD frame, a pulse is flagged RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_CTRL_PHY1_FRAMEINDICATOR_O_TXPCS_SFD_INDICATOR ,TX PCS start of frame deliminater indicator RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_REG_CTRL_PHY1_FRAMEINDICATOR_O_RXPCS_SFD_INDICATOR ,RX PCS start of frame deliminater indicator RESET:0x0"
          
         bitfld.long 0x00 4. " ETHERNET_REG_CTRL_PHY1_FRAMEINDICATOR_O_TXPCS_4B3B_ALIGN_INDICATOR ,TX PCS 4b3b clocks aligned indicator RESET:0x0"
          
         bitfld.long 0x00 5. " ETHERNET_REG_CTRL_PHY1_FRAMEINDICATOR_O_RXPCS_3B4B_ALIGN_INDICATOR ,RX PCS 4b3b clocks aligned indicator RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY2_CRC_I, CRC check of config registers is started by setting crc_check_trigger_i to 1 RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY2_CRC_I_CRC_CHECK_TRIGGER ,CRC check trigger for config registers RESET:0x0"
          
rgroup.long 0x3c++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY2_CRC_O, Active 1 as long as register CRC check is executing RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY2_CRC_O_CRC_CHECK_ACTIVE ,Logic 1 when CRC register check active RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_CTRL_PHY2_CRC_O_LINK_STATUS ,Provides PHY link status RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_CTRL_PHY2_CRC_O_COMM_READY ,Provides PHY comm ready status value RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY2_SLEEP_I, Sleep/wakeup input signals RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY2_SLEEP_I_SLEEP_ABORT_REQ ,Abort initiated sleep request RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_CTRL_PHY2_SLEEP_I_WAKEUP_REQ ,Wakeup request to leave deep sleep state RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_CTRL_PHY2_SLEEP_I_SLEEP_REQ ,Sleep request to enter deep sleep state RESET:0x0"
          
rgroup.long 0x44++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY2_SLEEP_O, Sleep/wakeup output pins RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY2_SLEEP_O_INHIBIT ,Inhibit indicator, when it is 0, then power switched power domains are turned off and the externally regulated ZBB can be switched off RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_CTRL_PHY2_SLEEP_O_WAKEUP_INDICATOR ,Wakeup indicator after sleep RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_CTRL_PHY2_SLEEP_O_SLEEP_INDICATOR ,Sleep indicator after sleep state RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_REG_CTRL_PHY2_SLEEP_O_SLEEP_FAIL_INDICATOR ,Sleep fail indicator while entering sleep state RESET:0x0"
          
         bitfld.long 0x00 4. " ETHERNET_REG_CTRL_PHY2_SLEEP_O_WUR ,Wakeup request RESET:0x0"
          
         bitfld.long 0x00 5. " ETHERNET_REG_CTRL_PHY2_SLEEP_O_PHY_SWITCH_OFF_SLEEP ,Indication from PHY to switch off because of sleep RESET:0x0"
          
         bitfld.long 0x00 6. " ETHERNET_REG_CTRL_PHY2_SLEEP_O_PHY_SWITCH_OFF_DISABLE ,Indication from PHY to switch off because of disable RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY2_PHY_SIGNALS_I, Pins starting with phy* RESET:0x6"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY2_PHY_SIGNALS_I_PHY_PT_MODE_EN ,Enable PHY production test mode RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_CTRL_PHY2_PHY_SIGNALS_I_PHY_REF_BUF_PD_N ,Reference clock buffer power down switch, setting to 0 powers down reference clock buffer RESET:0x1"
          
         bitfld.long 0x00 2. " ETHERNET_REG_CTRL_PHY2_PHY_SIGNALS_I_PHY_TX_DISABLE_N ,Energency PHY TX disable RESET:0x1"
          
rgroup.long 0x4c++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY2_PHY_SIGNALS_O, Indicates whether PHY is ready for APB transactions RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY2_PHY_SIGNALS_O_PHY_REGFILE_READY ,When set, indicates whether regfile is ready for APB transactions RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY2_BOOT_CONTROL_INTERFACE_I, PHY boot control interface RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY2_BOOT_CONTROL_INTERFACE_I_PHY_DISABLE ,Full PHY disable (into disable mode) RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_CTRL_PHY2_BOOT_CONTROL_INTERFACE_I_LOC_WAKE ,Local wake-up indication RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_CTRL_PHY2_BOOT_CONTROL_INTERFACE_I_REM_WAKE ,Remote wakeup indication RESET:0x0"
          
group.long  0x54++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY2_STRAP_I, Strap input pins RESET:0x17"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY2_STRAP_I_STRAP_MASTER ,Select PHY mode: 0 -> slave, 1 -> master RESET:0x1"
          
         hexmask.long 0x00 1.--2. 1. " ETHERNET_REG_CTRL_PHY2_STRAP_I_STRAP_REF_CLK_FREQ ,Select reference clock frequency: 00 -> 100 MHz, 01 -> 50 MHz, 10 -> reserved, 11 -> 25 MHz RESET:0x3"
          
         bitfld.long 0x00 3. " ETHERNET_REG_CTRL_PHY2_STRAP_I_STRAP_SINGLE_PHY ,Set to 1 when only 1 PHY is instantiated, otherwise 0 RESET:0x0"
          
         hexmask.long 0x00 4.--5. 1. " ETHERNET_REG_CTRL_PHY2_STRAP_I_STRAP_DFT_REF_CLK_FREQ ,Selects the clock frequency for at-scan speed RESET:0x1"
          
         bitfld.long 0x00 6. " ETHERNET_REG_CTRL_PHY2_STRAP_I_STRAP_AUTO_INIT ,PHY autonomous initialization without writing to any register RESET:0x0"
          
         hexmask.long 0x00 7.--12. 1. " ETHERNET_REG_CTRL_PHY2_STRAP_I_STRAP_DEV_ID_MODEL ,Sets the values for read-only registers based on a certain mapping RESET:0x0"
          
         hexmask.long 0x00 13.--16. 1. " ETHERNET_REG_CTRL_PHY2_STRAP_I_STRAP_DEV_ID_REVISION ,Sets the valies for read-only registers based on a certain mapping RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY2_STRAP_DEV_ID_OUI_I, Strap signal with 22 bits RESET:0x0"
         hexmask.long 0x00 0.--21. 1. " ETHERNET_REG_CTRL_PHY2_STRAP_DEV_ID_OUI_I_STRAP_DEV_ID_OUI ,Set the value for read-only device identifier related registers based on a certain mapping RESET:0x0"
          
rgroup.long 0x5c++0x3
    line.long 0x00 "ETHERNET_REG_CTRL_PHY2_FRAMEINDICATOR_O, Frame indicators RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_CTRL_PHY2_FRAMEINDICATOR_O_TXPCS_SMD_INDICATOR ,Whenever PHY transmits preemtion SMD frame, a pulse is flagged RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_CTRL_PHY2_FRAMEINDICATOR_O_RXPCS_SMD_INDICATOR ,Whenever PHY receives preemtion SMD frame, a pulse is flagged RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_CTRL_PHY2_FRAMEINDICATOR_O_TXPCS_SFD_INDICATOR ,TX PCS start of frame deliminater indicator RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_REG_CTRL_PHY2_FRAMEINDICATOR_O_RXPCS_SFD_INDICATOR ,RX PCS start of frame deliminater indicator RESET:0x0"
          
         bitfld.long 0x00 4. " ETHERNET_REG_CTRL_PHY2_FRAMEINDICATOR_O_TXPCS_4B3B_ALIGN_INDICATOR ,TX PCS 4b3b clocks aligned indicator RESET:0x0"
          
         bitfld.long 0x00 5. " ETHERNET_REG_CTRL_PHY2_FRAMEINDICATOR_O_RXPCS_3B4B_ALIGN_INDICATOR ,RX PCS 4b3b clocks aligned indicator RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "ETHERNET_REG_SW_RESET, Ethernet software resets RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_SW_RESET_SGMII_N ,SW trigger for reset_sgmii_n RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_SW_RESET_RESCAL_ARBITER ,SW trigger for reset_rescal_arbiter_n RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_SW_RESET_ETHPHY_1 ,SW trigger for reset_ethphy_1 RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_REG_SW_RESET_ETHPHY_2 ,SW trigger for reset_ethphy_2 RESET:0x0"
          
         bitfld.long 0x00 4. " ETHERNET_REG_SW_RESET_DBG_RESCAL_RESET_PHY1 ,SW trigger for active HIGH reset dbg_rescal_reset_phy1. This will be use only in case that see a problem in the ecmt1_rescal_ctrl and to reset it properly. RESET:0x0"
          
         bitfld.long 0x00 5. " ETHERNET_REG_SW_RESET_DBG_RESCAL_RESET_PHY2 ,SW trigger for active HIGH reset dbg_rescal_reset_phy2. This will be use only in case that see a problem in the ecmt1_rescal_ctrl and to reset it properly. RESET:0x0"
          
         bitfld.long 0x00 6. " ETHERNET_REG_SW_RESET_ETHERNET ,SW trigger for reset_ethernet_n RESET:0x0"
          
         bitfld.long 0x00 7. " ETHERNET_REG_SW_RESET_REF_FBIST ,SW trigger for reset_ref_fbist_n RESET:0x0"
          
tree.end

tree "ETHERNET_REG__WDMA"
base e:0x400f8080
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETHERNET_REG_WDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " ETHERNET_REG_WDMA_CTRL_ENABLE ,Global enable for the WDMA RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_WDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next write will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " ETHERNET_REG_WDMA_CTRL_ADDR_DECREMENT ,When = 1, address is decremented in the AXI master RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_REG_WDMA_CTRL_CONT_MODE ,Enables continuous mode if set to 1, transmission is finalized, if HW signals last access RESET:0x0"
          
         bitfld.long 0x00 4. " ETHERNET_REG_WDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 5.--12. 1. " ETHERNET_REG_WDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETHERNET_REG_WDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETHERNET_REG_WDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " ETHERNET_REG_WDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "ETHERNET_REG_WDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETHERNET_REG_WDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " ETHERNET_REG_WDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETHERNET_REG_WDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHERNET_REG_WDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ETHERNET_REG_WDMA_SIZE1, SIZE1 interrupt triggers in case buffer is filled with size1 byte / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHERNET_REG_WDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETHERNET_REG_WDMA_CURR_ADDR, the current address of the DMA write pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHERNET_REG_WDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "ETHERNET_REG_WDMA_IRQ_STATUS, interrupt status bits / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_WDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_WDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_WDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_REG_WDMA_IRQ_STATUS_OVFL ,Overflow: data from AXI-4S is coming too fast to be written to the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "ETHERNET_REG_WDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_WDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_WDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_WDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_REG_WDMA_IRQ_STATUS_ENABLE_OVFL ,Enable interrupt ovfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "ETHERNET_REG_WDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to force an interrupt event (used for Software debugging or integration testing) RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_WDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize for one cycle RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_WDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 for one cycle RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_WDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr for one cycle RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_REG_WDMA_IRQ_STATUS_SET_OVFL ,Set interrupt ovfl for one cycle RESET:0x0"
          
tree.end

tree "ETHERNET_REG__RDMA"
base e:0x400f80c0
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETHERNET_REG_RDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " ETHERNET_REG_RDMA_CTRL_ENABLE ,Global enable for the RDMA RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_RDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next read will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " ETHERNET_REG_RDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " ETHERNET_REG_RDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
         bitfld.long 0x00 11. " ETHERNET_REG_RDMA_CTRL_TERMINATE ,Manual termination of stream, concludes transaction and sends tlast. Self-clearing RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETHERNET_REG_RDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETHERNET_REG_RDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " ETHERNET_REG_RDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "ETHERNET_REG_RDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " ETHERNET_REG_RDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " ETHERNET_REG_RDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETHERNET_REG_RDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHERNET_REG_RDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ETHERNET_REG_RDMA_SIZE1, SIZE1 interrupt triggers in case size1 byte have been read from the buffer / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHERNET_REG_RDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ETHERNET_REG_RDMA_CURR_ADDR, the current address of the DMA read pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHERNET_REG_RDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "ETHERNET_REG_RDMA_IRQ_STATUS, interrupt status bits reflect the occurrence of an event / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_RDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_RDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_RDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_REG_RDMA_IRQ_STATUS_UNFL ,Underflow: data towards AXI-4S is consumed faster than the DMA is able to read data from the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "ETHERNET_REG_RDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_RDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_RDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_RDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_REG_RDMA_IRQ_STATUS_ENABLE_UNFL ,Enable interrupt unfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "ETHERNET_REG_RDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev) RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_REG_RDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_REG_RDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_REG_RDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_REG_RDMA_IRQ_STATUS_SET_UNFL ,Set interrupt unfl RESET:0x0"
          
tree.end

tree "MALIC55"
base e:0x40100000
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_ISP_COMMON"
base e:0x40100000
width 80.
rgroup.long 0x4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ID_REGISTER_0, ID_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ID_REGISTER_0_PRODUCT ,PRODUCT RESET:0x0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ID_REGISTER_1, ID_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ID_REGISTER_1_VERSION ,VERSION RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ID_REGISTER_2, ID_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ID_REGISTER_2_REVISION ,REVISION RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_0, ISP_GLOBAL_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_0_GLOBAL_FSM_RESET ,GLOBAL_FSM_RESET RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_0_FR_SCALER_FSM_RESET ,FR_SCALER_FSM_RESET RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_0_DS_SCALER_FSM_RESET ,DS_SCALER_FSM_RESET RESET:0x0"
          
          
         hexmask.long 0x00 4.--30. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_0_DMA_GLOBAL_CONFIG ,DMA_GLOBAL_CONFIG RESET:0x0"
          
          
group.long  0x14++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_1, ISP_GLOBAL_REGISTER_1 RESET:0x1040020"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_1_FLUSH_HBLANK ,FLUSH_HBLANK RESET:0x20"
          
         hexmask.long 0x00 16.--18. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_1_ISP_MONITOR_SELECT ,ISP_MONITOR_SELECT RESET:0x4"
          
          
         bitfld.long 0x00 24. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_1_RECOVERY_MODE ,RECOVERY_MODE RESET:0x1"
          
          
group.long  0x18++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_2, ISP_GLOBAL_REGISTER_2 RESET:0x280020"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_2_INTERLINE_BLANKS_MIN ,INTERLINE_BLANKS_MIN RESET:0x20"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_2_INTERFRAME_BLANKS_MIN ,INTERFRAME_BLANKS_MIN RESET:0x28"
          
group.long  0x1c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_3, ISP_GLOBAL_REGISTER_3 RESET:0xffffffff"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_3_WATCHDOG_TIMER_MAX_COUNT ,WATCHDOG_TIMER_MAX_COUNT RESET:0xffffffff"
          
group.long  0x20++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_4, ISP_GLOBAL_REGISTER_4 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_4_MCU_OVERRIDE_CONFIG_SELECT ,MCU_OVERRIDE_CONFIG_SELECT RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_4_MCU_PING_PONG_CONFIG_SELECT ,MCU_PING_PONG_CONFIG_SELECT RESET:0x0"
          
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_4_MULTI_CONTEXT_MODE ,MULTI_CONTEXT_MODE RESET:0x0"
          
          
group.long  0x24++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_5, ISP_GLOBAL_REGISTER_5 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_5_PING_LOCKED ,PING_LOCKED RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_5_PONG_LOCKED ,PONG_LOCKED RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_REGISTER_5_PING_PONG_CONFIG_SELECT ,PING_PONG_CONFIG_SELECT RESET:0x0"
          
          
group.long  0x28++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_METERING_BASE_ADDR_REGISTER_0, ISP_GLOBAL_METERING_BASE_ADDR_REGISTER_0 RESET:0x3a001d0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_METERING_BASE_ADDR_REGISTER_0_AWB ,AWB RESET:0x1d0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_METERING_BASE_ADDR_REGISTER_0_AF ,AF RESET:0x3a0"
          
group.long  0x30++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_INTERRUPT_REGISTER_0, ISP_GLOBAL_INTERRUPT_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_INTERRUPT_REGISTER_0_MASK_VECTOR ,MASK_VECTOR RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_INTERRUPT_REGISTER_1, ISP_GLOBAL_INTERRUPT_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_INTERRUPT_REGISTER_1_CLEAR_VECTOR ,CLEAR_VECTOR RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_INTERRUPT_REGISTER_2, ISP_GLOBAL_INTERRUPT_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_INTERRUPT_REGISTER_2_SHADOW_DISABLE_VECTOR ,SHADOW_DISABLE_VECTOR RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_INTERRUPT_REGISTER_3, ISP_GLOBAL_INTERRUPT_REGISTER_3 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_INTERRUPT_REGISTER_3_PULSE_MODE ,PULSE_MODE RESET:0x0"
          
          
group.long  0x40++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_INTERRUPT_REGISTER_4, ISP_GLOBAL_INTERRUPT_REGISTER_4 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_INTERRUPT_REGISTER_4_CLEAR ,CLEAR RESET:0x0"
          
          
rgroup.long 0x44++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_INTERRUPT_REGISTER_5, ISP_GLOBAL_INTERRUPT_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_INTERRUPT_REGISTER_5_STATUS_VECTOR ,STATUS_VECTOR RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_LP_REGISTER_0, ISP_GLOBAL_LP_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_LP_REGISTER_0_CG_DIS_FRAME_STITCH ,CG_DIS_FRAME_STITCH RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_LP_REGISTER_0_CG_DIS_RAW_FRONTEND ,CG_DIS_RAW_FRONTEND RESET:0x0"
          
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_LP_REGISTER_0_CG_DIS_SINTER ,CG_DIS_SINTER RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_LP_REGISTER_0_CG_DIS_TEMPER ,CG_DIS_TEMPER RESET:0x0"
          
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_LP_REGISTER_0_CG_DIS_MESH_SHADING ,CG_DIS_MESH_SHADING RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_LP_REGISTER_0_CG_DIS_IRIDIX ,CG_DIS_IRIDIX RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_LP_REGISTER_0_CG_DIS_DEMOSAIC_RGGB ,CG_DIS_DEMOSAIC_RGGB RESET:0x0"
          
          
         bitfld.long 0x00 11. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_LP_REGISTER_0_CG_DIS_PF_CORRECTION ,CG_DIS_PF_CORRECTION RESET:0x0"
          
         bitfld.long 0x00 12. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_LP_REGISTER_0_CG_DIS_CNR ,CG_DIS_CNR RESET:0x0"
          
         bitfld.long 0x00 13. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_LP_REGISTER_0_CG_DIS_RGB_SCALER_FR ,CG_DIS_RGB_SCALER_FR RESET:0x0"
          
         bitfld.long 0x00 14. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_LP_REGISTER_0_CG_DIS_RGB_SCALER_DS ,CG_DIS_RGB_SCALER_DS RESET:0x0"
          
          
         bitfld.long 0x00 17. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_LP_REGISTER_0_CG_DIS_SHARPEN_FR ,CG_DIS_SHARPEN_FR RESET:0x0"
          
         bitfld.long 0x00 18. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_LP_REGISTER_0_CG_DIS_SHARPEN_DS ,CG_DIS_SHARPEN_DS RESET:0x0"
          
          
group.long  0x50++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_0, ISP_GLOBAL_MONITOR_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_0_BROKEN_FRAME_STATUS ,BROKEN_FRAME_STATUS RESET:0x0"
          
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_0_GLOBAL_FSM_RST_STATUS ,GLOBAL_FSM_RST_STATUS RESET:0x0"
          
          
         bitfld.long 0x00 16. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_0_MAIN_PIPELINE_BUSY ,MAIN_PIPELINE_BUSY RESET:0x0"
          
          
         bitfld.long 0x00 24. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_0_ISP_BUSY ,ISP_BUSY RESET:0x0"
          
          
group.long  0x54++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_1, ISP_GLOBAL_MONITOR_REGISTER_1 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_1_FR_Y_DMA_WFIFO_FAIL_FULL ,FR_Y_DMA_WFIFO_FAIL_FULL RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_1_FR_Y_DMA_WFIFO_FAIL_EMPTY ,FR_Y_DMA_WFIFO_FAIL_EMPTY RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_1_FR_UV_DMA_WFIFO_FAIL_FULL ,FR_UV_DMA_WFIFO_FAIL_FULL RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_1_FR_UV_DMA_WFIFO_FAIL_EMPTY ,FR_UV_DMA_WFIFO_FAIL_EMPTY RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_1_DS_Y_DMA_WFIFO_FAIL_FULL ,DS_Y_DMA_WFIFO_FAIL_FULL RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_1_DS_Y_DMA_WFIFO_FAIL_EMPTY ,DS_Y_DMA_WFIFO_FAIL_EMPTY RESET:0x0"
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_1_DS_UV_DMA_WFIFO_FAIL_FULL ,DS_UV_DMA_WFIFO_FAIL_FULL RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_1_DS_UV_DMA_WFIFO_FAIL_EMPTY ,DS_UV_DMA_WFIFO_FAIL_EMPTY RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_1_TEMPER_DMA_WFIFO_FAIL_EMPTY ,TEMPER_DMA_WFIFO_FAIL_EMPTY RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_1_TEMPER_DMA_WFIFO_FAIL_FULL ,TEMPER_DMA_WFIFO_FAIL_FULL RESET:0x0"
          
         bitfld.long 0x00 10. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_1_TEMPER_DMA_RFIFO_FAIL_EMPTY ,TEMPER_DMA_RFIFO_FAIL_EMPTY RESET:0x0"
          
         bitfld.long 0x00 11. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_1_TEMPER_DMA_RFIFO_FAIL_FULL ,TEMPER_DMA_RFIFO_FAIL_FULL RESET:0x0"
          
          
         hexmask.long 0x00 16.--26. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_1_DMA_ALARMS ,DMA_ALARMS RESET:0x0"
          
          
group.long  0x58++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_2, ISP_GLOBAL_MONITOR_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_2_DS_SCALER_IRQSTAT ,DS_SCALER_IRQSTAT RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_2_FR_SCALER_IRQSTAT ,FR_SCALER_IRQSTAT RESET:0x0"
          
          
group.long  0x5c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_3, ISP_GLOBAL_MONITOR_REGISTER_3 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_3_BROKEN_FRAME_ERROR_CLEAR ,BROKEN_FRAME_ERROR_CLEAR RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_3_CONTEXT_ERROR_CLR ,CONTEXT_ERROR_CLR RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_3_OUTPUT_DMA_CLR_ALARM ,OUTPUT_DMA_CLR_ALARM RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_3_TEMPER_DMA_CLR_ALARM ,TEMPER_DMA_CLR_ALARM RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_3_DS_SCALER_CLEAR_ALARMS ,DS_SCALER_CLEAR_ALARMS RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_3_FR_SCALER_CLEAR_ALARMS ,FR_SCALER_CLEAR_ALARMS RESET:0x0"
          
          
rgroup.long 0x60++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_4, ISP_GLOBAL_MONITOR_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_4_MAX_ADDRESS_DELAY_LINE_FR ,MAX_ADDRESS_DELAY_LINE_FR RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_MONITOR_REGISTER_4_MAX_ADDRESS_DELAY_LINE_DS ,MAX_ADDRESS_DELAY_LINE_DS RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_SELECT_REGISTER_0, ISP_GLOBAL_SELECT_REGISTER_0 RESET:0x5"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_SELECT_REGISTER_0_FRAME_END_SELECT ,FRAME_END_SELECT RESET:0x1"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_SELECT_REGISTER_0_RD_START_SEL ,RD_START_SEL RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_SELECT_REGISTER_0_INPUT_ALIGNMENT ,INPUT_ALIGNMENT RESET:0x1"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_SELECT_REGISTER_0_WATCHDOG_TIMER_DIS ,WATCHDOG_TIMER_DIS RESET:0x0"
          
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_SELECT_REGISTER_0_DMA_WRITER_TIMEOUT_DISABLE ,DMA_WRITER_TIMEOUT_DISABLE RESET:0x0"
          
          
group.long  0x68++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_PARAMETER_STATUS_REGISTER_0, ISP_GLOBAL_PARAMETER_STATUS_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_PARAMETER_STATUS_REGISTER_0_PONG_CONFIG_FITTED ,PONG_CONFIG_FITTED RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_PARAMETER_STATUS_REGISTER_0_WDR_FITTED ,WDR_FITTED RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_PARAMETER_STATUS_REGISTER_0_COMPRESSION_FITTED ,COMPRESSION_FITTED RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_PARAMETER_STATUS_REGISTER_0_TEMPER_FITTED ,TEMPER_FITTED RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_PARAMETER_STATUS_REGISTER_0_SINTER_LITE ,SINTER_LITE RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_PARAMETER_STATUS_REGISTER_0_SINTER_FITTED ,SINTER_FITTED RESET:0x0"
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_PARAMETER_STATUS_REGISTER_0_IRIDIX_LTM_FITTED ,IRIDIX_LTM_FITTED RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_PARAMETER_STATUS_REGISTER_0_IRIDIX_GTM_FITTED ,IRIDIX_GTM_FITTED RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_PARAMETER_STATUS_REGISTER_0_CNR_FITTED ,CNR_FITTED RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_PARAMETER_STATUS_REGISTER_0_FRSCALER_FITTED ,FRSCALER_FITTED RESET:0x0"
          
         bitfld.long 0x00 10. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_PARAMETER_STATUS_REGISTER_0_DS_PIPE ,DS_PIPE RESET:0x0"
          
          
rgroup.long 0x6c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_PARAMETER_STATUS_REGISTER_1, ISP_GLOBAL_PARAMETER_STATUS_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_PARAMETER_STATUS_REGISTER_1_SCALER_COEF_SETS ,SCALER_COEF_SETS RESET:0x0"
          
group.long  0x70++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_DBG_REGISTER_0, ISP_GLOBAL_DBG_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_DBG_REGISTER_0_MODE_EN ,MODE_EN RESET:0x0"
          
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_DBG_REGISTER_0_CLEAR_FRAME_CNT ,CLEAR_FRAME_CNT RESET:0x0"
          
          
         bitfld.long 0x00 16. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_DBG_REGISTER_0_UNLOCK_CONFIG_SPACE ,UNLOCK_CONFIG_SPACE RESET:0x0"
          
          
rgroup.long 0x74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_DBG_REGISTER_1, ISP_GLOBAL_DBG_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_ISP_GLOBAL_DBG_REGISTER_1_FRAME_CNT ,FRAME_CNT RESET:0x0"
          
group.long  0x80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_0, INPUT_PORT_REGISTER_0 RESET:0x7d00000"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_0_GEN_VIDEO_ON ,GEN_VIDEO_ON RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_0_GEN_VIDEO_MULTI ,GEN_VIDEO_MULTI RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_0_GEN_PREFETCH ,GEN_PREFETCH RESET:0x7d0"
          
group.long  0x84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_1, INPUT_PORT_REGISTER_1 RESET:0x500020"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_1_GEN_HBLANK ,GEN_HBLANK RESET:0x20"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_1_GEN_VBLANK ,GEN_VBLANK RESET:0x50"
          
group.long  0x88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_2, INPUT_PORT_REGISTER_2 RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_2_HC_START0 ,HC_START0 RESET:0x0"
          
group.long  0x8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_3, INPUT_PORT_REGISTER_3 RESET:0xffff"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_3_HC_SIZE0 ,HC_SIZE0 RESET:0xffff"
          
          
group.long  0x94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_4, INPUT_PORT_REGISTER_4 RESET:0xffff0000"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_4_VC_START ,VC_START RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_4_VC_SIZE ,VC_SIZE RESET:0xffff"
          
rgroup.long 0x98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_5, INPUT_PORT_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_5_DET_FRAME_WIDTH ,DET_FRAME_WIDTH RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_5_DET_FRAME_HEIGHT ,DET_FRAME_HEIGHT RESET:0x0"
          
group.long  0x9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_6, INPUT_PORT_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_6_MODE_REQUEST ,MODE_REQUEST RESET:0x0"
          
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_6_FREEZE_CONFIG ,FREEZE_CONFIG RESET:0x0"
          
          
group.long  0xa0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_7, INPUT_PORT_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_COMMON_INPUT_PORT_REGISTER_7_MODE_STATUS ,MODE_STATUS RESET:0x0"
          
          
tree.end

tree "MALIC55__IP_CONFIG_TOP_CMD_QUEUES"
base e:0x40100108
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_DS_SCALER_HFILT_COEFMEM"
base e:0x401014a8
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_DS_SCALER_VFILT_COEFMEM"
base e:0x401024a8
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_FR_SCALER_HFILT_COEFMEM"
base e:0x401034a8
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_FR_SCALER_VFILT_COEFMEM"
base e:0x401044a8
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_AEXP_HIST_STATS_MEM"
base e:0x401054a8
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_IHIST_STATS_MEM"
base e:0x40105ca8
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_METERING_STATS_PING_MEM"
base e:0x401095ac
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_DECOMPANDER0_PING_MEM"
base e:0x4010ab6c
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_DECOMPANDER1_PING_MEM"
base e:0x4010abf0
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_MESH_SHADING_PING_MEM"
base e:0x40113074
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_FR_GAMMA_RGB_PING_MEM"
base e:0x40118280
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_DS_GAMMA_RGB_PING_MEM"
base e:0x40118484
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_ISP_CONFIG_PING"
base e:0x40118e88
width 80.
group.long  0x0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_0, TOP_REGISTER_0 RESET:0x4380780"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_0_ACTIVE_WIDTH ,ACTIVE_WIDTH RESET:0x780"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_0_ACTIVE_HEIGHT ,ACTIVE_HEIGHT RESET:0x438"
          
group.long  0x4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_1, TOP_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_1_RGGB_START ,RGGB_START RESET:0x0"
          
          
         hexmask.long 0x00 16.--17. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_1_CFA_PATTERN ,CFA_PATTERN RESET:0x0"
          
          
         hexmask.long 0x00 24.--25. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_1_LINEAR_DATA_SRC ,LINEAR_DATA_SRC RESET:0x0"
          
          
group.long  0x24++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_2, TOP_REGISTER_2 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_2_BYPASS_VIDEO_TEST_GEN ,BYPASS_VIDEO_TEST_GEN RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_2_BYPASS_INPUT_FORMATTER ,BYPASS_INPUT_FORMATTER RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_2_BYPASS_DECOMPANDER ,BYPASS_DECOMPANDER RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_2_BYPASS_SENSOR_OFFSET_WDR ,BYPASS_SENSOR_OFFSET_WDR RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_2_BYPASS_GAIN_WDR ,BYPASS_GAIN_WDR RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_2_BYPASS_FRAME_STITCH ,BYPASS_FRAME_STITCH RESET:0x0"
          
          
group.long  0x28++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_3, TOP_REGISTER_3 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_3_BYPASS_DIGITAL_GAIN ,BYPASS_DIGITAL_GAIN RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_3_BYPASS_FRONTEND_SENSOR_OFFSET ,BYPASS_FRONTEND_SENSOR_OFFSET RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_3_BYPASS_FE_SQRT ,BYPASS_FE_SQRT RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_3_BYPASS_RAW_FRONTEND ,BYPASS_RAW_FRONTEND RESET:0x0"
          
          
group.long  0x30++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_4, TOP_REGISTER_4 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_4_BYPASS_SINTER ,BYPASS_SINTER RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_4_BYPASS_TEMPER ,BYPASS_TEMPER RESET:0x0"
          
          
group.long  0x34++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_5, TOP_REGISTER_5 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_5_BYPASS_SQUARE_BE ,BYPASS_SQUARE_BE RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_5_BYPASS_SENSOR_OFFSET_PRE_SHADING ,BYPASS_SENSOR_OFFSET_PRE_SHADING RESET:0x0"
          
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_5_BYPASS_MESH_SHADING ,BYPASS_MESH_SHADING RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_5_BYPASS_WHITE_BALANCE ,BYPASS_WHITE_BALANCE RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_5_BYPASS_IRIDIX_GAIN ,BYPASS_IRIDIX_GAIN RESET:0x0"
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_5_BYPASS_IRIDIX ,BYPASS_IRIDIX RESET:0x0"
          
          
group.long  0x38++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_6, TOP_REGISTER_6 RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_6_BYPASS_DEMOSAIC_RGB ,BYPASS_DEMOSAIC_RGB RESET:0x0"
          
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_6_BYPASS_PF_CORRECTION ,BYPASS_PF_CORRECTION RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_6_BYPASS_CCM ,BYPASS_CCM RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_6_BYPASS_CNR ,BYPASS_CNR RESET:0x0"
          
          
group.long  0x3c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_7, TOP_REGISTER_7 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_7_BYPASS_FR_CROP ,BYPASS_FR_CROP RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_7_BYPASS_FR_SCALER ,BYPASS_FR_SCALER RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_7_BYPASS_FR_GAMMA_RGB ,BYPASS_FR_GAMMA_RGB RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_7_BYPASS_FR_SHARPEN ,BYPASS_FR_SHARPEN RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_7_BYPASS_FR_CS_CONV ,BYPASS_FR_CS_CONV RESET:0x0"
          
          
group.long  0x40++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_8, TOP_REGISTER_8 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_8_BYPASS_DS_CROP ,BYPASS_DS_CROP RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_8_BYPASS_DS_SCALER ,BYPASS_DS_SCALER RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_8_BYPASS_DS_GAMMA_RGB ,BYPASS_DS_GAMMA_RGB RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_8_BYPASS_DS_SHARPEN ,BYPASS_DS_SHARPEN RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_8_BYPASS_DS_CS_CONV ,BYPASS_DS_CS_CONV RESET:0x0"
          
          
group.long  0x44++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_9, TOP_REGISTER_9 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_9_ISP_RAW_BYPASS ,ISP_RAW_BYPASS RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_9_ISP_DOWNSCALE_PIPE_DISABLE ,ISP_DOWNSCALE_PIPE_DISABLE RESET:0x0"
          
          
         hexmask.long 0x00 8.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_9_ISP_PROCESSING_FR_BYPASS_MODE ,ISP_PROCESSING_FR_BYPASS_MODE RESET:0x0"
          
          
group.long  0x48++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_10, TOP_REGISTER_10 RESET:0x10020"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_10_AE_5BIN_HIST_DISABLE ,AE_5BIN_HIST_DISABLE RESET:0x0"
          
         hexmask.long 0x00 1.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_10_AE_SWITCH ,AE_SWITCH RESET:0x0"
          
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_10_AF_DISABLE ,AF_DISABLE RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_10_AF_SWITCH ,AF_SWITCH RESET:0x1"
          
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_10_AWB_DISABLE ,AWB_DISABLE RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_10_AWB_SWITCH ,AWB_SWITCH RESET:0x0"
          
          
         bitfld.long 0x00 12. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_10_AEXP_HIST_DISABLE ,AEXP_HIST_DISABLE RESET:0x0"
          
         hexmask.long 0x00 13.--14. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_10_AEXP_HISTOGRAM_SWITCH ,AEXP_HISTOGRAM_SWITCH RESET:0x0"
          
          
         bitfld.long 0x00 16. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_10_IHIST_DISABLE ,IHIST_DISABLE RESET:0x1"
          
          
         bitfld.long 0x00 24. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TOP_REGISTER_10_AEXP_SRC ,AEXP_SRC RESET:0x0"
          
          
group.long  0x4c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CROSSBAR_REGISTER_0, CROSSBAR_REGISTER_0 RESET:0x20100"
         hexmask.long 0x00 0.--1. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CROSSBAR_REGISTER_0_CHANNEL0_SELECT ,CHANNEL0_SELECT RESET:0x0"
          
          
         hexmask.long 0x00 8.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CROSSBAR_REGISTER_0_CHANNEL1_SELECT ,CHANNEL1_SELECT RESET:0x1"
          
          
         hexmask.long 0x00 16.--17. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CROSSBAR_REGISTER_0_CHANNEL2_SELECT ,CHANNEL2_SELECT RESET:0x2"
          
          
group.long  0x50++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_0, VIDEO_TEST_GEN_CH0_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_0_TEST_PATTERN_OFF_ON ,TEST_PATTERN_OFF_ON RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_0_BAYER_RGB_O_SEL ,BAYER_RGB_O_SEL RESET:0x0"
          
          
group.long  0x54++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_1, VIDEO_TEST_GEN_CH0_REGISTER_1 RESET:0x3"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_1_PATTERN_TYPE ,PATTERN_TYPE RESET:0x3"
          
          
group.long  0x58++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_2, VIDEO_TEST_GEN_CH0_REGISTER_2 RESET:0xffff"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_2_R_BACKGND ,R_BACKGND RESET:0xffff"
          
          
group.long  0x5c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_3, VIDEO_TEST_GEN_CH0_REGISTER_3 RESET:0xffff"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_3_G_BACKGND ,G_BACKGND RESET:0xffff"
          
          
group.long  0x60++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_4, VIDEO_TEST_GEN_CH0_REGISTER_4 RESET:0xffff"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_4_B_BACKGND ,B_BACKGND RESET:0xffff"
          
          
group.long  0x64++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_5, VIDEO_TEST_GEN_CH0_REGISTER_5 RESET:0x8fff"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_5_R_FOREGND ,R_FOREGND RESET:0x8fff"
          
          
group.long  0x68++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_6, VIDEO_TEST_GEN_CH0_REGISTER_6 RESET:0x8fff"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_6_G_FOREGND ,G_FOREGND RESET:0x8fff"
          
          
group.long  0x6c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_7, VIDEO_TEST_GEN_CH0_REGISTER_7 RESET:0x8fff"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_7_B_FOREGND ,B_FOREGND RESET:0x8fff"
          
          
group.long  0x70++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_8, VIDEO_TEST_GEN_CH0_REGISTER_8 RESET:0x3caa"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_8_RGB_GRADIENT ,RGB_GRADIENT RESET:0x3caa"
          
          
group.long  0x74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_9, VIDEO_TEST_GEN_CH0_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_9_RGB_GRADIENT_START ,RGB_GRADIENT_START RESET:0x0"
          
          
group.long  0x78++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_10, VIDEO_TEST_GEN_CH0_REGISTER_10 RESET:0x1000001"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_10_RECT_TOP ,RECT_TOP RESET:0x1"
          
          
         hexmask.long 0x00 16.--29. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_10_RECT_BOT ,RECT_BOT RESET:0x100"
          
          
group.long  0x7c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_11, VIDEO_TEST_GEN_CH0_REGISTER_11 RESET:0x1000001"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_11_RECT_LEFT ,RECT_LEFT RESET:0x1"
          
          
         hexmask.long 0x00 16.--29. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH0_REGISTER_11_RECT_RIGHT ,RECT_RIGHT RESET:0x100"
          
          
group.long  0x80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_0, VIDEO_TEST_GEN_CH1_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_0_TEST_PATTERN_OFF_ON ,TEST_PATTERN_OFF_ON RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_0_BAYER_RGB_O_SEL ,BAYER_RGB_O_SEL RESET:0x0"
          
          
group.long  0x84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_1, VIDEO_TEST_GEN_CH1_REGISTER_1 RESET:0x3"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_1_PATTERN_TYPE ,PATTERN_TYPE RESET:0x3"
          
          
group.long  0x88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_2, VIDEO_TEST_GEN_CH1_REGISTER_2 RESET:0xffff"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_2_R_BACKGND ,R_BACKGND RESET:0xffff"
          
          
group.long  0x8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_3, VIDEO_TEST_GEN_CH1_REGISTER_3 RESET:0xffff"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_3_G_BACKGND ,G_BACKGND RESET:0xffff"
          
          
group.long  0x90++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_4, VIDEO_TEST_GEN_CH1_REGISTER_4 RESET:0xffff"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_4_B_BACKGND ,B_BACKGND RESET:0xffff"
          
          
group.long  0x94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_5, VIDEO_TEST_GEN_CH1_REGISTER_5 RESET:0x8fff"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_5_R_FOREGND ,R_FOREGND RESET:0x8fff"
          
          
group.long  0x98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_6, VIDEO_TEST_GEN_CH1_REGISTER_6 RESET:0x8fff"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_6_G_FOREGND ,G_FOREGND RESET:0x8fff"
          
          
group.long  0x9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_7, VIDEO_TEST_GEN_CH1_REGISTER_7 RESET:0x8fff"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_7_B_FOREGND ,B_FOREGND RESET:0x8fff"
          
          
group.long  0xa0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_8, VIDEO_TEST_GEN_CH1_REGISTER_8 RESET:0x3caa"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_8_RGB_GRADIENT ,RGB_GRADIENT RESET:0x3caa"
          
          
group.long  0xa4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_9, VIDEO_TEST_GEN_CH1_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_9_RGB_GRADIENT_START ,RGB_GRADIENT_START RESET:0x0"
          
          
group.long  0xa8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_10, VIDEO_TEST_GEN_CH1_REGISTER_10 RESET:0x1000001"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_10_RECT_TOP ,RECT_TOP RESET:0x1"
          
          
         hexmask.long 0x00 16.--29. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_10_RECT_BOT ,RECT_BOT RESET:0x100"
          
          
group.long  0xac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_11, VIDEO_TEST_GEN_CH1_REGISTER_11 RESET:0x1000001"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_11_RECT_LEFT ,RECT_LEFT RESET:0x1"
          
          
         hexmask.long 0x00 16.--29. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_VIDEO_TEST_GEN_CH1_REGISTER_11_RECT_RIGHT ,RECT_RIGHT RESET:0x100"
          
          
group.long  0x110++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_0, INPUT_FORMATTER_REGISTER_0 RESET:0x20000"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_0_MODE_IN ,MODE_IN RESET:0x0"
          
          
         hexmask.long 0x00 16.--18. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_0_INPUT_BITWIDTH_SELECT ,INPUT_BITWIDTH_SELECT RESET:0x2"
          
          
group.long  0x114++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_1, INPUT_FORMATTER_REGISTER_1 RESET:0x1000"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_1_FACTOR_ML ,FACTOR_ML RESET:0x0"
          
          
group.long  0x118++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_2, INPUT_FORMATTER_REGISTER_2 RESET:0x1000"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_2_FACTOR_MS ,FACTOR_MS RESET:0x0"
          
          
group.long  0x11c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_3, INPUT_FORMATTER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_3_BLACK_LEVEL ,BLACK_LEVEL RESET:0x0"
          
          
group.long  0x120++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_4, INPUT_FORMATTER_REGISTER_4 RESET:0x5800200"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_4_KNEE_POINT0 ,KNEE_POINT0 RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_4_KNEE_POINT1 ,KNEE_POINT1 RESET:0x80"
          
          
group.long  0x124++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_5, INPUT_FORMATTER_REGISTER_5 RESET:0x881"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_5_KNEE_POINT2 ,KNEE_POINT2 RESET:0x81"
          
          
group.long  0x128++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_6, INPUT_FORMATTER_REGISTER_6 RESET:0x9060402"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_6_SLOPE0_SELECT ,SLOPE0_SELECT RESET:0x2"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_6_SLOPE1_SELECT ,SLOPE1_SELECT RESET:0x4"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_6_SLOPE2_SELECT ,SLOPE2_SELECT RESET:0x6"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_INPUT_FORMATTER_REGISTER_6_SLOPE3_SELECT ,SLOPE3_SELECT RESET:0x9"
          
          
group.long  0x13c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_WDR_L_REGISTER_0, SENSOR_OFFSET_WDR_L_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_WDR_L_REGISTER_0_OFFSET_00 ,OFFSET_00 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_WDR_L_REGISTER_0_OFFSET_01 ,OFFSET_01 RESET:0x0"
          
          
group.long  0x140++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_WDR_L_REGISTER_1, SENSOR_OFFSET_WDR_L_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_WDR_L_REGISTER_1_OFFSET_10 ,OFFSET_10 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_WDR_L_REGISTER_1_OFFSET_11 ,OFFSET_11 RESET:0x0"
          
          
group.long  0x144++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_WDR_M_REGISTER_0, SENSOR_OFFSET_WDR_M_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_WDR_M_REGISTER_0_OFFSET_00 ,OFFSET_00 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_WDR_M_REGISTER_0_OFFSET_01 ,OFFSET_01 RESET:0x0"
          
          
group.long  0x148++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_WDR_M_REGISTER_1, SENSOR_OFFSET_WDR_M_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_WDR_M_REGISTER_1_OFFSET_10 ,OFFSET_10 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_WDR_M_REGISTER_1_OFFSET_11 ,OFFSET_11 RESET:0x0"
          
          
group.long  0x150++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_GAIN_WDR_REGISTER_0, GAIN_WDR_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_GAIN_WDR_REGISTER_0_GAIN_L ,GAIN_L RESET:0x0"
          
          
         hexmask.long 0x00 16.--28. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_GAIN_WDR_REGISTER_0_GAIN_M ,GAIN_M RESET:0x0"
          
          
group.long  0x158++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_GAIN_WDR_REGISTER_1, GAIN_WDR_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_GAIN_WDR_REGISTER_1_BLACK_LEVEL_L ,BLACK_LEVEL_L RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_GAIN_WDR_REGISTER_1_BLACK_LEVEL_M ,BLACK_LEVEL_M RESET:0x0"
          
          
group.long  0x160++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_0, FRAME_STITCH_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_0_LM_EXPOSURE_RATIO ,LM_EXPOSURE_RATIO RESET:0x0"
          
          
group.long  0x168++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_1, FRAME_STITCH_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_1_LM_THRESH_HIGH ,LM_THRESH_HIGH RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_1_LM_THRESH_LOW ,LM_THRESH_LOW RESET:0x0"
          
          
group.long  0x174++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_2, FRAME_STITCH_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_2_BLACK_LEVEL_LONG ,BLACK_LEVEL_LONG RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_2_BLACK_LEVEL_MEDIUM ,BLACK_LEVEL_MEDIUM RESET:0x0"
          
          
group.long  0x17c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_3, FRAME_STITCH_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_3_BLACK_LEVEL_OUT ,BLACK_LEVEL_OUT RESET:0x0"
          
          
group.long  0x180++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_4, FRAME_STITCH_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_4_LM_NP_MULT ,LM_NP_MULT RESET:0x0"
          
          
group.long  0x184++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_5, FRAME_STITCH_REGISTER_5 RESET:0x0"
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_5_LM_ALPHA_MOV_SLOPE ,LM_ALPHA_MOV_SLOPE RESET:0x0"
          
          
group.long  0x18c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_6, FRAME_STITCH_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_6_GAIN_R ,GAIN_R RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_6_GAIN_B ,GAIN_B RESET:0x0"
          
          
group.long  0x198++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_7, FRAME_STITCH_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_7_LM_NOISE_THRESH ,LM_NOISE_THRESH RESET:0x0"
          
          
         hexmask.long 0x00 8.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_7_LM_POS_WEIGHT ,LM_POS_WEIGHT RESET:0x0"
          
          
         hexmask.long 0x00 16.--21. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_7_LM_NEG_WEIGHT ,LM_NEG_WEIGHT RESET:0x0"
          
          
group.long  0x19c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_8, FRAME_STITCH_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_8_LM_MED_NOISE_ALPHA_THRESH ,LM_MED_NOISE_ALPHA_THRESH RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_8_LM_MED_NOISE_INTENSITY_THRESH ,LM_MED_NOISE_INTENSITY_THRESH RESET:0x0"
          
          
group.long  0x1c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_9, FRAME_STITCH_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_9_MCOFF_WB_OFFSET ,MCOFF_WB_OFFSET RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_9_EXPOSURE_MASK_THRESH ,EXPOSURE_MASK_THRESH RESET:0x0"
          
          
group.long  0x1c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_10, FRAME_STITCH_REGISTER_10 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_10_BWB_SELECT ,BWB_SELECT RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_10_USE_3X3_MAX ,USE_3X3_MAX RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_10_MCOFF_NC_ENABLE ,MCOFF_NC_ENABLE RESET:0x0"
          
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_10_MCOFF_MODE_ENABLE ,MCOFF_MODE_ENABLE RESET:0x0"
          
          
group.long  0x1c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_11, FRAME_STITCH_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_11_MCOFF_L_MAX ,MCOFF_L_MAX RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_11_MCOFF_M_MAX ,MCOFF_M_MAX RESET:0x0"
          
          
group.long  0x1d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_12, FRAME_STITCH_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_12_MCOFF_L_SCALER ,MCOFF_L_SCALER RESET:0x0"
          
          
group.long  0x1d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_13, FRAME_STITCH_REGISTER_13 RESET:0x0"
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_13_MCOFF_NC_THRESH_LOW ,MCOFF_NC_THRESH_LOW RESET:0x0"
          
          
group.long  0x1d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_14, FRAME_STITCH_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_14_MCOFF_NC_THRESH_HIGH ,MCOFF_NC_THRESH_HIGH RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_REGISTER_14_MCOFF_NC_SCALE ,MCOFF_NC_SCALE RESET:0x0"
          
          
group.long  0x35c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_0, FRAME_STITCH_NP_LUT_L_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT0 ,WEIGHT_LUT_REG0_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT1 ,WEIGHT_LUT_REG0_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT2 ,WEIGHT_LUT_REG0_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT3 ,WEIGHT_LUT_REG0_SEGMENT3 RESET:0x0"
          
group.long  0x360++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_1, FRAME_STITCH_NP_LUT_L_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT0 ,WEIGHT_LUT_REG1_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT1 ,WEIGHT_LUT_REG1_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT2 ,WEIGHT_LUT_REG1_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT3 ,WEIGHT_LUT_REG1_SEGMENT3 RESET:0x0"
          
group.long  0x364++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_2, FRAME_STITCH_NP_LUT_L_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT0 ,WEIGHT_LUT_REG2_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT1 ,WEIGHT_LUT_REG2_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT2 ,WEIGHT_LUT_REG2_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT3 ,WEIGHT_LUT_REG2_SEGMENT3 RESET:0x0"
          
group.long  0x368++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_3, FRAME_STITCH_NP_LUT_L_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT0 ,WEIGHT_LUT_REG3_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT1 ,WEIGHT_LUT_REG3_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT2 ,WEIGHT_LUT_REG3_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT3 ,WEIGHT_LUT_REG3_SEGMENT3 RESET:0x0"
          
group.long  0x36c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_4, FRAME_STITCH_NP_LUT_L_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT0 ,WEIGHT_LUT_REG4_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT1 ,WEIGHT_LUT_REG4_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT2 ,WEIGHT_LUT_REG4_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT3 ,WEIGHT_LUT_REG4_SEGMENT3 RESET:0x0"
          
group.long  0x370++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_5, FRAME_STITCH_NP_LUT_L_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT0 ,WEIGHT_LUT_REG5_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT1 ,WEIGHT_LUT_REG5_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT2 ,WEIGHT_LUT_REG5_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT3 ,WEIGHT_LUT_REG5_SEGMENT3 RESET:0x0"
          
group.long  0x374++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_6, FRAME_STITCH_NP_LUT_L_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT0 ,WEIGHT_LUT_REG6_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT1 ,WEIGHT_LUT_REG6_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT2 ,WEIGHT_LUT_REG6_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT3 ,WEIGHT_LUT_REG6_SEGMENT3 RESET:0x0"
          
group.long  0x378++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_7, FRAME_STITCH_NP_LUT_L_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT0 ,WEIGHT_LUT_REG7_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT1 ,WEIGHT_LUT_REG7_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT2 ,WEIGHT_LUT_REG7_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT3 ,WEIGHT_LUT_REG7_SEGMENT3 RESET:0x0"
          
group.long  0x37c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_8, FRAME_STITCH_NP_LUT_L_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT0 ,WEIGHT_LUT_REG8_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT1 ,WEIGHT_LUT_REG8_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT2 ,WEIGHT_LUT_REG8_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT3 ,WEIGHT_LUT_REG8_SEGMENT3 RESET:0x0"
          
group.long  0x380++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_9, FRAME_STITCH_NP_LUT_L_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT0 ,WEIGHT_LUT_REG9_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT1 ,WEIGHT_LUT_REG9_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT2 ,WEIGHT_LUT_REG9_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT3 ,WEIGHT_LUT_REG9_SEGMENT3 RESET:0x0"
          
group.long  0x384++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_10, FRAME_STITCH_NP_LUT_L_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT0 ,WEIGHT_LUT_REG10_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT1 ,WEIGHT_LUT_REG10_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT2 ,WEIGHT_LUT_REG10_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT3 ,WEIGHT_LUT_REG10_SEGMENT3 RESET:0x0"
          
group.long  0x388++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_11, FRAME_STITCH_NP_LUT_L_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT0 ,WEIGHT_LUT_REG11_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT1 ,WEIGHT_LUT_REG11_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT2 ,WEIGHT_LUT_REG11_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT3 ,WEIGHT_LUT_REG11_SEGMENT3 RESET:0x0"
          
group.long  0x38c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_12, FRAME_STITCH_NP_LUT_L_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT0 ,WEIGHT_LUT_REG12_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT1 ,WEIGHT_LUT_REG12_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT2 ,WEIGHT_LUT_REG12_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT3 ,WEIGHT_LUT_REG12_SEGMENT3 RESET:0x0"
          
group.long  0x390++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_13, FRAME_STITCH_NP_LUT_L_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT0 ,WEIGHT_LUT_REG13_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT1 ,WEIGHT_LUT_REG13_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT2 ,WEIGHT_LUT_REG13_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT3 ,WEIGHT_LUT_REG13_SEGMENT3 RESET:0x0"
          
group.long  0x394++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_14, FRAME_STITCH_NP_LUT_L_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT0 ,WEIGHT_LUT_REG14_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT1 ,WEIGHT_LUT_REG14_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT2 ,WEIGHT_LUT_REG14_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT3 ,WEIGHT_LUT_REG14_SEGMENT3 RESET:0x0"
          
group.long  0x398++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_15, FRAME_STITCH_NP_LUT_L_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT0 ,WEIGHT_LUT_REG15_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT1 ,WEIGHT_LUT_REG15_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT2 ,WEIGHT_LUT_REG15_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT3 ,WEIGHT_LUT_REG15_SEGMENT3 RESET:0x0"
          
group.long  0x39c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_16, FRAME_STITCH_NP_LUT_L_REGISTER_16 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT0 ,WEIGHT_LUT_REG16_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT1 ,WEIGHT_LUT_REG16_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT2 ,WEIGHT_LUT_REG16_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT3 ,WEIGHT_LUT_REG16_SEGMENT3 RESET:0x0"
          
group.long  0x3a0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_17, FRAME_STITCH_NP_LUT_L_REGISTER_17 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT0 ,WEIGHT_LUT_REG17_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT1 ,WEIGHT_LUT_REG17_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT2 ,WEIGHT_LUT_REG17_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT3 ,WEIGHT_LUT_REG17_SEGMENT3 RESET:0x0"
          
group.long  0x3a4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_18, FRAME_STITCH_NP_LUT_L_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT0 ,WEIGHT_LUT_REG18_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT1 ,WEIGHT_LUT_REG18_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT2 ,WEIGHT_LUT_REG18_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT3 ,WEIGHT_LUT_REG18_SEGMENT3 RESET:0x0"
          
group.long  0x3a8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_19, FRAME_STITCH_NP_LUT_L_REGISTER_19 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT0 ,WEIGHT_LUT_REG19_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT1 ,WEIGHT_LUT_REG19_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT2 ,WEIGHT_LUT_REG19_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT3 ,WEIGHT_LUT_REG19_SEGMENT3 RESET:0x0"
          
group.long  0x3ac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_20, FRAME_STITCH_NP_LUT_L_REGISTER_20 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT0 ,WEIGHT_LUT_REG20_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT1 ,WEIGHT_LUT_REG20_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT2 ,WEIGHT_LUT_REG20_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT3 ,WEIGHT_LUT_REG20_SEGMENT3 RESET:0x0"
          
group.long  0x3b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_21, FRAME_STITCH_NP_LUT_L_REGISTER_21 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT0 ,WEIGHT_LUT_REG21_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT1 ,WEIGHT_LUT_REG21_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT2 ,WEIGHT_LUT_REG21_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT3 ,WEIGHT_LUT_REG21_SEGMENT3 RESET:0x0"
          
group.long  0x3b4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_22, FRAME_STITCH_NP_LUT_L_REGISTER_22 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT0 ,WEIGHT_LUT_REG22_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT1 ,WEIGHT_LUT_REG22_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT2 ,WEIGHT_LUT_REG22_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT3 ,WEIGHT_LUT_REG22_SEGMENT3 RESET:0x0"
          
group.long  0x3b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_23, FRAME_STITCH_NP_LUT_L_REGISTER_23 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT0 ,WEIGHT_LUT_REG23_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT1 ,WEIGHT_LUT_REG23_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT2 ,WEIGHT_LUT_REG23_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT3 ,WEIGHT_LUT_REG23_SEGMENT3 RESET:0x0"
          
group.long  0x3bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_24, FRAME_STITCH_NP_LUT_L_REGISTER_24 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT0 ,WEIGHT_LUT_REG24_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT1 ,WEIGHT_LUT_REG24_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT2 ,WEIGHT_LUT_REG24_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT3 ,WEIGHT_LUT_REG24_SEGMENT3 RESET:0x0"
          
group.long  0x3c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_25, FRAME_STITCH_NP_LUT_L_REGISTER_25 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT0 ,WEIGHT_LUT_REG25_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT1 ,WEIGHT_LUT_REG25_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT2 ,WEIGHT_LUT_REG25_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT3 ,WEIGHT_LUT_REG25_SEGMENT3 RESET:0x0"
          
group.long  0x3c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_26, FRAME_STITCH_NP_LUT_L_REGISTER_26 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT0 ,WEIGHT_LUT_REG26_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT1 ,WEIGHT_LUT_REG26_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT2 ,WEIGHT_LUT_REG26_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT3 ,WEIGHT_LUT_REG26_SEGMENT3 RESET:0x0"
          
group.long  0x3c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_27, FRAME_STITCH_NP_LUT_L_REGISTER_27 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT0 ,WEIGHT_LUT_REG27_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT1 ,WEIGHT_LUT_REG27_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT2 ,WEIGHT_LUT_REG27_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT3 ,WEIGHT_LUT_REG27_SEGMENT3 RESET:0x0"
          
group.long  0x3cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_28, FRAME_STITCH_NP_LUT_L_REGISTER_28 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT0 ,WEIGHT_LUT_REG28_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT1 ,WEIGHT_LUT_REG28_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT2 ,WEIGHT_LUT_REG28_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT3 ,WEIGHT_LUT_REG28_SEGMENT3 RESET:0x0"
          
group.long  0x3d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_29, FRAME_STITCH_NP_LUT_L_REGISTER_29 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT0 ,WEIGHT_LUT_REG29_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT1 ,WEIGHT_LUT_REG29_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT2 ,WEIGHT_LUT_REG29_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT3 ,WEIGHT_LUT_REG29_SEGMENT3 RESET:0x0"
          
group.long  0x3d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_30, FRAME_STITCH_NP_LUT_L_REGISTER_30 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT0 ,WEIGHT_LUT_REG30_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT1 ,WEIGHT_LUT_REG30_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT2 ,WEIGHT_LUT_REG30_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT3 ,WEIGHT_LUT_REG30_SEGMENT3 RESET:0x0"
          
group.long  0x3d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_31, FRAME_STITCH_NP_LUT_L_REGISTER_31 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT0 ,WEIGHT_LUT_REG31_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT1 ,WEIGHT_LUT_REG31_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT2 ,WEIGHT_LUT_REG31_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FRAME_STITCH_NP_LUT_L_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT3 ,WEIGHT_LUT_REG31_SEGMENT3 RESET:0x0"
          
group.long  0x3dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DECOMPANDER0_REGISTER_0, DECOMPANDER0_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DECOMPANDER0_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DECOMPANDER0_REGISTER_0_OFFSET_MODE ,OFFSET_MODE RESET:0x0"
          
          
group.long  0x3e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DECOMPANDER1_REGISTER_0, DECOMPANDER1_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DECOMPANDER1_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DECOMPANDER1_REGISTER_0_OFFSET_MODE ,OFFSET_MODE RESET:0x0"
          
          
group.long  0x3e4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DIGITAL_GAIN_REGISTER_0, DIGITAL_GAIN_REGISTER_0 RESET:0x100"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DIGITAL_GAIN_REGISTER_0_GAIN ,GAIN RESET:0x100"
          
          
group.long  0x3e8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DIGITAL_GAIN_REGISTER_1, DIGITAL_GAIN_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DIGITAL_GAIN_REGISTER_1_OFFSET ,OFFSET RESET:0x0"
          
          
group.long  0x3ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_FE_REGISTER_0, SENSOR_OFFSET_FE_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_FE_REGISTER_0_OFFSET_00 ,OFFSET_00 RESET:0x0"
          
          
group.long  0x3f0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_FE_REGISTER_1, SENSOR_OFFSET_FE_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_FE_REGISTER_1_OFFSET_01 ,OFFSET_01 RESET:0x0"
          
          
group.long  0x3f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_FE_REGISTER_2, SENSOR_OFFSET_FE_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_FE_REGISTER_2_OFFSET_10 ,OFFSET_10 RESET:0x0"
          
          
group.long  0x3f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_FE_REGISTER_3, SENSOR_OFFSET_FE_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_FE_REGISTER_3_OFFSET_11 ,OFFSET_11 RESET:0x0"
          
          
group.long  0x3fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SQRT_REGISTER_0, SQRT_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SQRT_REGISTER_0_BLACK_LEVEL_IN ,BLACK_LEVEL_IN RESET:0x0"
          
          
group.long  0x400++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SQRT_REGISTER_1, SQRT_REGISTER_1 RESET:0x80000000"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SQRT_REGISTER_1_BLACK_LEVEL_OUT ,BLACK_LEVEL_OUT RESET:0x0"
          
          
         hexmask.long 0x00 15.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SQRT_REGISTER_1_NORMALIZATION ,NORMALIZATION RESET:0x10000"
          
group.long  0x404++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_RAW_FRONTEND_REGISTER_0, RAW_FRONTEND_REGISTER_0 RESET:0x4"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_RAW_FRONTEND_REGISTER_0_DP_ENABLE ,DP_ENABLE RESET:0x1"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_RAW_FRONTEND_REGISTER_0_SHOW_DYNAMIC_DEFECT_PIXEL ,SHOW_DYNAMIC_DEFECT_PIXEL RESET:0x0"
          
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_RAW_FRONTEND_REGISTER_0_DARK_DISABLE ,DARK_DISABLE RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_RAW_FRONTEND_REGISTER_0_BRIGHT_DISABLE ,BRIGHT_DISABLE RESET:0x0"
          
          
group.long  0x40c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_RAW_FRONTEND_REGISTER_1, RAW_FRONTEND_REGISTER_1 RESET:0x400200"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_RAW_FRONTEND_REGISTER_1_DP_SLOPE ,DP_SLOPE RESET:0x200"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_RAW_FRONTEND_REGISTER_1_DP_THRESHOLD ,DP_THRESHOLD RESET:0x40"
          
          
group.long  0x410++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_RAW_FRONTEND_REGISTER_2, RAW_FRONTEND_REGISTER_2 RESET:0x800"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_RAW_FRONTEND_REGISTER_2_DPDEV_THRESHOLD ,DPDEV_THRESHOLD RESET:0x800"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_RAW_FRONTEND_REGISTER_2_DP_BLEND ,DP_BLEND RESET:0x0"
          
          
group.long  0x41c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_RAW_FRONTEND_REGISTER_3, RAW_FRONTEND_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_RAW_FRONTEND_REGISTER_3_LINE_THRESH ,LINE_THRESH RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_RAW_FRONTEND_REGISTER_3_SIGMA_IN ,SIGMA_IN RESET:0x0"
          
          
group.long  0x4c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_0, SINTER_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_0_CONFIG1 ,CONFIG1 RESET:0x0"
          
          
group.long  0x4c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_1, SINTER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_1_CONFIG2 ,CONFIG2 RESET:0x0"
          
          
group.long  0x4c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_2, SINTER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_2_RM_CENTER_X ,RM_CENTER_X RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_2_RM_CENTER_Y ,RM_CENTER_Y RESET:0x0"
          
group.long  0x4cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_3, SINTER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_3_RM_OFF_CENTER_MULT ,RM_OFF_CENTER_MULT RESET:0x0"
          
          
group.long  0x4d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_4, SINTER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_4_THRESH_1H ,THRESH_1H RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_4_THRESH_4H ,THRESH_4H RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_4_THRESH_1V ,THRESH_1V RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_4_THRESH_4V ,THRESH_4V RESET:0x0"
          
group.long  0x4d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_5, SINTER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_5_STRENGTH_1 ,STRENGTH_1 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_REGISTER_5_STRENGTH_4 ,STRENGTH_4 RESET:0x0"
          
          
group.long  0x4d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_0, SINTER_NOISE_PROFILE_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_0_BLACK_REFLECT ,BLACK_REFLECT RESET:0x0"
          
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_0_GLOBAL_OFFSET ,GLOBAL_OFFSET RESET:0x0"
          
          
group.long  0x4dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_1, SINTER_NOISE_PROFILE_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_1_BLACK_LEVEL ,BLACK_LEVEL RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_1_THRESH1 ,THRESH1 RESET:0x0"
          
          
group.long  0x4e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_2, SINTER_NOISE_PROFILE_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_2_THRESH2 ,THRESH2 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_2_THRESH3 ,THRESH3 RESET:0x0"
          
          
group.long  0x4e4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_3, SINTER_NOISE_PROFILE_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_3_NOISE_LEVEL_R ,NOISE_LEVEL_R RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_3_NOISE_LEVEL_B ,NOISE_LEVEL_B RESET:0x0"
          
          
group.long  0x4e8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_4, SINTER_NOISE_PROFILE_REGISTER_4 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_4_ADD_LUT ,ADD_LUT RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_4_EXP_MASK_FROM_THRESH ,EXP_MASK_FROM_THRESH RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_4_ADD_EXP_OFFSET ,ADD_EXP_OFFSET RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_4_ADD_MOTION_OFFSET ,ADD_MOTION_OFFSET RESET:0x0"
          
          
group.long  0x4ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_5, SINTER_NOISE_PROFILE_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_5_EXP_OFFSET_0 ,EXP_OFFSET_0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_5_EXP_OFFSET_1 ,EXP_OFFSET_1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_5_EXP_OFFSET_2 ,EXP_OFFSET_2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_5_EXP_OFFSET_3 ,EXP_OFFSET_3 RESET:0x0"
          
group.long  0x4f0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_6, SINTER_NOISE_PROFILE_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_6_MOTION_OFFSET_0 ,MOTION_OFFSET_0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_6_MOTION_OFFSET_1 ,MOTION_OFFSET_1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_6_MOTION_OFFSET_2 ,MOTION_OFFSET_2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_REGISTER_6_MOTION_OFFSET_3 ,MOTION_OFFSET_3 RESET:0x0"
          
group.long  0x5b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_0, SINTER_NOISE_PROFILE_LUT_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT0 ,WEIGHT_LUT_REG0_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT1 ,WEIGHT_LUT_REG0_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT2 ,WEIGHT_LUT_REG0_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT3 ,WEIGHT_LUT_REG0_SEGMENT3 RESET:0x0"
          
group.long  0x5b4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_1, SINTER_NOISE_PROFILE_LUT_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT0 ,WEIGHT_LUT_REG1_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT1 ,WEIGHT_LUT_REG1_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT2 ,WEIGHT_LUT_REG1_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT3 ,WEIGHT_LUT_REG1_SEGMENT3 RESET:0x0"
          
group.long  0x5b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_2, SINTER_NOISE_PROFILE_LUT_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT0 ,WEIGHT_LUT_REG2_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT1 ,WEIGHT_LUT_REG2_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT2 ,WEIGHT_LUT_REG2_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT3 ,WEIGHT_LUT_REG2_SEGMENT3 RESET:0x0"
          
group.long  0x5bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_3, SINTER_NOISE_PROFILE_LUT_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT0 ,WEIGHT_LUT_REG3_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT1 ,WEIGHT_LUT_REG3_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT2 ,WEIGHT_LUT_REG3_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT3 ,WEIGHT_LUT_REG3_SEGMENT3 RESET:0x0"
          
group.long  0x5c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_4, SINTER_NOISE_PROFILE_LUT_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT0 ,WEIGHT_LUT_REG4_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT1 ,WEIGHT_LUT_REG4_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT2 ,WEIGHT_LUT_REG4_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT3 ,WEIGHT_LUT_REG4_SEGMENT3 RESET:0x0"
          
group.long  0x5c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_5, SINTER_NOISE_PROFILE_LUT_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT0 ,WEIGHT_LUT_REG5_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT1 ,WEIGHT_LUT_REG5_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT2 ,WEIGHT_LUT_REG5_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT3 ,WEIGHT_LUT_REG5_SEGMENT3 RESET:0x0"
          
group.long  0x5c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_6, SINTER_NOISE_PROFILE_LUT_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT0 ,WEIGHT_LUT_REG6_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT1 ,WEIGHT_LUT_REG6_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT2 ,WEIGHT_LUT_REG6_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT3 ,WEIGHT_LUT_REG6_SEGMENT3 RESET:0x0"
          
group.long  0x5cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_7, SINTER_NOISE_PROFILE_LUT_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT0 ,WEIGHT_LUT_REG7_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT1 ,WEIGHT_LUT_REG7_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT2 ,WEIGHT_LUT_REG7_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT3 ,WEIGHT_LUT_REG7_SEGMENT3 RESET:0x0"
          
group.long  0x5d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_8, SINTER_NOISE_PROFILE_LUT_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT0 ,WEIGHT_LUT_REG8_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT1 ,WEIGHT_LUT_REG8_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT2 ,WEIGHT_LUT_REG8_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT3 ,WEIGHT_LUT_REG8_SEGMENT3 RESET:0x0"
          
group.long  0x5d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_9, SINTER_NOISE_PROFILE_LUT_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT0 ,WEIGHT_LUT_REG9_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT1 ,WEIGHT_LUT_REG9_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT2 ,WEIGHT_LUT_REG9_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT3 ,WEIGHT_LUT_REG9_SEGMENT3 RESET:0x0"
          
group.long  0x5d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_10, SINTER_NOISE_PROFILE_LUT_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT0 ,WEIGHT_LUT_REG10_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT1 ,WEIGHT_LUT_REG10_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT2 ,WEIGHT_LUT_REG10_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT3 ,WEIGHT_LUT_REG10_SEGMENT3 RESET:0x0"
          
group.long  0x5dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_11, SINTER_NOISE_PROFILE_LUT_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT0 ,WEIGHT_LUT_REG11_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT1 ,WEIGHT_LUT_REG11_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT2 ,WEIGHT_LUT_REG11_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT3 ,WEIGHT_LUT_REG11_SEGMENT3 RESET:0x0"
          
group.long  0x5e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_12, SINTER_NOISE_PROFILE_LUT_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT0 ,WEIGHT_LUT_REG12_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT1 ,WEIGHT_LUT_REG12_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT2 ,WEIGHT_LUT_REG12_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT3 ,WEIGHT_LUT_REG12_SEGMENT3 RESET:0x0"
          
group.long  0x5e4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_13, SINTER_NOISE_PROFILE_LUT_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT0 ,WEIGHT_LUT_REG13_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT1 ,WEIGHT_LUT_REG13_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT2 ,WEIGHT_LUT_REG13_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT3 ,WEIGHT_LUT_REG13_SEGMENT3 RESET:0x0"
          
group.long  0x5e8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_14, SINTER_NOISE_PROFILE_LUT_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT0 ,WEIGHT_LUT_REG14_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT1 ,WEIGHT_LUT_REG14_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT2 ,WEIGHT_LUT_REG14_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT3 ,WEIGHT_LUT_REG14_SEGMENT3 RESET:0x0"
          
group.long  0x5ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_15, SINTER_NOISE_PROFILE_LUT_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT0 ,WEIGHT_LUT_REG15_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT1 ,WEIGHT_LUT_REG15_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT2 ,WEIGHT_LUT_REG15_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT3 ,WEIGHT_LUT_REG15_SEGMENT3 RESET:0x0"
          
group.long  0x5f0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_16, SINTER_NOISE_PROFILE_LUT_REGISTER_16 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT0 ,WEIGHT_LUT_REG16_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT1 ,WEIGHT_LUT_REG16_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT2 ,WEIGHT_LUT_REG16_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT3 ,WEIGHT_LUT_REG16_SEGMENT3 RESET:0x0"
          
group.long  0x5f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_17, SINTER_NOISE_PROFILE_LUT_REGISTER_17 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT0 ,WEIGHT_LUT_REG17_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT1 ,WEIGHT_LUT_REG17_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT2 ,WEIGHT_LUT_REG17_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT3 ,WEIGHT_LUT_REG17_SEGMENT3 RESET:0x0"
          
group.long  0x5f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_18, SINTER_NOISE_PROFILE_LUT_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT0 ,WEIGHT_LUT_REG18_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT1 ,WEIGHT_LUT_REG18_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT2 ,WEIGHT_LUT_REG18_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT3 ,WEIGHT_LUT_REG18_SEGMENT3 RESET:0x0"
          
group.long  0x5fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_19, SINTER_NOISE_PROFILE_LUT_REGISTER_19 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT0 ,WEIGHT_LUT_REG19_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT1 ,WEIGHT_LUT_REG19_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT2 ,WEIGHT_LUT_REG19_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT3 ,WEIGHT_LUT_REG19_SEGMENT3 RESET:0x0"
          
group.long  0x600++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_20, SINTER_NOISE_PROFILE_LUT_REGISTER_20 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT0 ,WEIGHT_LUT_REG20_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT1 ,WEIGHT_LUT_REG20_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT2 ,WEIGHT_LUT_REG20_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT3 ,WEIGHT_LUT_REG20_SEGMENT3 RESET:0x0"
          
group.long  0x604++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_21, SINTER_NOISE_PROFILE_LUT_REGISTER_21 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT0 ,WEIGHT_LUT_REG21_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT1 ,WEIGHT_LUT_REG21_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT2 ,WEIGHT_LUT_REG21_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT3 ,WEIGHT_LUT_REG21_SEGMENT3 RESET:0x0"
          
group.long  0x608++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_22, SINTER_NOISE_PROFILE_LUT_REGISTER_22 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT0 ,WEIGHT_LUT_REG22_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT1 ,WEIGHT_LUT_REG22_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT2 ,WEIGHT_LUT_REG22_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT3 ,WEIGHT_LUT_REG22_SEGMENT3 RESET:0x0"
          
group.long  0x60c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_23, SINTER_NOISE_PROFILE_LUT_REGISTER_23 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT0 ,WEIGHT_LUT_REG23_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT1 ,WEIGHT_LUT_REG23_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT2 ,WEIGHT_LUT_REG23_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT3 ,WEIGHT_LUT_REG23_SEGMENT3 RESET:0x0"
          
group.long  0x610++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_24, SINTER_NOISE_PROFILE_LUT_REGISTER_24 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT0 ,WEIGHT_LUT_REG24_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT1 ,WEIGHT_LUT_REG24_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT2 ,WEIGHT_LUT_REG24_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT3 ,WEIGHT_LUT_REG24_SEGMENT3 RESET:0x0"
          
group.long  0x614++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_25, SINTER_NOISE_PROFILE_LUT_REGISTER_25 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT0 ,WEIGHT_LUT_REG25_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT1 ,WEIGHT_LUT_REG25_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT2 ,WEIGHT_LUT_REG25_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT3 ,WEIGHT_LUT_REG25_SEGMENT3 RESET:0x0"
          
group.long  0x618++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_26, SINTER_NOISE_PROFILE_LUT_REGISTER_26 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT0 ,WEIGHT_LUT_REG26_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT1 ,WEIGHT_LUT_REG26_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT2 ,WEIGHT_LUT_REG26_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT3 ,WEIGHT_LUT_REG26_SEGMENT3 RESET:0x0"
          
group.long  0x61c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_27, SINTER_NOISE_PROFILE_LUT_REGISTER_27 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT0 ,WEIGHT_LUT_REG27_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT1 ,WEIGHT_LUT_REG27_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT2 ,WEIGHT_LUT_REG27_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT3 ,WEIGHT_LUT_REG27_SEGMENT3 RESET:0x0"
          
group.long  0x620++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_28, SINTER_NOISE_PROFILE_LUT_REGISTER_28 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT0 ,WEIGHT_LUT_REG28_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT1 ,WEIGHT_LUT_REG28_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT2 ,WEIGHT_LUT_REG28_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT3 ,WEIGHT_LUT_REG28_SEGMENT3 RESET:0x0"
          
group.long  0x624++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_29, SINTER_NOISE_PROFILE_LUT_REGISTER_29 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT0 ,WEIGHT_LUT_REG29_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT1 ,WEIGHT_LUT_REG29_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT2 ,WEIGHT_LUT_REG29_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT3 ,WEIGHT_LUT_REG29_SEGMENT3 RESET:0x0"
          
group.long  0x628++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_30, SINTER_NOISE_PROFILE_LUT_REGISTER_30 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT0 ,WEIGHT_LUT_REG30_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT1 ,WEIGHT_LUT_REG30_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT2 ,WEIGHT_LUT_REG30_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT3 ,WEIGHT_LUT_REG30_SEGMENT3 RESET:0x0"
          
group.long  0x62c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_31, SINTER_NOISE_PROFILE_LUT_REGISTER_31 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT0 ,WEIGHT_LUT_REG31_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT1 ,WEIGHT_LUT_REG31_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT2 ,WEIGHT_LUT_REG31_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT3 ,WEIGHT_LUT_REG31_SEGMENT3 RESET:0x0"
          
group.long  0x1b70++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_0, SINTER_SHADING_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_0_RM_SHADING_LUT_REG0_SEGMENT0 ,RM_SHADING_LUT_REG0_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_0_RM_SHADING_LUT_REG0_SEGMENT1 ,RM_SHADING_LUT_REG0_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_0_RM_SHADING_LUT_REG0_SEGMENT2 ,RM_SHADING_LUT_REG0_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_0_RM_SHADING_LUT_REG0_SEGMENT3 ,RM_SHADING_LUT_REG0_SEGMENT3 RESET:0x0"
          
group.long  0x1b74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_1, SINTER_SHADING_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_1_RM_SHADING_LUT_REG1_SEGMENT0 ,RM_SHADING_LUT_REG1_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_1_RM_SHADING_LUT_REG1_SEGMENT1 ,RM_SHADING_LUT_REG1_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_1_RM_SHADING_LUT_REG1_SEGMENT2 ,RM_SHADING_LUT_REG1_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_1_RM_SHADING_LUT_REG1_SEGMENT3 ,RM_SHADING_LUT_REG1_SEGMENT3 RESET:0x0"
          
group.long  0x1b78++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_2, SINTER_SHADING_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_2_RM_SHADING_LUT_REG2_SEGMENT0 ,RM_SHADING_LUT_REG2_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_2_RM_SHADING_LUT_REG2_SEGMENT1 ,RM_SHADING_LUT_REG2_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_2_RM_SHADING_LUT_REG2_SEGMENT2 ,RM_SHADING_LUT_REG2_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_2_RM_SHADING_LUT_REG2_SEGMENT3 ,RM_SHADING_LUT_REG2_SEGMENT3 RESET:0x0"
          
group.long  0x1b7c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_3, SINTER_SHADING_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_3_RM_SHADING_LUT_REG3_SEGMENT0 ,RM_SHADING_LUT_REG3_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_3_RM_SHADING_LUT_REG3_SEGMENT1 ,RM_SHADING_LUT_REG3_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_3_RM_SHADING_LUT_REG3_SEGMENT2 ,RM_SHADING_LUT_REG3_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_3_RM_SHADING_LUT_REG3_SEGMENT3 ,RM_SHADING_LUT_REG3_SEGMENT3 RESET:0x0"
          
group.long  0x1b80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_4, SINTER_SHADING_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_4_RM_SHADING_LUT_REG4_SEGMENT0 ,RM_SHADING_LUT_REG4_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_4_RM_SHADING_LUT_REG4_SEGMENT1 ,RM_SHADING_LUT_REG4_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_4_RM_SHADING_LUT_REG4_SEGMENT2 ,RM_SHADING_LUT_REG4_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_4_RM_SHADING_LUT_REG4_SEGMENT3 ,RM_SHADING_LUT_REG4_SEGMENT3 RESET:0x0"
          
group.long  0x1b84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_5, SINTER_SHADING_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_5_RM_SHADING_LUT_REG5_SEGMENT0 ,RM_SHADING_LUT_REG5_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_5_RM_SHADING_LUT_REG5_SEGMENT1 ,RM_SHADING_LUT_REG5_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_5_RM_SHADING_LUT_REG5_SEGMENT2 ,RM_SHADING_LUT_REG5_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_5_RM_SHADING_LUT_REG5_SEGMENT3 ,RM_SHADING_LUT_REG5_SEGMENT3 RESET:0x0"
          
group.long  0x1b88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_6, SINTER_SHADING_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_6_RM_SHADING_LUT_REG6_SEGMENT0 ,RM_SHADING_LUT_REG6_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_6_RM_SHADING_LUT_REG6_SEGMENT1 ,RM_SHADING_LUT_REG6_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_6_RM_SHADING_LUT_REG6_SEGMENT2 ,RM_SHADING_LUT_REG6_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_6_RM_SHADING_LUT_REG6_SEGMENT3 ,RM_SHADING_LUT_REG6_SEGMENT3 RESET:0x0"
          
group.long  0x1b8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_7, SINTER_SHADING_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_7_RM_SHADING_LUT_REG7_SEGMENT0 ,RM_SHADING_LUT_REG7_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_7_RM_SHADING_LUT_REG7_SEGMENT1 ,RM_SHADING_LUT_REG7_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_7_RM_SHADING_LUT_REG7_SEGMENT2 ,RM_SHADING_LUT_REG7_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SINTER_SHADING_REGISTER_7_RM_SHADING_LUT_REG7_SEGMENT3 ,RM_SHADING_LUT_REG7_SEGMENT3 RESET:0x0"
          
group.long  0x1b94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_REGISTER_0, TEMPER_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_REGISTER_0_SHOW_ALPHA ,SHOW_ALPHA RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_REGISTER_0_MIXER_SELECT ,MIXER_SELECT RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_REGISTER_0_COMPRESS_PIXEL_DATA ,COMPRESS_PIXEL_DATA RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_REGISTER_0_COMPRESS_META_DATA ,COMPRESS_META_DATA RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_REGISTER_0_SHOW_MOTION ,SHOW_MOTION RESET:0x0"
          
          
         hexmask.long 0x00 8.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_REGISTER_0_MODE ,MODE RESET:0x0"
          
          
group.long  0x1b98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_REGISTER_1, TEMPER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_REGISTER_1_RECURSION_LIMIT ,RECURSION_LIMIT RESET:0x0"
          
          
group.long  0x1b9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_REGISTER_2, TEMPER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_REGISTER_2_MOT_THRESH ,MOT_THRESH RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_REGISTER_2_MOT_SLOPE ,MOT_SLOPE RESET:0x0"
          
          
group.long  0x1ba0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_0, TEMPER_NOISE_PROFILE_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_0_USE_LUT ,USE_LUT RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_0_USE_EXP_MASK ,USE_EXP_MASK RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_0_BLACK_REFLECT ,BLACK_REFLECT RESET:0x0"
          
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_0_GLOBAL_OFFSET ,GLOBAL_OFFSET RESET:0x0"
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_0_BLACK_LEVEL ,BLACK_LEVEL RESET:0x0"
          
          
group.long  0x1ba4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_1, TEMPER_NOISE_PROFILE_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_1_THRESH1 ,THRESH1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_1_THRESH2 ,THRESH2 RESET:0x0"
          
          
group.long  0x1ba8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_2, TEMPER_NOISE_PROFILE_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_2_THRESH3 ,THRESH3 RESET:0x0"
          
          
group.long  0x1bac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_3, TEMPER_NOISE_PROFILE_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_3_NOISE_LEVEL_0 ,NOISE_LEVEL_0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_3_NOISE_LEVEL_1 ,NOISE_LEVEL_1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_3_NOISE_LEVEL_2 ,NOISE_LEVEL_2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_3_NOISE_LEVEL_3 ,NOISE_LEVEL_3 RESET:0x0"
          
group.long  0x1bb0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_4, TEMPER_NOISE_PROFILE_REGISTER_4 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_4_RGGB_MODE_ENABLE ,RGGB_MODE_ENABLE RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_4_SQRT_MODE_ENABLE ,SQRT_MODE_ENABLE RESET:0x0"
          
          
         hexmask.long 0x00 8.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_4_RECURSION_STRENGTH ,RECURSION_STRENGTH RESET:0x0"
          
          
         hexmask.long 0x00 16.--21. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_4_SMOOTHNESS ,SMOOTHNESS RESET:0x0"
          
          
group.long  0x1bb4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_5, TEMPER_NOISE_PROFILE_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_5_MOTION_THRESH_0 ,MOTION_THRESH_0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_5_MOTION_THRESH_1 ,MOTION_THRESH_1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--21. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_REGISTER_5_MOTION_THRESH_2 ,MOTION_THRESH_2 RESET:0x0"
          
          
group.long  0x1c70++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_0, TEMPER_NOISE_PROFILE_LUT_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT0 ,WEIGHT_LUT_REG0_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT1 ,WEIGHT_LUT_REG0_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT2 ,WEIGHT_LUT_REG0_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT3 ,WEIGHT_LUT_REG0_SEGMENT3 RESET:0x0"
          
group.long  0x1c74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_1, TEMPER_NOISE_PROFILE_LUT_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT0 ,WEIGHT_LUT_REG1_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT1 ,WEIGHT_LUT_REG1_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT2 ,WEIGHT_LUT_REG1_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT3 ,WEIGHT_LUT_REG1_SEGMENT3 RESET:0x0"
          
group.long  0x1c78++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_2, TEMPER_NOISE_PROFILE_LUT_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT0 ,WEIGHT_LUT_REG2_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT1 ,WEIGHT_LUT_REG2_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT2 ,WEIGHT_LUT_REG2_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT3 ,WEIGHT_LUT_REG2_SEGMENT3 RESET:0x0"
          
group.long  0x1c7c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_3, TEMPER_NOISE_PROFILE_LUT_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT0 ,WEIGHT_LUT_REG3_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT1 ,WEIGHT_LUT_REG3_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT2 ,WEIGHT_LUT_REG3_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT3 ,WEIGHT_LUT_REG3_SEGMENT3 RESET:0x0"
          
group.long  0x1c80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_4, TEMPER_NOISE_PROFILE_LUT_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT0 ,WEIGHT_LUT_REG4_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT1 ,WEIGHT_LUT_REG4_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT2 ,WEIGHT_LUT_REG4_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT3 ,WEIGHT_LUT_REG4_SEGMENT3 RESET:0x0"
          
group.long  0x1c84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_5, TEMPER_NOISE_PROFILE_LUT_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT0 ,WEIGHT_LUT_REG5_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT1 ,WEIGHT_LUT_REG5_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT2 ,WEIGHT_LUT_REG5_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT3 ,WEIGHT_LUT_REG5_SEGMENT3 RESET:0x0"
          
group.long  0x1c88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_6, TEMPER_NOISE_PROFILE_LUT_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT0 ,WEIGHT_LUT_REG6_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT1 ,WEIGHT_LUT_REG6_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT2 ,WEIGHT_LUT_REG6_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT3 ,WEIGHT_LUT_REG6_SEGMENT3 RESET:0x0"
          
group.long  0x1c8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_7, TEMPER_NOISE_PROFILE_LUT_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT0 ,WEIGHT_LUT_REG7_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT1 ,WEIGHT_LUT_REG7_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT2 ,WEIGHT_LUT_REG7_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT3 ,WEIGHT_LUT_REG7_SEGMENT3 RESET:0x0"
          
group.long  0x1c90++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_8, TEMPER_NOISE_PROFILE_LUT_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT0 ,WEIGHT_LUT_REG8_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT1 ,WEIGHT_LUT_REG8_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT2 ,WEIGHT_LUT_REG8_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT3 ,WEIGHT_LUT_REG8_SEGMENT3 RESET:0x0"
          
group.long  0x1c94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_9, TEMPER_NOISE_PROFILE_LUT_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT0 ,WEIGHT_LUT_REG9_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT1 ,WEIGHT_LUT_REG9_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT2 ,WEIGHT_LUT_REG9_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT3 ,WEIGHT_LUT_REG9_SEGMENT3 RESET:0x0"
          
group.long  0x1c98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_10, TEMPER_NOISE_PROFILE_LUT_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT0 ,WEIGHT_LUT_REG10_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT1 ,WEIGHT_LUT_REG10_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT2 ,WEIGHT_LUT_REG10_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT3 ,WEIGHT_LUT_REG10_SEGMENT3 RESET:0x0"
          
group.long  0x1c9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_11, TEMPER_NOISE_PROFILE_LUT_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT0 ,WEIGHT_LUT_REG11_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT1 ,WEIGHT_LUT_REG11_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT2 ,WEIGHT_LUT_REG11_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT3 ,WEIGHT_LUT_REG11_SEGMENT3 RESET:0x0"
          
group.long  0x1ca0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_12, TEMPER_NOISE_PROFILE_LUT_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT0 ,WEIGHT_LUT_REG12_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT1 ,WEIGHT_LUT_REG12_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT2 ,WEIGHT_LUT_REG12_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT3 ,WEIGHT_LUT_REG12_SEGMENT3 RESET:0x0"
          
group.long  0x1ca4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_13, TEMPER_NOISE_PROFILE_LUT_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT0 ,WEIGHT_LUT_REG13_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT1 ,WEIGHT_LUT_REG13_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT2 ,WEIGHT_LUT_REG13_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT3 ,WEIGHT_LUT_REG13_SEGMENT3 RESET:0x0"
          
group.long  0x1ca8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_14, TEMPER_NOISE_PROFILE_LUT_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT0 ,WEIGHT_LUT_REG14_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT1 ,WEIGHT_LUT_REG14_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT2 ,WEIGHT_LUT_REG14_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT3 ,WEIGHT_LUT_REG14_SEGMENT3 RESET:0x0"
          
group.long  0x1cac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_15, TEMPER_NOISE_PROFILE_LUT_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT0 ,WEIGHT_LUT_REG15_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT1 ,WEIGHT_LUT_REG15_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT2 ,WEIGHT_LUT_REG15_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT3 ,WEIGHT_LUT_REG15_SEGMENT3 RESET:0x0"
          
group.long  0x1cb0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_16, TEMPER_NOISE_PROFILE_LUT_REGISTER_16 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT0 ,WEIGHT_LUT_REG16_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT1 ,WEIGHT_LUT_REG16_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT2 ,WEIGHT_LUT_REG16_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT3 ,WEIGHT_LUT_REG16_SEGMENT3 RESET:0x0"
          
group.long  0x1cb4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_17, TEMPER_NOISE_PROFILE_LUT_REGISTER_17 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT0 ,WEIGHT_LUT_REG17_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT1 ,WEIGHT_LUT_REG17_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT2 ,WEIGHT_LUT_REG17_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT3 ,WEIGHT_LUT_REG17_SEGMENT3 RESET:0x0"
          
group.long  0x1cb8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_18, TEMPER_NOISE_PROFILE_LUT_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT0 ,WEIGHT_LUT_REG18_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT1 ,WEIGHT_LUT_REG18_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT2 ,WEIGHT_LUT_REG18_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT3 ,WEIGHT_LUT_REG18_SEGMENT3 RESET:0x0"
          
group.long  0x1cbc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_19, TEMPER_NOISE_PROFILE_LUT_REGISTER_19 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT0 ,WEIGHT_LUT_REG19_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT1 ,WEIGHT_LUT_REG19_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT2 ,WEIGHT_LUT_REG19_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT3 ,WEIGHT_LUT_REG19_SEGMENT3 RESET:0x0"
          
group.long  0x1cc0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_20, TEMPER_NOISE_PROFILE_LUT_REGISTER_20 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT0 ,WEIGHT_LUT_REG20_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT1 ,WEIGHT_LUT_REG20_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT2 ,WEIGHT_LUT_REG20_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT3 ,WEIGHT_LUT_REG20_SEGMENT3 RESET:0x0"
          
group.long  0x1cc4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_21, TEMPER_NOISE_PROFILE_LUT_REGISTER_21 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT0 ,WEIGHT_LUT_REG21_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT1 ,WEIGHT_LUT_REG21_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT2 ,WEIGHT_LUT_REG21_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT3 ,WEIGHT_LUT_REG21_SEGMENT3 RESET:0x0"
          
group.long  0x1cc8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_22, TEMPER_NOISE_PROFILE_LUT_REGISTER_22 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT0 ,WEIGHT_LUT_REG22_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT1 ,WEIGHT_LUT_REG22_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT2 ,WEIGHT_LUT_REG22_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT3 ,WEIGHT_LUT_REG22_SEGMENT3 RESET:0x0"
          
group.long  0x1ccc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_23, TEMPER_NOISE_PROFILE_LUT_REGISTER_23 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT0 ,WEIGHT_LUT_REG23_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT1 ,WEIGHT_LUT_REG23_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT2 ,WEIGHT_LUT_REG23_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT3 ,WEIGHT_LUT_REG23_SEGMENT3 RESET:0x0"
          
group.long  0x1cd0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_24, TEMPER_NOISE_PROFILE_LUT_REGISTER_24 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT0 ,WEIGHT_LUT_REG24_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT1 ,WEIGHT_LUT_REG24_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT2 ,WEIGHT_LUT_REG24_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT3 ,WEIGHT_LUT_REG24_SEGMENT3 RESET:0x0"
          
group.long  0x1cd4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_25, TEMPER_NOISE_PROFILE_LUT_REGISTER_25 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT0 ,WEIGHT_LUT_REG25_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT1 ,WEIGHT_LUT_REG25_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT2 ,WEIGHT_LUT_REG25_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT3 ,WEIGHT_LUT_REG25_SEGMENT3 RESET:0x0"
          
group.long  0x1cd8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_26, TEMPER_NOISE_PROFILE_LUT_REGISTER_26 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT0 ,WEIGHT_LUT_REG26_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT1 ,WEIGHT_LUT_REG26_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT2 ,WEIGHT_LUT_REG26_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT3 ,WEIGHT_LUT_REG26_SEGMENT3 RESET:0x0"
          
group.long  0x1cdc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_27, TEMPER_NOISE_PROFILE_LUT_REGISTER_27 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT0 ,WEIGHT_LUT_REG27_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT1 ,WEIGHT_LUT_REG27_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT2 ,WEIGHT_LUT_REG27_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT3 ,WEIGHT_LUT_REG27_SEGMENT3 RESET:0x0"
          
group.long  0x1ce0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_28, TEMPER_NOISE_PROFILE_LUT_REGISTER_28 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT0 ,WEIGHT_LUT_REG28_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT1 ,WEIGHT_LUT_REG28_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT2 ,WEIGHT_LUT_REG28_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT3 ,WEIGHT_LUT_REG28_SEGMENT3 RESET:0x0"
          
group.long  0x1ce4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_29, TEMPER_NOISE_PROFILE_LUT_REGISTER_29 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT0 ,WEIGHT_LUT_REG29_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT1 ,WEIGHT_LUT_REG29_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT2 ,WEIGHT_LUT_REG29_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT3 ,WEIGHT_LUT_REG29_SEGMENT3 RESET:0x0"
          
group.long  0x1ce8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_30, TEMPER_NOISE_PROFILE_LUT_REGISTER_30 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT0 ,WEIGHT_LUT_REG30_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT1 ,WEIGHT_LUT_REG30_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT2 ,WEIGHT_LUT_REG30_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT3 ,WEIGHT_LUT_REG30_SEGMENT3 RESET:0x0"
          
group.long  0x1cec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_31, TEMPER_NOISE_PROFILE_LUT_REGISTER_31 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT0 ,WEIGHT_LUT_REG31_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT1 ,WEIGHT_LUT_REG31_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT2 ,WEIGHT_LUT_REG31_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT3 ,WEIGHT_LUT_REG31_SEGMENT3 RESET:0x0"
          
group.long  0x1cf0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_0, TEMPER_DMA_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_0_FRAME_WRITE_ON_DMA ,FRAME_WRITE_ON_DMA RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_0_FRAME_READ_ON_DMA ,FRAME_READ_ON_DMA RESET:0x0"
          
          
group.long  0x1cf4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_1, TEMPER_DMA_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_1_FORMAT ,FORMAT RESET:0x0"
          
          
rgroup.long 0x1cf8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_2, TEMPER_DMA_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_2_BLK_STATUS ,BLK_STATUS RESET:0x0"
          
group.long  0x1cfc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_3, TEMPER_DMA_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_3_BANK_BASE_WRITER ,BANK_BASE_WRITER RESET:0x0"
          
group.long  0x1d04++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_4, TEMPER_DMA_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_4_BANK_BASE_READER ,BANK_BASE_READER RESET:0x0"
          
group.long  0x1d0c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_5, TEMPER_DMA_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_5_LINE_OFFSET ,LINE_OFFSET RESET:0x0"
          
group.long  0x1d10++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_6, TEMPER_DMA_REGISTER_6 RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_6_LINETICK_EOL ,LINETICK_EOL RESET:0x0"
          
          
group.long  0x1d14++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_7, TEMPER_DMA_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_7_WRITER_LINES_WRAPPED ,WRITER_LINES_WRAPPED RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_7_READER_LINES_WRAPPED ,READER_LINES_WRAPPED RESET:0x0"
          
group.long  0x1d18++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_8, TEMPER_DMA_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_8_LINETICK_FIRST ,LINETICK_FIRST RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_8_LINETICK_REPEAT ,LINETICK_REPEAT RESET:0x0"
          
group.long  0x1d1c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_9, TEMPER_DMA_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_9_LINETICK_DELAY ,LINETICK_DELAY RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_9_FIFO_MAXFILL ,FIFO_MAXFILL RESET:0x0"
          
group.long  0x1d20++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_10, TEMPER_DMA_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_10_WRITER_AXI_ID_VALUE ,WRITER_AXI_ID_VALUE RESET:0x0"
          
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_10_WRITER_AXI_ID_MULTI ,WRITER_AXI_ID_MULTI RESET:0x0"
          
         hexmask.long 0x00 9.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_10_WRITER_AXI_BURSTSPLIT ,WRITER_AXI_BURSTSPLIT RESET:0x0"
          
         hexmask.long 0x00 11.--14. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_10_WRITER_AXI_CACHE_VALUE ,WRITER_AXI_CACHE_VALUE RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_10_WRITER_AXI_MAXOSTAND ,WRITER_AXI_MAXOSTAND RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_10_WRITER_AXI_MAX_AWLEN ,WRITER_AXI_MAX_AWLEN RESET:0x0"
          
         bitfld.long 0x00 28. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_10_WRITER_PAGEWARM_ON ,WRITER_PAGEWARM_ON RESET:0x0"
          
          
group.long  0x1d24++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_11, TEMPER_DMA_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_11_READER_AXI_ID_VALUE ,READER_AXI_ID_VALUE RESET:0x0"
          
          
         hexmask.long 0x00 9.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_11_READER_AXI_BURSTSPLIT ,READER_AXI_BURSTSPLIT RESET:0x0"
          
         hexmask.long 0x00 11.--14. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_11_READER_AXI_CACHE_VALUE ,READER_AXI_CACHE_VALUE RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_11_READER_AXI_MAXOSTAND ,READER_AXI_MAXOSTAND RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_11_READER_AXI_MAX_ARLEN ,READER_AXI_MAX_ARLEN RESET:0x0"
          
         bitfld.long 0x00 28. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TEMPER_DMA_REGISTER_11_READER_PAGEWARM_ON ,READER_PAGEWARM_ON RESET:0x0"
          
          
group.long  0x1d38++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SQUARE_BE_REGISTER_0, SQUARE_BE_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SQUARE_BE_REGISTER_0_BLACK_LEVEL_IN ,BLACK_LEVEL_IN RESET:0x0"
          
          
group.long  0x1d3c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SQUARE_BE_REGISTER_1, SQUARE_BE_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SQUARE_BE_REGISTER_1_BLACK_LEVEL_OUT ,BLACK_LEVEL_OUT RESET:0x0"
          
          
group.long  0x1d40++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SQUARE_BE_REGISTER_2, SQUARE_BE_REGISTER_2 RESET:0x10000"
         hexmask.long 0x00 0.--16. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SQUARE_BE_REGISTER_2_NORMALIZATION ,NORMALIZATION RESET:0x10000"
          
          
group.long  0x1d44++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_PRE_SHADING_REGISTER_0, SENSOR_OFFSET_PRE_SHADING_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_PRE_SHADING_REGISTER_0_OFFSET_00 ,OFFSET_00 RESET:0x0"
          
          
group.long  0x1d48++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_PRE_SHADING_REGISTER_1, SENSOR_OFFSET_PRE_SHADING_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_PRE_SHADING_REGISTER_1_OFFSET_01 ,OFFSET_01 RESET:0x0"
          
          
group.long  0x1d4c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_PRE_SHADING_REGISTER_2, SENSOR_OFFSET_PRE_SHADING_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_PRE_SHADING_REGISTER_2_OFFSET_10 ,OFFSET_10 RESET:0x0"
          
          
group.long  0x1d50++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_PRE_SHADING_REGISTER_3, SENSOR_OFFSET_PRE_SHADING_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_SENSOR_OFFSET_PRE_SHADING_REGISTER_3_OFFSET_11 ,OFFSET_11 RESET:0x0"
          
          
group.long  0x1d74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_0, MESH_SHADING_REGISTER_0 RESET:0x1f1fe406"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_0_MESH_SHOW ,MESH_SHOW RESET:0x1"
          
         hexmask.long 0x00 2.--4. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_0_MESH_SCALE ,MESH_SCALE RESET:0x1"
          
          
         hexmask.long 0x00 8.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_0_MESH_PAGE_R ,MESH_PAGE_R RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_0_MESH_PAGE_G ,MESH_PAGE_G RESET:0x1"
          
         hexmask.long 0x00 12.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_0_MESH_PAGE_B ,MESH_PAGE_B RESET:0x2"
          
         hexmask.long 0x00 14.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_0_MESH_PAGE_IR ,MESH_PAGE_IR RESET:0x3"
          
         hexmask.long 0x00 16.--21. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_0_MESH_WIDTH ,MESH_WIDTH RESET:0x1f"
          
          
         hexmask.long 0x00 24.--29. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_0_MESH_HEIGHT ,MESH_HEIGHT RESET:0x1f"
          
          
group.long  0x1d78++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_1, MESH_SHADING_REGISTER_1 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_1_MESH_RELOAD ,MESH_RELOAD RESET:0x0"
          
          
group.long  0x1d7c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_2, MESH_SHADING_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_2_MESH_ALPHA_BANK_R ,MESH_ALPHA_BANK_R RESET:0x0"
          
         hexmask.long 0x00 3.--5. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_2_MESH_ALPHA_BANK_G ,MESH_ALPHA_BANK_G RESET:0x0"
          
         hexmask.long 0x00 6.--8. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_2_MESH_ALPHA_BANK_B ,MESH_ALPHA_BANK_B RESET:0x0"
          
         hexmask.long 0x00 9.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_2_MESH_ALPHA_BANK_IR ,MESH_ALPHA_BANK_IR RESET:0x0"
          
          
group.long  0x1d80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_3, MESH_SHADING_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_3_MESH_ALPHA_R ,MESH_ALPHA_R RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_3_MESH_ALPHA_G ,MESH_ALPHA_G RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_3_MESH_ALPHA_B ,MESH_ALPHA_B RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_3_MESH_ALPHA_IR ,MESH_ALPHA_IR RESET:0x0"
          
group.long  0x1d84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_4, MESH_SHADING_REGISTER_4 RESET:0x1000"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MESH_SHADING_REGISTER_4_MESH_STRENGTH ,MESH_STRENGTH RESET:0x1000"
          
          
group.long  0x1d88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_WHITE_BALANCE_REGISTER_0, WHITE_BALANCE_REGISTER_0 RESET:0x1000100"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_WHITE_BALANCE_REGISTER_0_GAIN_00 ,GAIN_00 RESET:0x100"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_WHITE_BALANCE_REGISTER_0_GAIN_01 ,GAIN_01 RESET:0x100"
          
          
group.long  0x1d8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_WHITE_BALANCE_REGISTER_1, WHITE_BALANCE_REGISTER_1 RESET:0x1000100"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_WHITE_BALANCE_REGISTER_1_GAIN_10 ,GAIN_10 RESET:0x100"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_WHITE_BALANCE_REGISTER_1_GAIN_11 ,GAIN_11 RESET:0x100"
          
          
group.long  0x1d90++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_WHITE_BALANCE_AEXP_REGISTER_0, WHITE_BALANCE_AEXP_REGISTER_0 RESET:0x1000100"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_WHITE_BALANCE_AEXP_REGISTER_0_GAIN_00 ,GAIN_00 RESET:0x100"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_WHITE_BALANCE_AEXP_REGISTER_0_GAIN_01 ,GAIN_01 RESET:0x100"
          
          
group.long  0x1d94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_WHITE_BALANCE_AEXP_REGISTER_1, WHITE_BALANCE_AEXP_REGISTER_1 RESET:0x1000100"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_WHITE_BALANCE_AEXP_REGISTER_1_GAIN_10 ,GAIN_10 RESET:0x100"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_WHITE_BALANCE_AEXP_REGISTER_1_GAIN_11 ,GAIN_11 RESET:0x100"
          
          
group.long  0x1d98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_GAIN_REGISTER_0, IRIDIX_GAIN_REGISTER_0 RESET:0x100"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_GAIN_REGISTER_0_GAIN ,GAIN RESET:0x100"
          
          
group.long  0x1d9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_GAIN_REGISTER_1, IRIDIX_GAIN_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_GAIN_REGISTER_1_OFFSET ,OFFSET RESET:0x0"
          
          
group.long  0x1da0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_0, IRIDIX_REGISTER_0 RESET:0x4229"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_0_IRIDIX_ON ,IRIDIX_ON RESET:0x1"
          
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_0_MAX_ALG_TYPE ,MAX_ALG_TYPE RESET:0x1"
          
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_0_BLACK_LEVEL_AMP0 ,BLACK_LEVEL_AMP0 RESET:0x1"
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_0_POSTGAMMA_POS ,POSTGAMMA_POS RESET:0x0"
          
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_0_COLLECT_OVL ,COLLECT_OVL RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_0_COLLECT_RND ,COLLECT_RND RESET:0x1"
          
          
         hexmask.long 0x00 14.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_0_STAT_MULT ,STAT_MULT RESET:0x1"
          
          
group.long  0x1da4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_1, IRIDIX_REGISTER_1 RESET:0x50"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_1_IVARIANCE1 ,IVARIANCE1 RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_1_IVARIANCE2 ,IVARIANCE2 RESET:0x5"
          
          
group.long  0x1da8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_2, IRIDIX_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_2_BLACK_LEVEL ,BLACK_LEVEL RESET:0x0"
          
          
group.long  0x1dac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_3, IRIDIX_REGISTER_3 RESET:0xd9999"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_3_WHITE_LEVEL ,WHITE_LEVEL RESET:0xd9999"
          
          
group.long  0x1db0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_4, IRIDIX_REGISTER_4 RESET:0x100"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_4_COLLECTION_CORRECTION ,COLLECTION_CORRECTION RESET:0x100"
          
          
group.long  0x1db4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_5, IRIDIX_REGISTER_5 RESET:0x2000202"
         hexmask.long 0x00 0.--1. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_5_FWD_PERCEPT_CONTROL ,FWD_PERCEPT_CONTROL RESET:0x2"
          
          
         hexmask.long 0x00 8.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_5_REV_PERCEPT_CONTROL ,REV_PERCEPT_CONTROL RESET:0x2"
          
          
         hexmask.long 0x00 16.--25. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_5_STRENGTH_INROI ,STRENGTH_INROI RESET:0x200"
          
          
group.long  0x1db8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_6, IRIDIX_REGISTER_6 RESET:0x200"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_6_STRENGTH_OUTROI ,STRENGTH_OUTROI RESET:0x200"
          
          
group.long  0x1dbc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_7, IRIDIX_REGISTER_7 RESET:0xffff0000"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_7_ROI_HOR_START ,ROI_HOR_START RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_7_ROI_HOR_END ,ROI_HOR_END RESET:0xffff"
          
group.long  0x1dc0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_8, IRIDIX_REGISTER_8 RESET:0xffff0000"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_8_ROI_VER_START ,ROI_VER_START RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_8_ROI_VER_END ,ROI_VER_END RESET:0xffff"
          
group.long  0x1dc4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_9, IRIDIX_REGISTER_9 RESET:0xc8dc0800"
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_9_SVARIANCE ,SVARIANCE RESET:0x8"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_9_BRIGHT_PR ,BRIGHT_PR RESET:0xdc"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_9_CONTRAST ,CONTRAST RESET:0xc8"
          
group.long  0x1dc8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_10, IRIDIX_REGISTER_10 RESET:0x800"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_10_DARK_ENH ,DARK_ENH RESET:0x800"
          
          
group.long  0x1dd4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_11, IRIDIX_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_11_CONTEXT_NO ,CONTEXT_NO RESET:0x0"
          
          
group.long  0x1dd8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_12, IRIDIX_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_12_WB_OFFSET ,WB_OFFSET RESET:0x0"
          
          
group.long  0x1ddc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_13, IRIDIX_REGISTER_13 RESET:0x1000100"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_13_GAIN_R ,GAIN_R RESET:0x100"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_13_GAIN_GR ,GAIN_GR RESET:0x100"
          
          
group.long  0x1de0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_14, IRIDIX_REGISTER_14 RESET:0x1000100"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_14_GAIN_GB ,GAIN_GB RESET:0x100"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_14_GAIN_B ,GAIN_B RESET:0x100"
          
          
group.long  0x1de4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_15, IRIDIX_REGISTER_15 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_REGISTER_15_GTM_SELECT ,GTM_SELECT RESET:0x0"
          
          
group.long  0x1de8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_0, IRIDIX_LUT_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_0_ASYMMETRY_LUT_REG0_SEGMENT0 ,ASYMMETRY_LUT_REG0_SEGMENT0 RESET:0x0"
          
          
group.long  0x1dec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_1, IRIDIX_LUT_REGISTER_1 RESET:0x36dd0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_1_ASYMMETRY_LUT_REG1_SEGMENT0 ,ASYMMETRY_LUT_REG1_SEGMENT0 RESET:0x36dd0"
          
          
group.long  0x1df0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_2, IRIDIX_LUT_REGISTER_2 RESET:0x549bd"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_2_ASYMMETRY_LUT_REG2_SEGMENT0 ,ASYMMETRY_LUT_REG2_SEGMENT0 RESET:0x549bd"
          
          
group.long  0x1df4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_3, IRIDIX_LUT_REGISTER_3 RESET:0x67ade"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_3_ASYMMETRY_LUT_REG3_SEGMENT0 ,ASYMMETRY_LUT_REG3_SEGMENT0 RESET:0x67ade"
          
          
group.long  0x1df8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_4, IRIDIX_LUT_REGISTER_4 RESET:0x76557"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_4_ASYMMETRY_LUT_REG4_SEGMENT0 ,ASYMMETRY_LUT_REG4_SEGMENT0 RESET:0x76557"
          
          
group.long  0x1dfc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_5, IRIDIX_LUT_REGISTER_5 RESET:0x82168"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_5_ASYMMETRY_LUT_REG5_SEGMENT0 ,ASYMMETRY_LUT_REG5_SEGMENT0 RESET:0x82168"
          
          
group.long  0x1e00++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_6, IRIDIX_LUT_REGISTER_6 RESET:0x8bca8"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_6_ASYMMETRY_LUT_REG6_SEGMENT0 ,ASYMMETRY_LUT_REG6_SEGMENT0 RESET:0x8bca8"
          
          
group.long  0x1e04++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_7, IRIDIX_LUT_REGISTER_7 RESET:0x93f91"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_7_ASYMMETRY_LUT_REG7_SEGMENT0 ,ASYMMETRY_LUT_REG7_SEGMENT0 RESET:0x93f91"
          
          
group.long  0x1e08++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_8, IRIDIX_LUT_REGISTER_8 RESET:0x9afd9"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_8_ASYMMETRY_LUT_REG8_SEGMENT0 ,ASYMMETRY_LUT_REG8_SEGMENT0 RESET:0x9afd9"
          
          
group.long  0x1e0c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_9, IRIDIX_LUT_REGISTER_9 RESET:0xa1179"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_9_ASYMMETRY_LUT_REG9_SEGMENT0 ,ASYMMETRY_LUT_REG9_SEGMENT0 RESET:0xa1179"
          
          
group.long  0x1e10++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_10, IRIDIX_LUT_REGISTER_10 RESET:0xa6742"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_10_ASYMMETRY_LUT_REG10_SEGMENT0 ,ASYMMETRY_LUT_REG10_SEGMENT0 RESET:0xa6742"
          
          
group.long  0x1e14++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_11, IRIDIX_LUT_REGISTER_11 RESET:0xab372"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_11_ASYMMETRY_LUT_REG11_SEGMENT0 ,ASYMMETRY_LUT_REG11_SEGMENT0 RESET:0xab372"
          
          
group.long  0x1e18++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_12, IRIDIX_LUT_REGISTER_12 RESET:0xaf792"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_12_ASYMMETRY_LUT_REG12_SEGMENT0 ,ASYMMETRY_LUT_REG12_SEGMENT0 RESET:0xaf792"
          
          
group.long  0x1e1c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_13, IRIDIX_LUT_REGISTER_13 RESET:0xb3503"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_13_ASYMMETRY_LUT_REG13_SEGMENT0 ,ASYMMETRY_LUT_REG13_SEGMENT0 RESET:0xb3503"
          
          
group.long  0x1e20++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_14, IRIDIX_LUT_REGISTER_14 RESET:0xb6cbb"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_14_ASYMMETRY_LUT_REG14_SEGMENT0 ,ASYMMETRY_LUT_REG14_SEGMENT0 RESET:0xb6cbb"
          
          
group.long  0x1e24++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_15, IRIDIX_LUT_REGISTER_15 RESET:0xb9fa3"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_15_ASYMMETRY_LUT_REG15_SEGMENT0 ,ASYMMETRY_LUT_REG15_SEGMENT0 RESET:0xb9fa3"
          
          
group.long  0x1e28++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_16, IRIDIX_LUT_REGISTER_16 RESET:0xbce4b"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_16_ASYMMETRY_LUT_REG16_SEGMENT0 ,ASYMMETRY_LUT_REG16_SEGMENT0 RESET:0xbce4b"
          
          
group.long  0x1e2c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_17, IRIDIX_LUT_REGISTER_17 RESET:0xbf95b"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_17_ASYMMETRY_LUT_REG17_SEGMENT0 ,ASYMMETRY_LUT_REG17_SEGMENT0 RESET:0xbf95b"
          
          
group.long  0x1e30++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_18, IRIDIX_LUT_REGISTER_18 RESET:0xc2133"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_18_ASYMMETRY_LUT_REG18_SEGMENT0 ,ASYMMETRY_LUT_REG18_SEGMENT0 RESET:0xc2133"
          
          
group.long  0x1e34++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_19, IRIDIX_LUT_REGISTER_19 RESET:0xc4644"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_19_ASYMMETRY_LUT_REG19_SEGMENT0 ,ASYMMETRY_LUT_REG19_SEGMENT0 RESET:0xc4644"
          
          
group.long  0x1e38++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_20, IRIDIX_LUT_REGISTER_20 RESET:0xc68ec"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_20_ASYMMETRY_LUT_REG20_SEGMENT0 ,ASYMMETRY_LUT_REG20_SEGMENT0 RESET:0xc68ec"
          
          
group.long  0x1e3c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_21, IRIDIX_LUT_REGISTER_21 RESET:0xc896c"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_21_ASYMMETRY_LUT_REG21_SEGMENT0 ,ASYMMETRY_LUT_REG21_SEGMENT0 RESET:0xc896c"
          
          
group.long  0x1e40++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_22, IRIDIX_LUT_REGISTER_22 RESET:0xca7fc"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_22_ASYMMETRY_LUT_REG22_SEGMENT0 ,ASYMMETRY_LUT_REG22_SEGMENT0 RESET:0xca7fc"
          
          
group.long  0x1e44++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_23, IRIDIX_LUT_REGISTER_23 RESET:0xcc4dc"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_23_ASYMMETRY_LUT_REG23_SEGMENT0 ,ASYMMETRY_LUT_REG23_SEGMENT0 RESET:0xcc4dc"
          
          
group.long  0x1e48++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_24, IRIDIX_LUT_REGISTER_24 RESET:0xce034"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_24_ASYMMETRY_LUT_REG24_SEGMENT0 ,ASYMMETRY_LUT_REG24_SEGMENT0 RESET:0xce034"
          
          
group.long  0x1e4c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_25, IRIDIX_LUT_REGISTER_25 RESET:0xcfa44"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_25_ASYMMETRY_LUT_REG25_SEGMENT0 ,ASYMMETRY_LUT_REG25_SEGMENT0 RESET:0xcfa44"
          
          
group.long  0x1e50++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_26, IRIDIX_LUT_REGISTER_26 RESET:0xd1314"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_26_ASYMMETRY_LUT_REG26_SEGMENT0 ,ASYMMETRY_LUT_REG26_SEGMENT0 RESET:0xd1314"
          
          
group.long  0x1e54++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_27, IRIDIX_LUT_REGISTER_27 RESET:0xd2ad4"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_27_ASYMMETRY_LUT_REG27_SEGMENT0 ,ASYMMETRY_LUT_REG27_SEGMENT0 RESET:0xd2ad4"
          
          
group.long  0x1e58++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_28, IRIDIX_LUT_REGISTER_28 RESET:0xd41a4"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_28_ASYMMETRY_LUT_REG28_SEGMENT0 ,ASYMMETRY_LUT_REG28_SEGMENT0 RESET:0xd41a4"
          
          
group.long  0x1e5c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_29, IRIDIX_LUT_REGISTER_29 RESET:0xd57a5"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_29_ASYMMETRY_LUT_REG29_SEGMENT0 ,ASYMMETRY_LUT_REG29_SEGMENT0 RESET:0xd57a5"
          
          
group.long  0x1e60++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_30, IRIDIX_LUT_REGISTER_30 RESET:0xd6cdd"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_30_ASYMMETRY_LUT_REG30_SEGMENT0 ,ASYMMETRY_LUT_REG30_SEGMENT0 RESET:0xd6cdd"
          
          
group.long  0x1e64++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_31, IRIDIX_LUT_REGISTER_31 RESET:0xd8175"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_31_ASYMMETRY_LUT_REG31_SEGMENT0 ,ASYMMETRY_LUT_REG31_SEGMENT0 RESET:0xd8175"
          
          
group.long  0x1e68++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_32, IRIDIX_LUT_REGISTER_32 RESET:0xd9575"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_32_ASYMMETRY_LUT_REG32_SEGMENT0 ,ASYMMETRY_LUT_REG32_SEGMENT0 RESET:0xd9575"
          
          
group.long  0x1e6c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_33, IRIDIX_LUT_REGISTER_33 RESET:0xda8fd"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_33_ASYMMETRY_LUT_REG33_SEGMENT0 ,ASYMMETRY_LUT_REG33_SEGMENT0 RESET:0xda8fd"
          
          
group.long  0x1e70++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_34, IRIDIX_LUT_REGISTER_34 RESET:0xdbc05"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_34_ASYMMETRY_LUT_REG34_SEGMENT0 ,ASYMMETRY_LUT_REG34_SEGMENT0 RESET:0xdbc05"
          
          
group.long  0x1e74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_35, IRIDIX_LUT_REGISTER_35 RESET:0xdcebd"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_35_ASYMMETRY_LUT_REG35_SEGMENT0 ,ASYMMETRY_LUT_REG35_SEGMENT0 RESET:0xdcebd"
          
          
group.long  0x1e78++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_36, IRIDIX_LUT_REGISTER_36 RESET:0xde11d"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_36_ASYMMETRY_LUT_REG36_SEGMENT0 ,ASYMMETRY_LUT_REG36_SEGMENT0 RESET:0xde11d"
          
          
group.long  0x1e7c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_37, IRIDIX_LUT_REGISTER_37 RESET:0xdf33d"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_37_ASYMMETRY_LUT_REG37_SEGMENT0 ,ASYMMETRY_LUT_REG37_SEGMENT0 RESET:0xdf33d"
          
          
group.long  0x1e80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_38, IRIDIX_LUT_REGISTER_38 RESET:0xe052d"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_38_ASYMMETRY_LUT_REG38_SEGMENT0 ,ASYMMETRY_LUT_REG38_SEGMENT0 RESET:0xe052d"
          
          
group.long  0x1e84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_39, IRIDIX_LUT_REGISTER_39 RESET:0xe16e5"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_39_ASYMMETRY_LUT_REG39_SEGMENT0 ,ASYMMETRY_LUT_REG39_SEGMENT0 RESET:0xe16e5"
          
          
group.long  0x1e88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_40, IRIDIX_LUT_REGISTER_40 RESET:0xe2885"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_40_ASYMMETRY_LUT_REG40_SEGMENT0 ,ASYMMETRY_LUT_REG40_SEGMENT0 RESET:0xe2885"
          
          
group.long  0x1e8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_41, IRIDIX_LUT_REGISTER_41 RESET:0xe3a15"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_41_ASYMMETRY_LUT_REG41_SEGMENT0 ,ASYMMETRY_LUT_REG41_SEGMENT0 RESET:0xe3a15"
          
          
group.long  0x1e90++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_42, IRIDIX_LUT_REGISTER_42 RESET:0xe4b9d"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_42_ASYMMETRY_LUT_REG42_SEGMENT0 ,ASYMMETRY_LUT_REG42_SEGMENT0 RESET:0xe4b9d"
          
          
group.long  0x1e94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_43, IRIDIX_LUT_REGISTER_43 RESET:0xe5d1e"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_43_ASYMMETRY_LUT_REG43_SEGMENT0 ,ASYMMETRY_LUT_REG43_SEGMENT0 RESET:0xe5d1e"
          
          
group.long  0x1e98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_44, IRIDIX_LUT_REGISTER_44 RESET:0xe6ea6"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_44_ASYMMETRY_LUT_REG44_SEGMENT0 ,ASYMMETRY_LUT_REG44_SEGMENT0 RESET:0xe6ea6"
          
          
group.long  0x1e9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_45, IRIDIX_LUT_REGISTER_45 RESET:0xe8046"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_45_ASYMMETRY_LUT_REG45_SEGMENT0 ,ASYMMETRY_LUT_REG45_SEGMENT0 RESET:0xe8046"
          
          
group.long  0x1ea0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_46, IRIDIX_LUT_REGISTER_46 RESET:0xe91fe"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_46_ASYMMETRY_LUT_REG46_SEGMENT0 ,ASYMMETRY_LUT_REG46_SEGMENT0 RESET:0xe91fe"
          
          
group.long  0x1ea4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_47, IRIDIX_LUT_REGISTER_47 RESET:0xea3d6"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_47_ASYMMETRY_LUT_REG47_SEGMENT0 ,ASYMMETRY_LUT_REG47_SEGMENT0 RESET:0xea3d6"
          
          
group.long  0x1ea8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_48, IRIDIX_LUT_REGISTER_48 RESET:0xeb5de"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_48_ASYMMETRY_LUT_REG48_SEGMENT0 ,ASYMMETRY_LUT_REG48_SEGMENT0 RESET:0xeb5de"
          
          
group.long  0x1eac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_49, IRIDIX_LUT_REGISTER_49 RESET:0xec80e"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_49_ASYMMETRY_LUT_REG49_SEGMENT0 ,ASYMMETRY_LUT_REG49_SEGMENT0 RESET:0xec80e"
          
          
group.long  0x1eb0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_50, IRIDIX_LUT_REGISTER_50 RESET:0xeda7e"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_50_ASYMMETRY_LUT_REG50_SEGMENT0 ,ASYMMETRY_LUT_REG50_SEGMENT0 RESET:0xeda7e"
          
          
group.long  0x1eb4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_51, IRIDIX_LUT_REGISTER_51 RESET:0xeed2e"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_51_ASYMMETRY_LUT_REG51_SEGMENT0 ,ASYMMETRY_LUT_REG51_SEGMENT0 RESET:0xeed2e"
          
          
group.long  0x1eb8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_52, IRIDIX_LUT_REGISTER_52 RESET:0xf0016"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_52_ASYMMETRY_LUT_REG52_SEGMENT0 ,ASYMMETRY_LUT_REG52_SEGMENT0 RESET:0xf0016"
          
          
group.long  0x1ebc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_53, IRIDIX_LUT_REGISTER_53 RESET:0xf1356"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_53_ASYMMETRY_LUT_REG53_SEGMENT0 ,ASYMMETRY_LUT_REG53_SEGMENT0 RESET:0xf1356"
          
          
group.long  0x1ec0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_54, IRIDIX_LUT_REGISTER_54 RESET:0xf26e6"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_54_ASYMMETRY_LUT_REG54_SEGMENT0 ,ASYMMETRY_LUT_REG54_SEGMENT0 RESET:0xf26e6"
          
          
group.long  0x1ec4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_55, IRIDIX_LUT_REGISTER_55 RESET:0xf3ac6"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_55_ASYMMETRY_LUT_REG55_SEGMENT0 ,ASYMMETRY_LUT_REG55_SEGMENT0 RESET:0xf3ac6"
          
          
group.long  0x1ec8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_56, IRIDIX_LUT_REGISTER_56 RESET:0xf4f0e"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_56_ASYMMETRY_LUT_REG56_SEGMENT0 ,ASYMMETRY_LUT_REG56_SEGMENT0 RESET:0xf4f0e"
          
          
group.long  0x1ecc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_57, IRIDIX_LUT_REGISTER_57 RESET:0xf63b6"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_57_ASYMMETRY_LUT_REG57_SEGMENT0 ,ASYMMETRY_LUT_REG57_SEGMENT0 RESET:0xf63b6"
          
          
group.long  0x1ed0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_58, IRIDIX_LUT_REGISTER_58 RESET:0xf78c7"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_58_ASYMMETRY_LUT_REG58_SEGMENT0 ,ASYMMETRY_LUT_REG58_SEGMENT0 RESET:0xf78c7"
          
          
group.long  0x1ed4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_59, IRIDIX_LUT_REGISTER_59 RESET:0xf8e47"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_59_ASYMMETRY_LUT_REG59_SEGMENT0 ,ASYMMETRY_LUT_REG59_SEGMENT0 RESET:0xf8e47"
          
          
group.long  0x1ed8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_60, IRIDIX_LUT_REGISTER_60 RESET:0xfa437"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_60_ASYMMETRY_LUT_REG60_SEGMENT0 ,ASYMMETRY_LUT_REG60_SEGMENT0 RESET:0xfa437"
          
          
group.long  0x1edc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_61, IRIDIX_LUT_REGISTER_61 RESET:0xfba9f"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_61_ASYMMETRY_LUT_REG61_SEGMENT0 ,ASYMMETRY_LUT_REG61_SEGMENT0 RESET:0xfba9f"
          
          
group.long  0x1ee0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_62, IRIDIX_LUT_REGISTER_62 RESET:0xfd18f"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_62_ASYMMETRY_LUT_REG62_SEGMENT0 ,ASYMMETRY_LUT_REG62_SEGMENT0 RESET:0xfd18f"
          
          
group.long  0x1ee4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_63, IRIDIX_LUT_REGISTER_63 RESET:0xfe8ff"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_63_ASYMMETRY_LUT_REG63_SEGMENT0 ,ASYMMETRY_LUT_REG63_SEGMENT0 RESET:0xfe8ff"
          
          
group.long  0x1ee8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_64, IRIDIX_LUT_REGISTER_64 RESET:0xfffff"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_64_ASYMMETRY_LUT_REG64_SEGMENT0 ,ASYMMETRY_LUT_REG64_SEGMENT0 RESET:0xfffff"
          
          
group.long  0x1eec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_65, IRIDIX_LUT_REGISTER_65 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_65_GLOBALTM_X_LUT_REG0_SEGMENT0 ,GLOBALTM_X_LUT_REG0_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ef0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_66, IRIDIX_LUT_REGISTER_66 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_66_GLOBALTM_X_LUT_REG1_SEGMENT0 ,GLOBALTM_X_LUT_REG1_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ef4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_67, IRIDIX_LUT_REGISTER_67 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_67_GLOBALTM_X_LUT_REG2_SEGMENT0 ,GLOBALTM_X_LUT_REG2_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ef8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_68, IRIDIX_LUT_REGISTER_68 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_68_GLOBALTM_X_LUT_REG3_SEGMENT0 ,GLOBALTM_X_LUT_REG3_SEGMENT0 RESET:0x0"
          
          
group.long  0x1efc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_69, IRIDIX_LUT_REGISTER_69 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_69_GLOBALTM_X_LUT_REG4_SEGMENT0 ,GLOBALTM_X_LUT_REG4_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f00++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_70, IRIDIX_LUT_REGISTER_70 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_70_GLOBALTM_X_LUT_REG5_SEGMENT0 ,GLOBALTM_X_LUT_REG5_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f04++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_71, IRIDIX_LUT_REGISTER_71 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_71_GLOBALTM_X_LUT_REG6_SEGMENT0 ,GLOBALTM_X_LUT_REG6_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f08++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_72, IRIDIX_LUT_REGISTER_72 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_72_GLOBALTM_X_LUT_REG7_SEGMENT0 ,GLOBALTM_X_LUT_REG7_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f0c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_73, IRIDIX_LUT_REGISTER_73 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_73_GLOBALTM_X_LUT_REG8_SEGMENT0 ,GLOBALTM_X_LUT_REG8_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f10++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_74, IRIDIX_LUT_REGISTER_74 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_74_GLOBALTM_X_LUT_REG9_SEGMENT0 ,GLOBALTM_X_LUT_REG9_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f14++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_75, IRIDIX_LUT_REGISTER_75 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_75_GLOBALTM_X_LUT_REG10_SEGMENT0 ,GLOBALTM_X_LUT_REG10_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f18++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_76, IRIDIX_LUT_REGISTER_76 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_76_GLOBALTM_X_LUT_REG11_SEGMENT0 ,GLOBALTM_X_LUT_REG11_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f1c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_77, IRIDIX_LUT_REGISTER_77 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_77_GLOBALTM_X_LUT_REG12_SEGMENT0 ,GLOBALTM_X_LUT_REG12_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f20++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_78, IRIDIX_LUT_REGISTER_78 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_78_GLOBALTM_X_LUT_REG13_SEGMENT0 ,GLOBALTM_X_LUT_REG13_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f24++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_79, IRIDIX_LUT_REGISTER_79 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_79_GLOBALTM_X_LUT_REG14_SEGMENT0 ,GLOBALTM_X_LUT_REG14_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f28++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_80, IRIDIX_LUT_REGISTER_80 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_80_GLOBALTM_X_LUT_REG15_SEGMENT0 ,GLOBALTM_X_LUT_REG15_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f2c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_81, IRIDIX_LUT_REGISTER_81 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_81_GLOBALTM_X_LUT_REG16_SEGMENT0 ,GLOBALTM_X_LUT_REG16_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f30++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_82, IRIDIX_LUT_REGISTER_82 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_82_GLOBALTM_X_LUT_REG17_SEGMENT0 ,GLOBALTM_X_LUT_REG17_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f34++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_83, IRIDIX_LUT_REGISTER_83 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_83_GLOBALTM_X_LUT_REG18_SEGMENT0 ,GLOBALTM_X_LUT_REG18_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f38++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_84, IRIDIX_LUT_REGISTER_84 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_84_GLOBALTM_X_LUT_REG19_SEGMENT0 ,GLOBALTM_X_LUT_REG19_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f3c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_85, IRIDIX_LUT_REGISTER_85 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_85_GLOBALTM_X_LUT_REG20_SEGMENT0 ,GLOBALTM_X_LUT_REG20_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f40++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_86, IRIDIX_LUT_REGISTER_86 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_86_GLOBALTM_X_LUT_REG21_SEGMENT0 ,GLOBALTM_X_LUT_REG21_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f44++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_87, IRIDIX_LUT_REGISTER_87 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_87_GLOBALTM_X_LUT_REG22_SEGMENT0 ,GLOBALTM_X_LUT_REG22_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f48++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_88, IRIDIX_LUT_REGISTER_88 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_88_GLOBALTM_X_LUT_REG23_SEGMENT0 ,GLOBALTM_X_LUT_REG23_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f4c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_89, IRIDIX_LUT_REGISTER_89 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_89_GLOBALTM_X_LUT_REG24_SEGMENT0 ,GLOBALTM_X_LUT_REG24_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f50++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_90, IRIDIX_LUT_REGISTER_90 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_90_GLOBALTM_X_LUT_REG25_SEGMENT0 ,GLOBALTM_X_LUT_REG25_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f54++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_91, IRIDIX_LUT_REGISTER_91 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_91_GLOBALTM_X_LUT_REG26_SEGMENT0 ,GLOBALTM_X_LUT_REG26_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f58++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_92, IRIDIX_LUT_REGISTER_92 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_92_GLOBALTM_X_LUT_REG27_SEGMENT0 ,GLOBALTM_X_LUT_REG27_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f5c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_93, IRIDIX_LUT_REGISTER_93 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_93_GLOBALTM_X_LUT_REG28_SEGMENT0 ,GLOBALTM_X_LUT_REG28_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f60++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_94, IRIDIX_LUT_REGISTER_94 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_94_GLOBALTM_X_LUT_REG29_SEGMENT0 ,GLOBALTM_X_LUT_REG29_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f64++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_95, IRIDIX_LUT_REGISTER_95 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_95_GLOBALTM_X_LUT_REG30_SEGMENT0 ,GLOBALTM_X_LUT_REG30_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f68++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_96, IRIDIX_LUT_REGISTER_96 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_96_GLOBALTM_X_LUT_REG31_SEGMENT0 ,GLOBALTM_X_LUT_REG31_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f6c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_97, IRIDIX_LUT_REGISTER_97 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_97_GLOBALTM_X_LUT_REG32_SEGMENT0 ,GLOBALTM_X_LUT_REG32_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f70++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_98, IRIDIX_LUT_REGISTER_98 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_98_GLOBALTM_Y_LUT_REG0_SEGMENT0 ,GLOBALTM_Y_LUT_REG0_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_99, IRIDIX_LUT_REGISTER_99 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_99_GLOBALTM_Y_LUT_REG1_SEGMENT0 ,GLOBALTM_Y_LUT_REG1_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f78++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_100, IRIDIX_LUT_REGISTER_100 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_100_GLOBALTM_Y_LUT_REG2_SEGMENT0 ,GLOBALTM_Y_LUT_REG2_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f7c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_101, IRIDIX_LUT_REGISTER_101 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_101_GLOBALTM_Y_LUT_REG3_SEGMENT0 ,GLOBALTM_Y_LUT_REG3_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_102, IRIDIX_LUT_REGISTER_102 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_102_GLOBALTM_Y_LUT_REG4_SEGMENT0 ,GLOBALTM_Y_LUT_REG4_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_103, IRIDIX_LUT_REGISTER_103 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_103_GLOBALTM_Y_LUT_REG5_SEGMENT0 ,GLOBALTM_Y_LUT_REG5_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_104, IRIDIX_LUT_REGISTER_104 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_104_GLOBALTM_Y_LUT_REG6_SEGMENT0 ,GLOBALTM_Y_LUT_REG6_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_105, IRIDIX_LUT_REGISTER_105 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_105_GLOBALTM_Y_LUT_REG7_SEGMENT0 ,GLOBALTM_Y_LUT_REG7_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f90++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_106, IRIDIX_LUT_REGISTER_106 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_106_GLOBALTM_Y_LUT_REG8_SEGMENT0 ,GLOBALTM_Y_LUT_REG8_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_107, IRIDIX_LUT_REGISTER_107 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_107_GLOBALTM_Y_LUT_REG9_SEGMENT0 ,GLOBALTM_Y_LUT_REG9_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_108, IRIDIX_LUT_REGISTER_108 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_108_GLOBALTM_Y_LUT_REG10_SEGMENT0 ,GLOBALTM_Y_LUT_REG10_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_109, IRIDIX_LUT_REGISTER_109 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_109_GLOBALTM_Y_LUT_REG11_SEGMENT0 ,GLOBALTM_Y_LUT_REG11_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fa0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_110, IRIDIX_LUT_REGISTER_110 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_110_GLOBALTM_Y_LUT_REG12_SEGMENT0 ,GLOBALTM_Y_LUT_REG12_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fa4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_111, IRIDIX_LUT_REGISTER_111 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_111_GLOBALTM_Y_LUT_REG13_SEGMENT0 ,GLOBALTM_Y_LUT_REG13_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fa8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_112, IRIDIX_LUT_REGISTER_112 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_112_GLOBALTM_Y_LUT_REG14_SEGMENT0 ,GLOBALTM_Y_LUT_REG14_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_113, IRIDIX_LUT_REGISTER_113 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_113_GLOBALTM_Y_LUT_REG15_SEGMENT0 ,GLOBALTM_Y_LUT_REG15_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fb0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_114, IRIDIX_LUT_REGISTER_114 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_114_GLOBALTM_Y_LUT_REG16_SEGMENT0 ,GLOBALTM_Y_LUT_REG16_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fb4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_115, IRIDIX_LUT_REGISTER_115 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_115_GLOBALTM_Y_LUT_REG17_SEGMENT0 ,GLOBALTM_Y_LUT_REG17_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fb8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_116, IRIDIX_LUT_REGISTER_116 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_116_GLOBALTM_Y_LUT_REG18_SEGMENT0 ,GLOBALTM_Y_LUT_REG18_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fbc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_117, IRIDIX_LUT_REGISTER_117 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_117_GLOBALTM_Y_LUT_REG19_SEGMENT0 ,GLOBALTM_Y_LUT_REG19_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fc0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_118, IRIDIX_LUT_REGISTER_118 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_118_GLOBALTM_Y_LUT_REG20_SEGMENT0 ,GLOBALTM_Y_LUT_REG20_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fc4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_119, IRIDIX_LUT_REGISTER_119 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_119_GLOBALTM_Y_LUT_REG21_SEGMENT0 ,GLOBALTM_Y_LUT_REG21_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fc8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_120, IRIDIX_LUT_REGISTER_120 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_120_GLOBALTM_Y_LUT_REG22_SEGMENT0 ,GLOBALTM_Y_LUT_REG22_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fcc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_121, IRIDIX_LUT_REGISTER_121 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_121_GLOBALTM_Y_LUT_REG23_SEGMENT0 ,GLOBALTM_Y_LUT_REG23_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fd0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_122, IRIDIX_LUT_REGISTER_122 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_122_GLOBALTM_Y_LUT_REG24_SEGMENT0 ,GLOBALTM_Y_LUT_REG24_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fd4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_123, IRIDIX_LUT_REGISTER_123 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_123_GLOBALTM_Y_LUT_REG25_SEGMENT0 ,GLOBALTM_Y_LUT_REG25_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fd8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_124, IRIDIX_LUT_REGISTER_124 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_124_GLOBALTM_Y_LUT_REG26_SEGMENT0 ,GLOBALTM_Y_LUT_REG26_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fdc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_125, IRIDIX_LUT_REGISTER_125 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_125_GLOBALTM_Y_LUT_REG27_SEGMENT0 ,GLOBALTM_Y_LUT_REG27_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fe0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_126, IRIDIX_LUT_REGISTER_126 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_126_GLOBALTM_Y_LUT_REG28_SEGMENT0 ,GLOBALTM_Y_LUT_REG28_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fe4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_127, IRIDIX_LUT_REGISTER_127 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_127_GLOBALTM_Y_LUT_REG29_SEGMENT0 ,GLOBALTM_Y_LUT_REG29_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fe8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_128, IRIDIX_LUT_REGISTER_128 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_128_GLOBALTM_Y_LUT_REG30_SEGMENT0 ,GLOBALTM_Y_LUT_REG30_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_129, IRIDIX_LUT_REGISTER_129 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_129_GLOBALTM_Y_LUT_REG31_SEGMENT0 ,GLOBALTM_Y_LUT_REG31_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ff0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_130, IRIDIX_LUT_REGISTER_130 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_IRIDIX_LUT_REGISTER_130_GLOBALTM_Y_LUT_REG32_SEGMENT0 ,GLOBALTM_Y_LUT_REG32_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ff4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_0, DEMOSAIC_RGB_REGISTER_0 RESET:0xad"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_0_UU_SLOPE ,UU_SLOPE RESET:0xad"
          
          
group.long  0x2000++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_1, DEMOSAIC_RGB_REGISTER_1 RESET:0xfa"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_1_UU_THRESH ,UU_THRESH RESET:0xfa"
          
          
group.long  0x2018++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_2, DEMOSAIC_RGB_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_2_DMSC_CONFIG ,DMSC_CONFIG RESET:0x0"
          
          
group.long  0x2020++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_3, DEMOSAIC_RGB_REGISTER_3 RESET:0x4080"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_3_FC_SLOPE ,FC_SLOPE RESET:0x80"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_3_FC_ALIAS_SLOPE ,FC_ALIAS_SLOPE RESET:0x40"
          
          
group.long  0x2028++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_4, DEMOSAIC_RGB_REGISTER_4 RESET:0x10101010"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_4_SHARP_ALT_LD ,SHARP_ALT_LD RESET:0x10"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_4_SHARP_ALT_LDU ,SHARP_ALT_LDU RESET:0x10"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_4_SHARP_ALT_LU ,SHARP_ALT_LU RESET:0x10"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_4_SAD_AMP ,SAD_AMP RESET:0x10"
          
group.long  0x202c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_5, DEMOSAIC_RGB_REGISTER_5 RESET:0x1f85"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_5_MIN_D_STRENGTH ,MIN_D_STRENGTH RESET:0x1f85"
          
          
group.long  0x2030++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_6, DEMOSAIC_RGB_REGISTER_6 RESET:0x1f85"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_6_MIN_UD_STRENGTH ,MIN_UD_STRENGTH RESET:0x1f85"
          
          
group.long  0x2038++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_7, DEMOSAIC_RGB_REGISTER_7 RESET:0xad"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_7_UU_SH_SLOPE ,UU_SH_SLOPE RESET:0xad"
          
          
group.long  0x203c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_8, DEMOSAIC_RGB_REGISTER_8 RESET:0xfa"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_8_UU_SH_THRESH ,UU_SH_THRESH RESET:0xfa"
          
          
group.long  0x2044++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_9, DEMOSAIC_RGB_REGISTER_9 RESET:0x3330333"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_9_MAX_D_STRENGTH ,MAX_D_STRENGTH RESET:0x333"
          
          
         hexmask.long 0x00 16.--28. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_9_MAX_UD_STRENGTH ,MAX_UD_STRENGTH RESET:0x333"
          
          
group.long  0x2048++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_10, DEMOSAIC_RGB_REGISTER_10 RESET:0x8"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_10_LUMA_THRESH_LOW_D ,LUMA_THRESH_LOW_D RESET:0x8"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_10_LUMA_OFFSET_LOW_D ,LUMA_OFFSET_LOW_D RESET:0x0"
          
          
group.long  0x204c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_11, DEMOSAIC_RGB_REGISTER_11 RESET:0x4000"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_11_LUMA_SLOPE_LOW_D ,LUMA_SLOPE_LOW_D RESET:0x4000"
          
          
group.long  0x2050++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_12, DEMOSAIC_RGB_REGISTER_12 RESET:0xfa00000"
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_12_LUMA_THRESH_HIGH_D ,LUMA_THRESH_HIGH_D RESET:0xfa0"
          
          
group.long  0x2054++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_13, DEMOSAIC_RGB_REGISTER_13 RESET:0x4000"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_13_LUMA_SLOPE_HIGH_D ,LUMA_SLOPE_HIGH_D RESET:0x4000"
          
          
group.long  0x2058++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_14, DEMOSAIC_RGB_REGISTER_14 RESET:0x8"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_14_LUMA_THRESH_LOW_UD ,LUMA_THRESH_LOW_UD RESET:0x8"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_14_LUMA_OFFSET_LOW_UD ,LUMA_OFFSET_LOW_UD RESET:0x0"
          
          
group.long  0x205c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_15, DEMOSAIC_RGB_REGISTER_15 RESET:0x4000"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_15_LUMA_SLOPE_LOW_UD ,LUMA_SLOPE_LOW_UD RESET:0x4000"
          
          
group.long  0x2060++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_16, DEMOSAIC_RGB_REGISTER_16 RESET:0xfa0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_16_LUMA_THRESH_HIGH_UD ,LUMA_THRESH_HIGH_UD RESET:0xfa0"
          
          
group.long  0x2064++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_17, DEMOSAIC_RGB_REGISTER_17 RESET:0x4000"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DEMOSAIC_RGB_REGISTER_17_LUMA_SLOPE_HIGH_UD ,LUMA_SLOPE_HIGH_UD RESET:0x4000"
          
          
group.long  0x2140++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_0, PF_CORRECTION_REGISTER_0 RESET:0x1"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_0_USE_COLOR_CORRECTED_RGB ,USE_COLOR_CORRECTED_RGB RESET:0x1"
          
          
group.long  0x2144++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_1, PF_CORRECTION_REGISTER_1 RESET:0x200"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_1_HUE_STRENGTH ,HUE_STRENGTH RESET:0x200"
          
          
group.long  0x2148++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_2, PF_CORRECTION_REGISTER_2 RESET:0x4000200"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_2_SAT_STRENGTH ,SAT_STRENGTH RESET:0x200"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_2_LUMA_STRENGTH ,LUMA_STRENGTH RESET:0x400"
          
          
group.long  0x214c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_3, PF_CORRECTION_REGISTER_3 RESET:0x400"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_3_PURPLE_STRENGTH ,PURPLE_STRENGTH RESET:0x400"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_3_SATURATION_STRENGTH ,SATURATION_STRENGTH RESET:0x0"
          
          
group.long  0x2150++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_4, PF_CORRECTION_REGISTER_4 RESET:0xf8f"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_4_OFF_CENTER_MULT ,OFF_CENTER_MULT RESET:0xf8f"
          
          
group.long  0x2154++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_5, PF_CORRECTION_REGISTER_5 RESET:0x2800168"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_5_CENTER_X ,CENTER_X RESET:0x168"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_5_CENTER_Y ,CENTER_Y RESET:0x280"
          
group.long  0x2158++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_6, PF_CORRECTION_REGISTER_6 RESET:0x1cb"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_6_CCM_COEFF_RR ,CCM_COEFF_RR RESET:0x1cb"
          
          
group.long  0x215c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_7, PF_CORRECTION_REGISTER_7 RESET:0x10c1"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_7_CCM_COEFF_RG ,CCM_COEFF_RG RESET:0x10c1"
          
          
group.long  0x2160++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_8, PF_CORRECTION_REGISTER_8 RESET:0x100a"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_8_CCM_COEFF_RB ,CCM_COEFF_RB RESET:0x100a"
          
          
group.long  0x2164++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_9, PF_CORRECTION_REGISTER_9 RESET:0x1028"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_9_CCM_COEFF_GR ,CCM_COEFF_GR RESET:0x1028"
          
          
group.long  0x2168++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_10, PF_CORRECTION_REGISTER_10 RESET:0x16d"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_10_CCM_COEFF_GG ,CCM_COEFF_GG RESET:0x16d"
          
          
group.long  0x216c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_11, PF_CORRECTION_REGISTER_11 RESET:0x1045"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_11_CCM_COEFF_GB ,CCM_COEFF_GB RESET:0x1045"
          
          
group.long  0x2170++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_12, PF_CORRECTION_REGISTER_12 RESET:0x12"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_12_CCM_COEFF_BR ,CCM_COEFF_BR RESET:0x12"
          
          
group.long  0x2174++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_13, PF_CORRECTION_REGISTER_13 RESET:0x10ac"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_13_CCM_COEFF_BG ,CCM_COEFF_BG RESET:0x10ac"
          
          
group.long  0x2178++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_14, PF_CORRECTION_REGISTER_14 RESET:0x19a"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_14_CCM_COEFF_BB ,CCM_COEFF_BB RESET:0x19a"
          
          
group.long  0x217c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_15, PF_CORRECTION_REGISTER_15 RESET:0x1"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_15_SAD_SLOPE ,SAD_SLOPE RESET:0x1"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_15_SAD_OFFSET ,SAD_OFFSET RESET:0x0"
          
          
group.long  0x2180++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_16, PF_CORRECTION_REGISTER_16 RESET:0x148"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_16_SAD_THRESH ,SAD_THRESH RESET:0x148"
          
          
group.long  0x2184++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_17, PF_CORRECTION_REGISTER_17 RESET:0x131"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_17_HUE_LOW_SLOPE ,HUE_LOW_SLOPE RESET:0x131"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_17_HUE_LOW_OFFSET ,HUE_LOW_OFFSET RESET:0x0"
          
          
group.long  0x2188++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_18, PF_CORRECTION_REGISTER_18 RESET:0x733"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_18_HUE_LOW_THRESH ,HUE_LOW_THRESH RESET:0x733"
          
          
group.long  0x218c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_19, PF_CORRECTION_REGISTER_19 RESET:0x855"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_19_HUE_HIGH_SLOPE ,HUE_HIGH_SLOPE RESET:0x855"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_19_HUE_HIGH_OFFSET ,HUE_HIGH_OFFSET RESET:0x0"
          
          
group.long  0x2190++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_20, PF_CORRECTION_REGISTER_20 RESET:0x8e1"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_20_HUE_HIGH_THRESH ,HUE_HIGH_THRESH RESET:0x8e1"
          
          
group.long  0x2194++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_21, PF_CORRECTION_REGISTER_21 RESET:0x21"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_21_SAT_LOW_SLOPE ,SAT_LOW_SLOPE RESET:0x21"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_21_SAT_LOW_OFFSET ,SAT_LOW_OFFSET RESET:0x0"
          
          
group.long  0x2198++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_22, PF_CORRECTION_REGISTER_22 RESET:0xa4"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_22_SAT_LOW_THRESH ,SAT_LOW_THRESH RESET:0xa4"
          
          
group.long  0x219c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_23, PF_CORRECTION_REGISTER_23 RESET:0xfff0000"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_23_SAT_HIGH_SLOPE ,SAT_HIGH_SLOPE RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_23_SAT_HIGH_OFFSET ,SAT_HIGH_OFFSET RESET:0xfff"
          
          
group.long  0x21a0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_24, PF_CORRECTION_REGISTER_24 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_24_SAT_HIGH_THRESH ,SAT_HIGH_THRESH RESET:0x0"
          
          
group.long  0x21a4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_25, PF_CORRECTION_REGISTER_25 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_25_LUMA1_LOW_SLOPE ,LUMA1_LOW_SLOPE RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_25_LUMA1_LOW_OFFSET ,LUMA1_LOW_OFFSET RESET:0x0"
          
          
group.long  0x21a8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_26, PF_CORRECTION_REGISTER_26 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_26_LUMA1_LOW_THRESH ,LUMA1_LOW_THRESH RESET:0x0"
          
          
group.long  0x21ac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_27, PF_CORRECTION_REGISTER_27 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_27_LUMA1_HIGH_SLOPE ,LUMA1_HIGH_SLOPE RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_27_LUMA1_HIGH_OFFSET ,LUMA1_HIGH_OFFSET RESET:0x0"
          
          
group.long  0x21b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_28, PF_CORRECTION_REGISTER_28 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_28_LUMA1_HIGH_THRESH ,LUMA1_HIGH_THRESH RESET:0x0"
          
          
group.long  0x21b4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_29, PF_CORRECTION_REGISTER_29 RESET:0x140"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_29_LUMA2_LOW_SLOPE ,LUMA2_LOW_SLOPE RESET:0x140"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_29_LUMA2_LOW_OFFSET ,LUMA2_LOW_OFFSET RESET:0x0"
          
          
group.long  0x21b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_30, PF_CORRECTION_REGISTER_30 RESET:0xcd"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_30_LUMA2_LOW_THRESH ,LUMA2_LOW_THRESH RESET:0xcd"
          
          
group.long  0x21bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_31, PF_CORRECTION_REGISTER_31 RESET:0x26"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_31_LUMA2_HIGH_SLOPE ,LUMA2_HIGH_SLOPE RESET:0x26"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_31_LUMA2_HIGH_OFFSET ,LUMA2_HIGH_OFFSET RESET:0x0"
          
          
group.long  0x21c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_32, PF_CORRECTION_REGISTER_32 RESET:0x1a0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_32_LUMA2_HIGH_THRESH ,LUMA2_HIGH_THRESH RESET:0x1a0"
          
          
group.long  0x21c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_33, PF_CORRECTION_REGISTER_33 RESET:0x24"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_33_HSL_SLOPE ,HSL_SLOPE RESET:0x24"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_33_HSL_OFFSET ,HSL_OFFSET RESET:0x0"
          
          
group.long  0x21c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_34, PF_CORRECTION_REGISTER_34 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_34_HSL_THRESH ,HSL_THRESH RESET:0x0"
          
          
group.long  0x21cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_35, PF_CORRECTION_REGISTER_35 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_REGISTER_35_DEBUG_SEL ,DEBUG_SEL RESET:0x0"
          
          
group.long  0x21d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_0, PF_CORRECTION_SHADING_REGISTER_0 RESET:0xffffffff"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_0_SHADING_LUT_REG0_SEGMENT0 ,SHADING_LUT_REG0_SEGMENT0 RESET:0xff"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_0_SHADING_LUT_REG0_SEGMENT1 ,SHADING_LUT_REG0_SEGMENT1 RESET:0xff"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_0_SHADING_LUT_REG0_SEGMENT2 ,SHADING_LUT_REG0_SEGMENT2 RESET:0xff"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_0_SHADING_LUT_REG0_SEGMENT3 ,SHADING_LUT_REG0_SEGMENT3 RESET:0xff"
          
group.long  0x21d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_1, PF_CORRECTION_SHADING_REGISTER_1 RESET:0xffffffff"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_1_SHADING_LUT_REG1_SEGMENT0 ,SHADING_LUT_REG1_SEGMENT0 RESET:0xff"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_1_SHADING_LUT_REG1_SEGMENT1 ,SHADING_LUT_REG1_SEGMENT1 RESET:0xff"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_1_SHADING_LUT_REG1_SEGMENT2 ,SHADING_LUT_REG1_SEGMENT2 RESET:0xff"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_1_SHADING_LUT_REG1_SEGMENT3 ,SHADING_LUT_REG1_SEGMENT3 RESET:0xff"
          
group.long  0x21d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_2, PF_CORRECTION_SHADING_REGISTER_2 RESET:0xffffffff"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_2_SHADING_LUT_REG2_SEGMENT0 ,SHADING_LUT_REG2_SEGMENT0 RESET:0xff"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_2_SHADING_LUT_REG2_SEGMENT1 ,SHADING_LUT_REG2_SEGMENT1 RESET:0xff"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_2_SHADING_LUT_REG2_SEGMENT2 ,SHADING_LUT_REG2_SEGMENT2 RESET:0xff"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_2_SHADING_LUT_REG2_SEGMENT3 ,SHADING_LUT_REG2_SEGMENT3 RESET:0xff"
          
group.long  0x21dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_3, PF_CORRECTION_SHADING_REGISTER_3 RESET:0xffffffff"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_3_SHADING_LUT_REG3_SEGMENT0 ,SHADING_LUT_REG3_SEGMENT0 RESET:0xff"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_3_SHADING_LUT_REG3_SEGMENT1 ,SHADING_LUT_REG3_SEGMENT1 RESET:0xff"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_3_SHADING_LUT_REG3_SEGMENT2 ,SHADING_LUT_REG3_SEGMENT2 RESET:0xff"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_3_SHADING_LUT_REG3_SEGMENT3 ,SHADING_LUT_REG3_SEGMENT3 RESET:0xff"
          
group.long  0x21e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_4, PF_CORRECTION_SHADING_REGISTER_4 RESET:0xffffffff"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_4_SHADING_LUT_REG4_SEGMENT0 ,SHADING_LUT_REG4_SEGMENT0 RESET:0xff"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_4_SHADING_LUT_REG4_SEGMENT1 ,SHADING_LUT_REG4_SEGMENT1 RESET:0xff"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_4_SHADING_LUT_REG4_SEGMENT2 ,SHADING_LUT_REG4_SEGMENT2 RESET:0xff"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_4_SHADING_LUT_REG4_SEGMENT3 ,SHADING_LUT_REG4_SEGMENT3 RESET:0xff"
          
group.long  0x21e4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_5, PF_CORRECTION_SHADING_REGISTER_5 RESET:0xffffffff"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_5_SHADING_LUT_REG5_SEGMENT0 ,SHADING_LUT_REG5_SEGMENT0 RESET:0xff"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_5_SHADING_LUT_REG5_SEGMENT1 ,SHADING_LUT_REG5_SEGMENT1 RESET:0xff"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_5_SHADING_LUT_REG5_SEGMENT2 ,SHADING_LUT_REG5_SEGMENT2 RESET:0xff"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_5_SHADING_LUT_REG5_SEGMENT3 ,SHADING_LUT_REG5_SEGMENT3 RESET:0xff"
          
group.long  0x21e8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_6, PF_CORRECTION_SHADING_REGISTER_6 RESET:0xffffffff"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_6_SHADING_LUT_REG6_SEGMENT0 ,SHADING_LUT_REG6_SEGMENT0 RESET:0xff"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_6_SHADING_LUT_REG6_SEGMENT1 ,SHADING_LUT_REG6_SEGMENT1 RESET:0xff"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_6_SHADING_LUT_REG6_SEGMENT2 ,SHADING_LUT_REG6_SEGMENT2 RESET:0xff"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_6_SHADING_LUT_REG6_SEGMENT3 ,SHADING_LUT_REG6_SEGMENT3 RESET:0xff"
          
group.long  0x21ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_7, PF_CORRECTION_SHADING_REGISTER_7 RESET:0xffffffff"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_7_SHADING_LUT_REG7_SEGMENT0 ,SHADING_LUT_REG7_SEGMENT0 RESET:0xff"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_7_SHADING_LUT_REG7_SEGMENT1 ,SHADING_LUT_REG7_SEGMENT1 RESET:0xff"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_7_SHADING_LUT_REG7_SEGMENT2 ,SHADING_LUT_REG7_SEGMENT2 RESET:0xff"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_PF_CORRECTION_SHADING_REGISTER_7_SHADING_LUT_REG7_SEGMENT3 ,SHADING_LUT_REG7_SEGMENT3 RESET:0xff"
          
group.long  0x21f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_0, CCM_REGISTER_0 RESET:0x1"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_0_ENABLE ,ENABLE RESET:0x1"
          
          
group.long  0x21f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_1, CCM_REGISTER_1 RESET:0x100"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_1_COEFFT_R_R ,COEFFT_R-R RESET:0x100"
          
          
group.long  0x21fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_2, CCM_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_2_COEFFT_R_G ,COEFFT_R-G RESET:0x0"
          
          
group.long  0x2200++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_3, CCM_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_3_COEFFT_R_B ,COEFFT_R-B RESET:0x0"
          
          
group.long  0x2208++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_4, CCM_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_4_COEFFT_G_R ,COEFFT_G-R RESET:0x0"
          
          
group.long  0x220c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_5, CCM_REGISTER_5 RESET:0x100"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_5_COEFFT_G_G ,COEFFT_G-G RESET:0x100"
          
          
group.long  0x2210++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_6, CCM_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_6_COEFFT_G_B ,COEFFT_G-B RESET:0x0"
          
          
group.long  0x2218++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_7, CCM_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_7_COEFFT_B_R ,COEFFT_B-R RESET:0x0"
          
          
group.long  0x221c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_8, CCM_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_8_COEFFT_B_G ,COEFFT_B-G RESET:0x0"
          
          
group.long  0x2220++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_9, CCM_REGISTER_9 RESET:0x100"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_9_COEFFT_B_B ,COEFFT_B-B RESET:0x100"
          
          
group.long  0x2228++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_10, CCM_REGISTER_10 RESET:0x100"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_10_COEFFT_WB_R ,COEFFT_WB_R RESET:0x100"
          
          
group.long  0x222c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_11, CCM_REGISTER_11 RESET:0x100"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_11_COEFFT_WB_G ,COEFFT_WB_G RESET:0x100"
          
          
group.long  0x2230++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_12, CCM_REGISTER_12 RESET:0x100"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_12_COEFFT_WB_B ,COEFFT_WB_B RESET:0x100"
          
          
group.long  0x2238++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_13, CCM_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_13_COEFFT_FOG_OFFSET_R ,COEFFT_FOG_OFFSET_R RESET:0x0"
          
          
group.long  0x223c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_14, CCM_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_14_COEFFT_FOG_OFFSET_G ,COEFFT_FOG_OFFSET_G RESET:0x0"
          
          
group.long  0x2240++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_15, CCM_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CCM_REGISTER_15_COEFFT_FOG_OFFSET_B ,COEFFT_FOG_OFFSET_B RESET:0x0"
          
          
group.long  0x2248++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_0, CNR_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_0_SQUARE_ROOT_ENABLE ,SQUARE_ROOT_ENABLE RESET:0x0"
          
          
group.long  0x224c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_1, CNR_REGISTER_1 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_1_ENABLE ,ENABLE RESET:0x0"
          
          
group.long  0x2250++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_2, CNR_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_2_DEBUG_REG ,DEBUG_REG RESET:0x0"
          
          
group.long  0x2258++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_3, CNR_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_3_DELTA_FACTOR ,DELTA_FACTOR RESET:0x0"
          
          
group.long  0x225c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_4, CNR_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_4_UV_SEG1_MIN ,UV_SEG1_MIN RESET:0x0"
          
          
group.long  0x2260++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_5, CNR_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_5_UV_SEG1_OFFSET ,UV_SEG1_OFFSET RESET:0x0"
          
          
group.long  0x2264++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_6, CNR_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_6_UV_SEG1_SLOPE ,UV_SEG1_SLOPE RESET:0x0"
          
          
group.long  0x2268++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_7, CNR_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_7_UV_MEAN_OFFSET ,UV_MEAN_OFFSET RESET:0x0"
          
          
group.long  0x226c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_8, CNR_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_8_UV_MEAN_SLOPE ,UV_MEAN_SLOPE RESET:0x0"
          
          
group.long  0x2270++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_9, CNR_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_9_UV_VAR_OFFSET ,UV_VAR_OFFSET RESET:0x0"
          
          
group.long  0x2274++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_10, CNR_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_10_UV_VAR_SLOPE ,UV_VAR_SLOPE RESET:0x0"
          
          
group.long  0x2278++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_11, CNR_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_11_UV_DELTA_OFFSET ,UV_DELTA_OFFSET RESET:0x0"
          
          
group.long  0x227c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_12, CNR_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_CNR_REGISTER_12_UV_DELTA_SLOPE ,UV_DELTA_SLOPE RESET:0x0"
          
          
group.long  0x23ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TARGETADDR_REGISTER_0, TARGETADDR_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TARGETADDR_REGISTER_0_TARGET1_ADDR ,TARGET1_ADDR RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_TARGETADDR_REGISTER_0_TARGET2_ADDR ,TARGET2_ADDR RESET:0x0"
          
group.long  0x23f0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AEXP_REGISTER_0, METERING_AEXP_REGISTER_0 RESET:0x10"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AEXP_REGISTER_0_HIST_THRESH_0_1 ,HIST_THRESH_0_1 RESET:0x10"
          
          
group.long  0x23f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AEXP_REGISTER_1, METERING_AEXP_REGISTER_1 RESET:0x20"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AEXP_REGISTER_1_HIST_THRESH_1_2 ,HIST_THRESH_1_2 RESET:0x20"
          
          
group.long  0x23f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AEXP_REGISTER_2, METERING_AEXP_REGISTER_2 RESET:0xd0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AEXP_REGISTER_2_HIST_THRESH_3_4 ,HIST_THRESH_3_4 RESET:0xd0"
          
          
group.long  0x23fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AEXP_REGISTER_3, METERING_AEXP_REGISTER_3 RESET:0xe0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AEXP_REGISTER_3_HIST_THRESH_4_5 ,HIST_THRESH_4_5 RESET:0xe0"
          
          
group.long  0x2410++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AEXP_REGISTER_4, METERING_AEXP_REGISTER_4 RESET:0xf0f"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AEXP_REGISTER_4_NODES_USED_HORIZ ,NODES_USED_HORIZ RESET:0xf"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AEXP_REGISTER_4_NODES_USED_VERT ,NODES_USED_VERT RESET:0xf"
          
          
group.long  0x2414++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_0, METERING_AWB_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_0_STATS_MODE ,STATS_MODE RESET:0x0"
          
          
group.long  0x2418++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_1, METERING_AWB_REGISTER_1 RESET:0x3ff"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_1_WHITE_LEVEL_AWB ,WHITE_LEVEL_AWB RESET:0x3ff"
          
          
group.long  0x241c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_2, METERING_AWB_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_2_BLACK_LEVEL_AWB ,BLACK_LEVEL_AWB RESET:0x0"
          
          
group.long  0x2420++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_3, METERING_AWB_REGISTER_3 RESET:0x1ff"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_3_CR_REF_MAX_AWB ,CR_REF_MAX_AWB RESET:0x1ff"
          
          
group.long  0x2424++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_4, METERING_AWB_REGISTER_4 RESET:0x40"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_4_CR_REF_MIN_AWB ,CR_REF_MIN_AWB RESET:0x40"
          
          
group.long  0x2428++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_5, METERING_AWB_REGISTER_5 RESET:0x1ff"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_5_CB_REF_MAX_AWB ,CB_REF_MAX_AWB RESET:0x1ff"
          
          
group.long  0x242c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_6, METERING_AWB_REGISTER_6 RESET:0x40"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_6_CB_REF_MIN_AWB ,CB_REF_MIN_AWB RESET:0x40"
          
          
group.long  0x243c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_7, METERING_AWB_REGISTER_7 RESET:0xf0f"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_7_NODES_USED_HORIZ ,NODES_USED_HORIZ RESET:0xf"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_7_NODES_USED_VERT ,NODES_USED_VERT RESET:0xf"
          
          
group.long  0x2440++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_8, METERING_AWB_REGISTER_8 RESET:0x1ff"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_8_CR_REF_HIGH_AWB ,CR_REF_HIGH_AWB RESET:0x1ff"
          
          
group.long  0x2444++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_9, METERING_AWB_REGISTER_9 RESET:0x40"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_9_CR_REF_LOW_AWB ,CR_REF_LOW_AWB RESET:0x40"
          
          
group.long  0x2448++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_10, METERING_AWB_REGISTER_10 RESET:0x1ff"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_10_CB_REF_HIGH_AWB ,CB_REF_HIGH_AWB RESET:0x1ff"
          
          
group.long  0x244c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_11, METERING_AWB_REGISTER_11 RESET:0x40"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AWB_REGISTER_11_CB_REF_LOW_AWB ,CB_REF_LOW_AWB RESET:0x40"
          
          
group.long  0x2880++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_0, METERING_AF_REGISTER_0 RESET:0x77f0000"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_0_ROI_HORIZ_START ,ROI_HORIZ_START RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_0_ROI_HORIZ_END ,ROI_HORIZ_END RESET:0x77f"
          
group.long  0x2884++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_1, METERING_AF_REGISTER_1 RESET:0x4370000"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_1_ROI_VERT_START ,ROI_VERT_START RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_1_ROI_VERT_END ,ROI_VERT_END RESET:0x437"
          
group.long  0x2888++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_2, METERING_AF_REGISTER_2 RESET:0xf0f"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_2_NODES_USED_HORIZ ,NODES_USED_HORIZ RESET:0xf"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_2_NODES_USED_VERT ,NODES_USED_VERT RESET:0xf"
          
          
group.long  0x288c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_3, METERING_AF_REGISTER_3 RESET:0xf"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_3_CHANNEL_MASK ,CHANNEL_MASK RESET:0xf"
          
          
group.long  0x2890++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_4, METERING_AF_REGISTER_4 RESET:0xf000"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_4_BLACK_LEVEL ,BLACK_LEVEL RESET:0xf000"
          
          
group.long  0x2894++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_5, METERING_AF_REGISTER_5 RESET:0x185"
         hexmask.long 0x00 0.--8. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_5_FIR_COEFFS_CENTER ,FIR_COEFFS_CENTER RESET:0x185"
          
          
group.long  0x2898++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_6, METERING_AF_REGISTER_6 RESET:0xc003c003"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_6_FIR_COEFFS_SIDES ,FIR_COEFFS_SIDES RESET:0xc003c003"
          
group.long  0x289c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_7, METERING_AF_REGISTER_7 RESET:0x3"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_7_FIR_COEFFS_SHIFT ,FIR_COEFFS_SHIFT RESET:0x3"
          
          
group.long  0x28a0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_8, METERING_AF_REGISTER_8 RESET:0x1fa6"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_8_AR_COEFFS_HORIZ ,AR_COEFFS_HORIZ RESET:0x1fa6"
          
          
group.long  0x28a4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_9, METERING_AF_REGISTER_9 RESET:0x1faa"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_AF_REGISTER_9_AR_COEFFS_VERT ,AR_COEFFS_VERT RESET:0x1faa"
          
          
group.long  0x28a8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_0, METERING_HIST_AEXP_REGISTER_0 RESET:0x1"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_0_SKIP_X ,SKIP_X RESET:0x1"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_0_OFFSET_X ,OFFSET_X RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_0_SKIP_Y ,SKIP_Y RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_0_OFFSET_Y ,OFFSET_Y RESET:0x0"
          
          
group.long  0x28ac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_1, METERING_HIST_AEXP_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_1_SCALE_BOTTOM ,SCALE_BOTTOM RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_1_SCALE_TOP ,SCALE_TOP RESET:0x0"
          
          
rgroup.long 0x28b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_2, METERING_HIST_AEXP_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_2_TOTAL_PIXELS ,TOTAL_PIXELS RESET:0x0"
          
rgroup.long 0x28b4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_3, METERING_HIST_AEXP_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_3_COUNTED_PIXELS ,COUNTED_PIXELS RESET:0x0"
          
group.long  0x28b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_4, METERING_HIST_AEXP_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_4_PLANE_MODE ,PLANE_MODE RESET:0x0"
          
          
rgroup.long 0x28bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_5, METERING_HIST_AEXP_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_5_PLANE_TOTAL_0 ,PLANE_TOTAL_0 RESET:0x0"
          
rgroup.long 0x28c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_6, METERING_HIST_AEXP_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_6_PLANE_TOTAL_1 ,PLANE_TOTAL_1 RESET:0x0"
          
rgroup.long 0x28c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_7, METERING_HIST_AEXP_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_7_PLANE_TOTAL_2 ,PLANE_TOTAL_2 RESET:0x0"
          
rgroup.long 0x28c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_8, METERING_HIST_AEXP_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_8_PLANE_TOTAL_3 ,PLANE_TOTAL_3 RESET:0x0"
          
rgroup.long 0x28cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_9, METERING_HIST_AEXP_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_9_PLANE_COUNTED_0 ,PLANE_COUNTED_0 RESET:0x0"
          
rgroup.long 0x28d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_10, METERING_HIST_AEXP_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_10_PLANE_COUNTED_1 ,PLANE_COUNTED_1 RESET:0x0"
          
rgroup.long 0x28d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_11, METERING_HIST_AEXP_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_11_PLANE_COUNTED_2 ,PLANE_COUNTED_2 RESET:0x0"
          
rgroup.long 0x28d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_12, METERING_HIST_AEXP_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_12_PLANE_COUNTED_3 ,PLANE_COUNTED_3 RESET:0x0"
          
group.long  0x28dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_13, METERING_HIST_AEXP_REGISTER_13 RESET:0xf0f"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_13_NODES_USED_HORIZ ,NODES_USED_HORIZ RESET:0xf"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_13_NODES_USED_VERT ,NODES_USED_VERT RESET:0xf"
          
          
group.long  0x28e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_14, METERING_HIST_AEXP_REGISTER_14 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT0 ,ZONES_WEIGHT_REG0_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT1 ,ZONES_WEIGHT_REG0_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT2 ,ZONES_WEIGHT_REG0_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT3 ,ZONES_WEIGHT_REG0_SEGMENT3 RESET:0xf"
          
          
group.long  0x28e4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_15, METERING_HIST_AEXP_REGISTER_15 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT0 ,ZONES_WEIGHT_REG1_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT1 ,ZONES_WEIGHT_REG1_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT2 ,ZONES_WEIGHT_REG1_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT3 ,ZONES_WEIGHT_REG1_SEGMENT3 RESET:0xf"
          
          
group.long  0x28e8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_16, METERING_HIST_AEXP_REGISTER_16 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT0 ,ZONES_WEIGHT_REG2_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT1 ,ZONES_WEIGHT_REG2_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT2 ,ZONES_WEIGHT_REG2_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT3 ,ZONES_WEIGHT_REG2_SEGMENT3 RESET:0xf"
          
          
group.long  0x28ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_17, METERING_HIST_AEXP_REGISTER_17 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT0 ,ZONES_WEIGHT_REG3_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT1 ,ZONES_WEIGHT_REG3_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT2 ,ZONES_WEIGHT_REG3_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT3 ,ZONES_WEIGHT_REG3_SEGMENT3 RESET:0xf"
          
          
group.long  0x28f0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_18, METERING_HIST_AEXP_REGISTER_18 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT0 ,ZONES_WEIGHT_REG4_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT1 ,ZONES_WEIGHT_REG4_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT2 ,ZONES_WEIGHT_REG4_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT3 ,ZONES_WEIGHT_REG4_SEGMENT3 RESET:0xf"
          
          
group.long  0x28f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_19, METERING_HIST_AEXP_REGISTER_19 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT0 ,ZONES_WEIGHT_REG5_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT1 ,ZONES_WEIGHT_REG5_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT2 ,ZONES_WEIGHT_REG5_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT3 ,ZONES_WEIGHT_REG5_SEGMENT3 RESET:0xf"
          
          
group.long  0x28f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_20, METERING_HIST_AEXP_REGISTER_20 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT0 ,ZONES_WEIGHT_REG6_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT1 ,ZONES_WEIGHT_REG6_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT2 ,ZONES_WEIGHT_REG6_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT3 ,ZONES_WEIGHT_REG6_SEGMENT3 RESET:0xf"
          
          
group.long  0x28fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_21, METERING_HIST_AEXP_REGISTER_21 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT0 ,ZONES_WEIGHT_REG7_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT1 ,ZONES_WEIGHT_REG7_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT2 ,ZONES_WEIGHT_REG7_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT3 ,ZONES_WEIGHT_REG7_SEGMENT3 RESET:0xf"
          
          
group.long  0x2900++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_22, METERING_HIST_AEXP_REGISTER_22 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT0 ,ZONES_WEIGHT_REG8_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT1 ,ZONES_WEIGHT_REG8_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT2 ,ZONES_WEIGHT_REG8_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT3 ,ZONES_WEIGHT_REG8_SEGMENT3 RESET:0xf"
          
          
group.long  0x2904++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_23, METERING_HIST_AEXP_REGISTER_23 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT0 ,ZONES_WEIGHT_REG9_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT1 ,ZONES_WEIGHT_REG9_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT2 ,ZONES_WEIGHT_REG9_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT3 ,ZONES_WEIGHT_REG9_SEGMENT3 RESET:0xf"
          
          
group.long  0x2908++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_24, METERING_HIST_AEXP_REGISTER_24 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT0 ,ZONES_WEIGHT_REG10_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT1 ,ZONES_WEIGHT_REG10_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT2 ,ZONES_WEIGHT_REG10_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT3 ,ZONES_WEIGHT_REG10_SEGMENT3 RESET:0xf"
          
          
group.long  0x290c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_25, METERING_HIST_AEXP_REGISTER_25 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT0 ,ZONES_WEIGHT_REG11_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT1 ,ZONES_WEIGHT_REG11_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT2 ,ZONES_WEIGHT_REG11_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT3 ,ZONES_WEIGHT_REG11_SEGMENT3 RESET:0xf"
          
          
group.long  0x2910++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_26, METERING_HIST_AEXP_REGISTER_26 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT0 ,ZONES_WEIGHT_REG12_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT1 ,ZONES_WEIGHT_REG12_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT2 ,ZONES_WEIGHT_REG12_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT3 ,ZONES_WEIGHT_REG12_SEGMENT3 RESET:0xf"
          
          
group.long  0x2914++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_27, METERING_HIST_AEXP_REGISTER_27 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT0 ,ZONES_WEIGHT_REG13_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT1 ,ZONES_WEIGHT_REG13_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT2 ,ZONES_WEIGHT_REG13_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT3 ,ZONES_WEIGHT_REG13_SEGMENT3 RESET:0xf"
          
          
group.long  0x2918++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_28, METERING_HIST_AEXP_REGISTER_28 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT0 ,ZONES_WEIGHT_REG14_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT1 ,ZONES_WEIGHT_REG14_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT2 ,ZONES_WEIGHT_REG14_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT3 ,ZONES_WEIGHT_REG14_SEGMENT3 RESET:0xf"
          
          
group.long  0x291c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_29, METERING_HIST_AEXP_REGISTER_29 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT0 ,ZONES_WEIGHT_REG15_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT1 ,ZONES_WEIGHT_REG15_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT2 ,ZONES_WEIGHT_REG15_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT3 ,ZONES_WEIGHT_REG15_SEGMENT3 RESET:0xf"
          
          
group.long  0x2920++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_30, METERING_HIST_AEXP_REGISTER_30 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT0 ,ZONES_WEIGHT_REG16_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT1 ,ZONES_WEIGHT_REG16_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT2 ,ZONES_WEIGHT_REG16_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT3 ,ZONES_WEIGHT_REG16_SEGMENT3 RESET:0xf"
          
          
group.long  0x2924++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_31, METERING_HIST_AEXP_REGISTER_31 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT0 ,ZONES_WEIGHT_REG17_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT1 ,ZONES_WEIGHT_REG17_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT2 ,ZONES_WEIGHT_REG17_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT3 ,ZONES_WEIGHT_REG17_SEGMENT3 RESET:0xf"
          
          
group.long  0x2928++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_32, METERING_HIST_AEXP_REGISTER_32 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT0 ,ZONES_WEIGHT_REG18_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT1 ,ZONES_WEIGHT_REG18_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT2 ,ZONES_WEIGHT_REG18_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT3 ,ZONES_WEIGHT_REG18_SEGMENT3 RESET:0xf"
          
          
group.long  0x292c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_33, METERING_HIST_AEXP_REGISTER_33 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT0 ,ZONES_WEIGHT_REG19_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT1 ,ZONES_WEIGHT_REG19_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT2 ,ZONES_WEIGHT_REG19_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT3 ,ZONES_WEIGHT_REG19_SEGMENT3 RESET:0xf"
          
          
group.long  0x2930++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_34, METERING_HIST_AEXP_REGISTER_34 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT0 ,ZONES_WEIGHT_REG20_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT1 ,ZONES_WEIGHT_REG20_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT2 ,ZONES_WEIGHT_REG20_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT3 ,ZONES_WEIGHT_REG20_SEGMENT3 RESET:0xf"
          
          
group.long  0x2934++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_35, METERING_HIST_AEXP_REGISTER_35 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT0 ,ZONES_WEIGHT_REG21_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT1 ,ZONES_WEIGHT_REG21_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT2 ,ZONES_WEIGHT_REG21_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT3 ,ZONES_WEIGHT_REG21_SEGMENT3 RESET:0xf"
          
          
group.long  0x2938++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_36, METERING_HIST_AEXP_REGISTER_36 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT0 ,ZONES_WEIGHT_REG22_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT1 ,ZONES_WEIGHT_REG22_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT2 ,ZONES_WEIGHT_REG22_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT3 ,ZONES_WEIGHT_REG22_SEGMENT3 RESET:0xf"
          
          
group.long  0x293c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_37, METERING_HIST_AEXP_REGISTER_37 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT0 ,ZONES_WEIGHT_REG23_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT1 ,ZONES_WEIGHT_REG23_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT2 ,ZONES_WEIGHT_REG23_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT3 ,ZONES_WEIGHT_REG23_SEGMENT3 RESET:0xf"
          
          
group.long  0x2940++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_38, METERING_HIST_AEXP_REGISTER_38 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT0 ,ZONES_WEIGHT_REG24_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT1 ,ZONES_WEIGHT_REG24_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT2 ,ZONES_WEIGHT_REG24_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT3 ,ZONES_WEIGHT_REG24_SEGMENT3 RESET:0xf"
          
          
group.long  0x2944++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_39, METERING_HIST_AEXP_REGISTER_39 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT0 ,ZONES_WEIGHT_REG25_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT1 ,ZONES_WEIGHT_REG25_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT2 ,ZONES_WEIGHT_REG25_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT3 ,ZONES_WEIGHT_REG25_SEGMENT3 RESET:0xf"
          
          
group.long  0x2948++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_40, METERING_HIST_AEXP_REGISTER_40 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT0 ,ZONES_WEIGHT_REG26_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT1 ,ZONES_WEIGHT_REG26_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT2 ,ZONES_WEIGHT_REG26_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT3 ,ZONES_WEIGHT_REG26_SEGMENT3 RESET:0xf"
          
          
group.long  0x294c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_41, METERING_HIST_AEXP_REGISTER_41 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT0 ,ZONES_WEIGHT_REG27_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT1 ,ZONES_WEIGHT_REG27_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT2 ,ZONES_WEIGHT_REG27_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT3 ,ZONES_WEIGHT_REG27_SEGMENT3 RESET:0xf"
          
          
group.long  0x2950++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_42, METERING_HIST_AEXP_REGISTER_42 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT0 ,ZONES_WEIGHT_REG28_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT1 ,ZONES_WEIGHT_REG28_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT2 ,ZONES_WEIGHT_REG28_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT3 ,ZONES_WEIGHT_REG28_SEGMENT3 RESET:0xf"
          
          
group.long  0x2954++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_43, METERING_HIST_AEXP_REGISTER_43 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT0 ,ZONES_WEIGHT_REG29_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT1 ,ZONES_WEIGHT_REG29_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT2 ,ZONES_WEIGHT_REG29_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT3 ,ZONES_WEIGHT_REG29_SEGMENT3 RESET:0xf"
          
          
group.long  0x2958++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_44, METERING_HIST_AEXP_REGISTER_44 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT0 ,ZONES_WEIGHT_REG30_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT1 ,ZONES_WEIGHT_REG30_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT2 ,ZONES_WEIGHT_REG30_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT3 ,ZONES_WEIGHT_REG30_SEGMENT3 RESET:0xf"
          
          
group.long  0x295c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_45, METERING_HIST_AEXP_REGISTER_45 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT0 ,ZONES_WEIGHT_REG31_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT1 ,ZONES_WEIGHT_REG31_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT2 ,ZONES_WEIGHT_REG31_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT3 ,ZONES_WEIGHT_REG31_SEGMENT3 RESET:0xf"
          
          
group.long  0x2960++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_46, METERING_HIST_AEXP_REGISTER_46 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT0 ,ZONES_WEIGHT_REG32_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT1 ,ZONES_WEIGHT_REG32_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT2 ,ZONES_WEIGHT_REG32_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT3 ,ZONES_WEIGHT_REG32_SEGMENT3 RESET:0xf"
          
          
group.long  0x2964++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_47, METERING_HIST_AEXP_REGISTER_47 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT0 ,ZONES_WEIGHT_REG33_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT1 ,ZONES_WEIGHT_REG33_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT2 ,ZONES_WEIGHT_REG33_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT3 ,ZONES_WEIGHT_REG33_SEGMENT3 RESET:0xf"
          
          
group.long  0x2968++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_48, METERING_HIST_AEXP_REGISTER_48 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT0 ,ZONES_WEIGHT_REG34_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT1 ,ZONES_WEIGHT_REG34_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT2 ,ZONES_WEIGHT_REG34_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT3 ,ZONES_WEIGHT_REG34_SEGMENT3 RESET:0xf"
          
          
group.long  0x296c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_49, METERING_HIST_AEXP_REGISTER_49 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT0 ,ZONES_WEIGHT_REG35_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT1 ,ZONES_WEIGHT_REG35_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT2 ,ZONES_WEIGHT_REG35_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT3 ,ZONES_WEIGHT_REG35_SEGMENT3 RESET:0xf"
          
          
group.long  0x2970++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_50, METERING_HIST_AEXP_REGISTER_50 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT0 ,ZONES_WEIGHT_REG36_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT1 ,ZONES_WEIGHT_REG36_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT2 ,ZONES_WEIGHT_REG36_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT3 ,ZONES_WEIGHT_REG36_SEGMENT3 RESET:0xf"
          
          
group.long  0x2974++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_51, METERING_HIST_AEXP_REGISTER_51 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT0 ,ZONES_WEIGHT_REG37_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT1 ,ZONES_WEIGHT_REG37_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT2 ,ZONES_WEIGHT_REG37_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT3 ,ZONES_WEIGHT_REG37_SEGMENT3 RESET:0xf"
          
          
group.long  0x2978++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_52, METERING_HIST_AEXP_REGISTER_52 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT0 ,ZONES_WEIGHT_REG38_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT1 ,ZONES_WEIGHT_REG38_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT2 ,ZONES_WEIGHT_REG38_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT3 ,ZONES_WEIGHT_REG38_SEGMENT3 RESET:0xf"
          
          
group.long  0x297c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_53, METERING_HIST_AEXP_REGISTER_53 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT0 ,ZONES_WEIGHT_REG39_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT1 ,ZONES_WEIGHT_REG39_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT2 ,ZONES_WEIGHT_REG39_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT3 ,ZONES_WEIGHT_REG39_SEGMENT3 RESET:0xf"
          
          
group.long  0x2980++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_54, METERING_HIST_AEXP_REGISTER_54 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT0 ,ZONES_WEIGHT_REG40_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT1 ,ZONES_WEIGHT_REG40_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT2 ,ZONES_WEIGHT_REG40_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT3 ,ZONES_WEIGHT_REG40_SEGMENT3 RESET:0xf"
          
          
group.long  0x2984++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_55, METERING_HIST_AEXP_REGISTER_55 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT0 ,ZONES_WEIGHT_REG41_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT1 ,ZONES_WEIGHT_REG41_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT2 ,ZONES_WEIGHT_REG41_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT3 ,ZONES_WEIGHT_REG41_SEGMENT3 RESET:0xf"
          
          
group.long  0x2988++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_56, METERING_HIST_AEXP_REGISTER_56 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT0 ,ZONES_WEIGHT_REG42_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT1 ,ZONES_WEIGHT_REG42_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT2 ,ZONES_WEIGHT_REG42_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT3 ,ZONES_WEIGHT_REG42_SEGMENT3 RESET:0xf"
          
          
group.long  0x298c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_57, METERING_HIST_AEXP_REGISTER_57 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT0 ,ZONES_WEIGHT_REG43_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT1 ,ZONES_WEIGHT_REG43_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT2 ,ZONES_WEIGHT_REG43_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT3 ,ZONES_WEIGHT_REG43_SEGMENT3 RESET:0xf"
          
          
group.long  0x2990++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_58, METERING_HIST_AEXP_REGISTER_58 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT0 ,ZONES_WEIGHT_REG44_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT1 ,ZONES_WEIGHT_REG44_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT2 ,ZONES_WEIGHT_REG44_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT3 ,ZONES_WEIGHT_REG44_SEGMENT3 RESET:0xf"
          
          
group.long  0x2994++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_59, METERING_HIST_AEXP_REGISTER_59 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT0 ,ZONES_WEIGHT_REG45_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT1 ,ZONES_WEIGHT_REG45_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT2 ,ZONES_WEIGHT_REG45_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT3 ,ZONES_WEIGHT_REG45_SEGMENT3 RESET:0xf"
          
          
group.long  0x2998++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_60, METERING_HIST_AEXP_REGISTER_60 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT0 ,ZONES_WEIGHT_REG46_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT1 ,ZONES_WEIGHT_REG46_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT2 ,ZONES_WEIGHT_REG46_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT3 ,ZONES_WEIGHT_REG46_SEGMENT3 RESET:0xf"
          
          
group.long  0x299c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_61, METERING_HIST_AEXP_REGISTER_61 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT0 ,ZONES_WEIGHT_REG47_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT1 ,ZONES_WEIGHT_REG47_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT2 ,ZONES_WEIGHT_REG47_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT3 ,ZONES_WEIGHT_REG47_SEGMENT3 RESET:0xf"
          
          
group.long  0x29a0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_62, METERING_HIST_AEXP_REGISTER_62 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT0 ,ZONES_WEIGHT_REG48_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT1 ,ZONES_WEIGHT_REG48_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT2 ,ZONES_WEIGHT_REG48_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT3 ,ZONES_WEIGHT_REG48_SEGMENT3 RESET:0xf"
          
          
group.long  0x29a4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_63, METERING_HIST_AEXP_REGISTER_63 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT0 ,ZONES_WEIGHT_REG49_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT1 ,ZONES_WEIGHT_REG49_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT2 ,ZONES_WEIGHT_REG49_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT3 ,ZONES_WEIGHT_REG49_SEGMENT3 RESET:0xf"
          
          
group.long  0x29a8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_64, METERING_HIST_AEXP_REGISTER_64 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT0 ,ZONES_WEIGHT_REG50_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT1 ,ZONES_WEIGHT_REG50_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT2 ,ZONES_WEIGHT_REG50_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT3 ,ZONES_WEIGHT_REG50_SEGMENT3 RESET:0xf"
          
          
group.long  0x29ac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_65, METERING_HIST_AEXP_REGISTER_65 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT0 ,ZONES_WEIGHT_REG51_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT1 ,ZONES_WEIGHT_REG51_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT2 ,ZONES_WEIGHT_REG51_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT3 ,ZONES_WEIGHT_REG51_SEGMENT3 RESET:0xf"
          
          
group.long  0x29b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_66, METERING_HIST_AEXP_REGISTER_66 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT0 ,ZONES_WEIGHT_REG52_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT1 ,ZONES_WEIGHT_REG52_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT2 ,ZONES_WEIGHT_REG52_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT3 ,ZONES_WEIGHT_REG52_SEGMENT3 RESET:0xf"
          
          
group.long  0x29b4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_67, METERING_HIST_AEXP_REGISTER_67 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT0 ,ZONES_WEIGHT_REG53_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT1 ,ZONES_WEIGHT_REG53_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT2 ,ZONES_WEIGHT_REG53_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT3 ,ZONES_WEIGHT_REG53_SEGMENT3 RESET:0xf"
          
          
group.long  0x29b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_68, METERING_HIST_AEXP_REGISTER_68 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT0 ,ZONES_WEIGHT_REG54_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT1 ,ZONES_WEIGHT_REG54_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT2 ,ZONES_WEIGHT_REG54_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT3 ,ZONES_WEIGHT_REG54_SEGMENT3 RESET:0xf"
          
          
group.long  0x29bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_69, METERING_HIST_AEXP_REGISTER_69 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT0 ,ZONES_WEIGHT_REG55_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT1 ,ZONES_WEIGHT_REG55_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT2 ,ZONES_WEIGHT_REG55_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_HIST_AEXP_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT3 ,ZONES_WEIGHT_REG55_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d24++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_0, METERING_IHIST_REGISTER_0 RESET:0x1"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_0_SKIP_X ,SKIP_X RESET:0x1"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_0_OFFSET_X ,OFFSET_X RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_0_SKIP_Y ,SKIP_Y RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_0_OFFSET_Y ,OFFSET_Y RESET:0x0"
          
          
group.long  0x2d28++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_1, METERING_IHIST_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_1_SCALE_BOTTOM ,SCALE_BOTTOM RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_1_SCALE_TOP ,SCALE_TOP RESET:0x0"
          
          
rgroup.long 0x2d2c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_2, METERING_IHIST_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_2_TOTAL_PIXELS ,TOTAL_PIXELS RESET:0x0"
          
rgroup.long 0x2d30++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_3, METERING_IHIST_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_3_COUNTED_PIXELS ,COUNTED_PIXELS RESET:0x0"
          
group.long  0x2d34++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_4, METERING_IHIST_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_4_PLANE_MODE ,PLANE_MODE RESET:0x0"
          
          
rgroup.long 0x2d38++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_5, METERING_IHIST_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_5_PLANE_TOTAL_0 ,PLANE_TOTAL_0 RESET:0x0"
          
rgroup.long 0x2d3c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_6, METERING_IHIST_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_6_PLANE_TOTAL_1 ,PLANE_TOTAL_1 RESET:0x0"
          
rgroup.long 0x2d40++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_7, METERING_IHIST_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_7_PLANE_TOTAL_2 ,PLANE_TOTAL_2 RESET:0x0"
          
rgroup.long 0x2d44++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_8, METERING_IHIST_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_8_PLANE_TOTAL_3 ,PLANE_TOTAL_3 RESET:0x0"
          
rgroup.long 0x2d48++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_9, METERING_IHIST_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_9_PLANE_COUNTED_0 ,PLANE_COUNTED_0 RESET:0x0"
          
rgroup.long 0x2d4c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_10, METERING_IHIST_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_10_PLANE_COUNTED_1 ,PLANE_COUNTED_1 RESET:0x0"
          
rgroup.long 0x2d50++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_11, METERING_IHIST_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_11_PLANE_COUNTED_2 ,PLANE_COUNTED_2 RESET:0x0"
          
rgroup.long 0x2d54++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_12, METERING_IHIST_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_12_PLANE_COUNTED_3 ,PLANE_COUNTED_3 RESET:0x0"
          
group.long  0x2d58++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_13, METERING_IHIST_REGISTER_13 RESET:0xf0f"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_13_NODES_USED_HORIZ ,NODES_USED_HORIZ RESET:0xf"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_13_NODES_USED_VERT ,NODES_USED_VERT RESET:0xf"
          
          
group.long  0x2d5c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_14, METERING_IHIST_REGISTER_14 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT0 ,ZONES_WEIGHT_REG0_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT1 ,ZONES_WEIGHT_REG0_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT2 ,ZONES_WEIGHT_REG0_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT3 ,ZONES_WEIGHT_REG0_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d60++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_15, METERING_IHIST_REGISTER_15 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT0 ,ZONES_WEIGHT_REG1_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT1 ,ZONES_WEIGHT_REG1_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT2 ,ZONES_WEIGHT_REG1_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT3 ,ZONES_WEIGHT_REG1_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d64++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_16, METERING_IHIST_REGISTER_16 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT0 ,ZONES_WEIGHT_REG2_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT1 ,ZONES_WEIGHT_REG2_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT2 ,ZONES_WEIGHT_REG2_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT3 ,ZONES_WEIGHT_REG2_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d68++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_17, METERING_IHIST_REGISTER_17 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT0 ,ZONES_WEIGHT_REG3_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT1 ,ZONES_WEIGHT_REG3_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT2 ,ZONES_WEIGHT_REG3_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT3 ,ZONES_WEIGHT_REG3_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d6c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_18, METERING_IHIST_REGISTER_18 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT0 ,ZONES_WEIGHT_REG4_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT1 ,ZONES_WEIGHT_REG4_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT2 ,ZONES_WEIGHT_REG4_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT3 ,ZONES_WEIGHT_REG4_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d70++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_19, METERING_IHIST_REGISTER_19 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT0 ,ZONES_WEIGHT_REG5_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT1 ,ZONES_WEIGHT_REG5_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT2 ,ZONES_WEIGHT_REG5_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT3 ,ZONES_WEIGHT_REG5_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_20, METERING_IHIST_REGISTER_20 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT0 ,ZONES_WEIGHT_REG6_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT1 ,ZONES_WEIGHT_REG6_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT2 ,ZONES_WEIGHT_REG6_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT3 ,ZONES_WEIGHT_REG6_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d78++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_21, METERING_IHIST_REGISTER_21 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT0 ,ZONES_WEIGHT_REG7_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT1 ,ZONES_WEIGHT_REG7_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT2 ,ZONES_WEIGHT_REG7_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT3 ,ZONES_WEIGHT_REG7_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d7c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_22, METERING_IHIST_REGISTER_22 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT0 ,ZONES_WEIGHT_REG8_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT1 ,ZONES_WEIGHT_REG8_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT2 ,ZONES_WEIGHT_REG8_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT3 ,ZONES_WEIGHT_REG8_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_23, METERING_IHIST_REGISTER_23 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT0 ,ZONES_WEIGHT_REG9_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT1 ,ZONES_WEIGHT_REG9_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT2 ,ZONES_WEIGHT_REG9_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT3 ,ZONES_WEIGHT_REG9_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_24, METERING_IHIST_REGISTER_24 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT0 ,ZONES_WEIGHT_REG10_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT1 ,ZONES_WEIGHT_REG10_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT2 ,ZONES_WEIGHT_REG10_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT3 ,ZONES_WEIGHT_REG10_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_25, METERING_IHIST_REGISTER_25 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT0 ,ZONES_WEIGHT_REG11_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT1 ,ZONES_WEIGHT_REG11_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT2 ,ZONES_WEIGHT_REG11_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT3 ,ZONES_WEIGHT_REG11_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_26, METERING_IHIST_REGISTER_26 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT0 ,ZONES_WEIGHT_REG12_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT1 ,ZONES_WEIGHT_REG12_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT2 ,ZONES_WEIGHT_REG12_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT3 ,ZONES_WEIGHT_REG12_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d90++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_27, METERING_IHIST_REGISTER_27 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT0 ,ZONES_WEIGHT_REG13_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT1 ,ZONES_WEIGHT_REG13_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT2 ,ZONES_WEIGHT_REG13_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT3 ,ZONES_WEIGHT_REG13_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_28, METERING_IHIST_REGISTER_28 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT0 ,ZONES_WEIGHT_REG14_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT1 ,ZONES_WEIGHT_REG14_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT2 ,ZONES_WEIGHT_REG14_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT3 ,ZONES_WEIGHT_REG14_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_29, METERING_IHIST_REGISTER_29 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT0 ,ZONES_WEIGHT_REG15_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT1 ,ZONES_WEIGHT_REG15_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT2 ,ZONES_WEIGHT_REG15_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT3 ,ZONES_WEIGHT_REG15_SEGMENT3 RESET:0xf"
          
          
group.long  0x2d9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_30, METERING_IHIST_REGISTER_30 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT0 ,ZONES_WEIGHT_REG16_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT1 ,ZONES_WEIGHT_REG16_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT2 ,ZONES_WEIGHT_REG16_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT3 ,ZONES_WEIGHT_REG16_SEGMENT3 RESET:0xf"
          
          
group.long  0x2da0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_31, METERING_IHIST_REGISTER_31 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT0 ,ZONES_WEIGHT_REG17_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT1 ,ZONES_WEIGHT_REG17_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT2 ,ZONES_WEIGHT_REG17_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT3 ,ZONES_WEIGHT_REG17_SEGMENT3 RESET:0xf"
          
          
group.long  0x2da4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_32, METERING_IHIST_REGISTER_32 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT0 ,ZONES_WEIGHT_REG18_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT1 ,ZONES_WEIGHT_REG18_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT2 ,ZONES_WEIGHT_REG18_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT3 ,ZONES_WEIGHT_REG18_SEGMENT3 RESET:0xf"
          
          
group.long  0x2da8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_33, METERING_IHIST_REGISTER_33 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT0 ,ZONES_WEIGHT_REG19_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT1 ,ZONES_WEIGHT_REG19_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT2 ,ZONES_WEIGHT_REG19_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT3 ,ZONES_WEIGHT_REG19_SEGMENT3 RESET:0xf"
          
          
group.long  0x2dac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_34, METERING_IHIST_REGISTER_34 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT0 ,ZONES_WEIGHT_REG20_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT1 ,ZONES_WEIGHT_REG20_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT2 ,ZONES_WEIGHT_REG20_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT3 ,ZONES_WEIGHT_REG20_SEGMENT3 RESET:0xf"
          
          
group.long  0x2db0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_35, METERING_IHIST_REGISTER_35 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT0 ,ZONES_WEIGHT_REG21_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT1 ,ZONES_WEIGHT_REG21_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT2 ,ZONES_WEIGHT_REG21_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT3 ,ZONES_WEIGHT_REG21_SEGMENT3 RESET:0xf"
          
          
group.long  0x2db4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_36, METERING_IHIST_REGISTER_36 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT0 ,ZONES_WEIGHT_REG22_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT1 ,ZONES_WEIGHT_REG22_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT2 ,ZONES_WEIGHT_REG22_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT3 ,ZONES_WEIGHT_REG22_SEGMENT3 RESET:0xf"
          
          
group.long  0x2db8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_37, METERING_IHIST_REGISTER_37 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT0 ,ZONES_WEIGHT_REG23_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT1 ,ZONES_WEIGHT_REG23_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT2 ,ZONES_WEIGHT_REG23_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT3 ,ZONES_WEIGHT_REG23_SEGMENT3 RESET:0xf"
          
          
group.long  0x2dbc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_38, METERING_IHIST_REGISTER_38 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT0 ,ZONES_WEIGHT_REG24_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT1 ,ZONES_WEIGHT_REG24_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT2 ,ZONES_WEIGHT_REG24_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT3 ,ZONES_WEIGHT_REG24_SEGMENT3 RESET:0xf"
          
          
group.long  0x2dc0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_39, METERING_IHIST_REGISTER_39 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT0 ,ZONES_WEIGHT_REG25_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT1 ,ZONES_WEIGHT_REG25_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT2 ,ZONES_WEIGHT_REG25_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT3 ,ZONES_WEIGHT_REG25_SEGMENT3 RESET:0xf"
          
          
group.long  0x2dc4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_40, METERING_IHIST_REGISTER_40 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT0 ,ZONES_WEIGHT_REG26_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT1 ,ZONES_WEIGHT_REG26_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT2 ,ZONES_WEIGHT_REG26_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT3 ,ZONES_WEIGHT_REG26_SEGMENT3 RESET:0xf"
          
          
group.long  0x2dc8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_41, METERING_IHIST_REGISTER_41 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT0 ,ZONES_WEIGHT_REG27_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT1 ,ZONES_WEIGHT_REG27_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT2 ,ZONES_WEIGHT_REG27_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT3 ,ZONES_WEIGHT_REG27_SEGMENT3 RESET:0xf"
          
          
group.long  0x2dcc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_42, METERING_IHIST_REGISTER_42 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT0 ,ZONES_WEIGHT_REG28_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT1 ,ZONES_WEIGHT_REG28_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT2 ,ZONES_WEIGHT_REG28_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT3 ,ZONES_WEIGHT_REG28_SEGMENT3 RESET:0xf"
          
          
group.long  0x2dd0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_43, METERING_IHIST_REGISTER_43 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT0 ,ZONES_WEIGHT_REG29_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT1 ,ZONES_WEIGHT_REG29_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT2 ,ZONES_WEIGHT_REG29_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT3 ,ZONES_WEIGHT_REG29_SEGMENT3 RESET:0xf"
          
          
group.long  0x2dd4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_44, METERING_IHIST_REGISTER_44 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT0 ,ZONES_WEIGHT_REG30_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT1 ,ZONES_WEIGHT_REG30_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT2 ,ZONES_WEIGHT_REG30_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT3 ,ZONES_WEIGHT_REG30_SEGMENT3 RESET:0xf"
          
          
group.long  0x2dd8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_45, METERING_IHIST_REGISTER_45 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT0 ,ZONES_WEIGHT_REG31_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT1 ,ZONES_WEIGHT_REG31_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT2 ,ZONES_WEIGHT_REG31_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT3 ,ZONES_WEIGHT_REG31_SEGMENT3 RESET:0xf"
          
          
group.long  0x2ddc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_46, METERING_IHIST_REGISTER_46 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT0 ,ZONES_WEIGHT_REG32_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT1 ,ZONES_WEIGHT_REG32_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT2 ,ZONES_WEIGHT_REG32_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT3 ,ZONES_WEIGHT_REG32_SEGMENT3 RESET:0xf"
          
          
group.long  0x2de0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_47, METERING_IHIST_REGISTER_47 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT0 ,ZONES_WEIGHT_REG33_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT1 ,ZONES_WEIGHT_REG33_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT2 ,ZONES_WEIGHT_REG33_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT3 ,ZONES_WEIGHT_REG33_SEGMENT3 RESET:0xf"
          
          
group.long  0x2de4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_48, METERING_IHIST_REGISTER_48 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT0 ,ZONES_WEIGHT_REG34_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT1 ,ZONES_WEIGHT_REG34_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT2 ,ZONES_WEIGHT_REG34_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT3 ,ZONES_WEIGHT_REG34_SEGMENT3 RESET:0xf"
          
          
group.long  0x2de8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_49, METERING_IHIST_REGISTER_49 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT0 ,ZONES_WEIGHT_REG35_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT1 ,ZONES_WEIGHT_REG35_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT2 ,ZONES_WEIGHT_REG35_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT3 ,ZONES_WEIGHT_REG35_SEGMENT3 RESET:0xf"
          
          
group.long  0x2dec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_50, METERING_IHIST_REGISTER_50 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT0 ,ZONES_WEIGHT_REG36_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT1 ,ZONES_WEIGHT_REG36_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT2 ,ZONES_WEIGHT_REG36_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT3 ,ZONES_WEIGHT_REG36_SEGMENT3 RESET:0xf"
          
          
group.long  0x2df0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_51, METERING_IHIST_REGISTER_51 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT0 ,ZONES_WEIGHT_REG37_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT1 ,ZONES_WEIGHT_REG37_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT2 ,ZONES_WEIGHT_REG37_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT3 ,ZONES_WEIGHT_REG37_SEGMENT3 RESET:0xf"
          
          
group.long  0x2df4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_52, METERING_IHIST_REGISTER_52 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT0 ,ZONES_WEIGHT_REG38_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT1 ,ZONES_WEIGHT_REG38_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT2 ,ZONES_WEIGHT_REG38_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT3 ,ZONES_WEIGHT_REG38_SEGMENT3 RESET:0xf"
          
          
group.long  0x2df8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_53, METERING_IHIST_REGISTER_53 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT0 ,ZONES_WEIGHT_REG39_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT1 ,ZONES_WEIGHT_REG39_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT2 ,ZONES_WEIGHT_REG39_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT3 ,ZONES_WEIGHT_REG39_SEGMENT3 RESET:0xf"
          
          
group.long  0x2dfc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_54, METERING_IHIST_REGISTER_54 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT0 ,ZONES_WEIGHT_REG40_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT1 ,ZONES_WEIGHT_REG40_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT2 ,ZONES_WEIGHT_REG40_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT3 ,ZONES_WEIGHT_REG40_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e00++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_55, METERING_IHIST_REGISTER_55 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT0 ,ZONES_WEIGHT_REG41_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT1 ,ZONES_WEIGHT_REG41_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT2 ,ZONES_WEIGHT_REG41_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT3 ,ZONES_WEIGHT_REG41_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e04++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_56, METERING_IHIST_REGISTER_56 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT0 ,ZONES_WEIGHT_REG42_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT1 ,ZONES_WEIGHT_REG42_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT2 ,ZONES_WEIGHT_REG42_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT3 ,ZONES_WEIGHT_REG42_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e08++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_57, METERING_IHIST_REGISTER_57 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT0 ,ZONES_WEIGHT_REG43_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT1 ,ZONES_WEIGHT_REG43_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT2 ,ZONES_WEIGHT_REG43_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT3 ,ZONES_WEIGHT_REG43_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e0c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_58, METERING_IHIST_REGISTER_58 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT0 ,ZONES_WEIGHT_REG44_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT1 ,ZONES_WEIGHT_REG44_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT2 ,ZONES_WEIGHT_REG44_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT3 ,ZONES_WEIGHT_REG44_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e10++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_59, METERING_IHIST_REGISTER_59 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT0 ,ZONES_WEIGHT_REG45_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT1 ,ZONES_WEIGHT_REG45_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT2 ,ZONES_WEIGHT_REG45_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT3 ,ZONES_WEIGHT_REG45_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e14++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_60, METERING_IHIST_REGISTER_60 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT0 ,ZONES_WEIGHT_REG46_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT1 ,ZONES_WEIGHT_REG46_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT2 ,ZONES_WEIGHT_REG46_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT3 ,ZONES_WEIGHT_REG46_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e18++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_61, METERING_IHIST_REGISTER_61 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT0 ,ZONES_WEIGHT_REG47_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT1 ,ZONES_WEIGHT_REG47_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT2 ,ZONES_WEIGHT_REG47_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT3 ,ZONES_WEIGHT_REG47_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e1c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_62, METERING_IHIST_REGISTER_62 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT0 ,ZONES_WEIGHT_REG48_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT1 ,ZONES_WEIGHT_REG48_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT2 ,ZONES_WEIGHT_REG48_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT3 ,ZONES_WEIGHT_REG48_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e20++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_63, METERING_IHIST_REGISTER_63 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT0 ,ZONES_WEIGHT_REG49_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT1 ,ZONES_WEIGHT_REG49_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT2 ,ZONES_WEIGHT_REG49_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT3 ,ZONES_WEIGHT_REG49_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e24++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_64, METERING_IHIST_REGISTER_64 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT0 ,ZONES_WEIGHT_REG50_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT1 ,ZONES_WEIGHT_REG50_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT2 ,ZONES_WEIGHT_REG50_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT3 ,ZONES_WEIGHT_REG50_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e28++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_65, METERING_IHIST_REGISTER_65 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT0 ,ZONES_WEIGHT_REG51_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT1 ,ZONES_WEIGHT_REG51_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT2 ,ZONES_WEIGHT_REG51_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT3 ,ZONES_WEIGHT_REG51_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e2c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_66, METERING_IHIST_REGISTER_66 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT0 ,ZONES_WEIGHT_REG52_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT1 ,ZONES_WEIGHT_REG52_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT2 ,ZONES_WEIGHT_REG52_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT3 ,ZONES_WEIGHT_REG52_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e30++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_67, METERING_IHIST_REGISTER_67 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT0 ,ZONES_WEIGHT_REG53_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT1 ,ZONES_WEIGHT_REG53_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT2 ,ZONES_WEIGHT_REG53_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT3 ,ZONES_WEIGHT_REG53_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e34++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_68, METERING_IHIST_REGISTER_68 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT0 ,ZONES_WEIGHT_REG54_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT1 ,ZONES_WEIGHT_REG54_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT2 ,ZONES_WEIGHT_REG54_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT3 ,ZONES_WEIGHT_REG54_SEGMENT3 RESET:0xf"
          
          
group.long  0x2e38++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_69, METERING_IHIST_REGISTER_69 RESET:0xf0f0f0f"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT0 ,ZONES_WEIGHT_REG55_SEGMENT0 RESET:0xf"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT1 ,ZONES_WEIGHT_REG55_SEGMENT1 RESET:0xf"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT2 ,ZONES_WEIGHT_REG55_SEGMENT2 RESET:0xf"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_METERING_IHIST_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT3 ,ZONES_WEIGHT_REG55_SEGMENT3 RESET:0xf"
          
          
group.long  0x31a0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CROP_REGISTER_0, FR_CROP_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CROP_REGISTER_0_ENABLE_CROP ,ENABLE_CROP RESET:0x0"
          
          
group.long  0x31a4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CROP_REGISTER_1, FR_CROP_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CROP_REGISTER_1_START_X ,START_X RESET:0x0"
          
          
group.long  0x31a8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CROP_REGISTER_2, FR_CROP_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CROP_REGISTER_2_START_Y ,START_Y RESET:0x0"
          
          
group.long  0x31ac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CROP_REGISTER_3, FR_CROP_REGISTER_3 RESET:0xffff"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CROP_REGISTER_3_SIZE_X ,SIZE_X RESET:0xffff"
          
          
group.long  0x31b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CROP_REGISTER_4, FR_CROP_REGISTER_4 RESET:0xffff"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CROP_REGISTER_4_SIZE_Y ,SIZE_Y RESET:0xffff"
          
          
group.long  0x31b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_0, FR_SCALER_REGISTER_0 RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_0_TIMEOUT_ENABLE ,TIMEOUT_ENABLE RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_0_TIMEOUT_VALUE ,TIMEOUT_VALUE RESET:0x0"
          
group.long  0x31bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_1, FR_SCALER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_1_WIDTH ,WIDTH RESET:0x0"
          
          
group.long  0x31c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_2, FR_SCALER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_2_HEIGHT ,HEIGHT RESET:0x0"
          
          
group.long  0x31c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_3, FR_SCALER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_3_OWIDTH ,OWIDTH RESET:0x0"
          
          
group.long  0x31c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_4, FR_SCALER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_4_OHEIGHT ,OHEIGHT RESET:0x0"
          
          
group.long  0x31cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_5, FR_SCALER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_5_HFILT_TINC ,HFILT_TINC RESET:0x0"
          
          
group.long  0x31d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_6, FR_SCALER_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_6_HFILT_COEFSET ,HFILT_COEFSET RESET:0x0"
          
          
group.long  0x31d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_7, FR_SCALER_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_7_VFILT_TINC ,VFILT_TINC RESET:0x0"
          
          
group.long  0x31d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_8, FR_SCALER_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SCALER_REGISTER_8_VFILT_COEFSET ,VFILT_COEFSET RESET:0x0"
          
          
group.long  0x31dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_GAMMA_RGB_REGISTER_0, FR_GAMMA_RGB_REGISTER_0 RESET:0x1"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_GAMMA_RGB_REGISTER_0_ENABLE ,ENABLE RESET:0x1"
          
          
group.long  0x31e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_GAMMA_RGB_REGISTER_1, FR_GAMMA_RGB_REGISTER_1 RESET:0x1000100"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_GAMMA_RGB_REGISTER_1_GAIN_R ,GAIN_R RESET:0x100"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_GAMMA_RGB_REGISTER_1_GAIN_G ,GAIN_G RESET:0x100"
          
          
group.long  0x31e4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_GAMMA_RGB_REGISTER_2, FR_GAMMA_RGB_REGISTER_2 RESET:0x100"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_GAMMA_RGB_REGISTER_2_GAIN_B ,GAIN_B RESET:0x100"
          
          
group.long  0x31e8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_GAMMA_RGB_REGISTER_3, FR_GAMMA_RGB_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_GAMMA_RGB_REGISTER_3_OFFSET_R ,OFFSET_R RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_GAMMA_RGB_REGISTER_3_OFFSET_G ,OFFSET_G RESET:0x0"
          
          
group.long  0x31ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_GAMMA_RGB_REGISTER_4, FR_GAMMA_RGB_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_GAMMA_RGB_REGISTER_4_OFFSET_B ,OFFSET_B RESET:0x0"
          
          
group.long  0x31f0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_0, FR_SHARPEN_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
          
group.long  0x31f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_1, FR_SHARPEN_REGISTER_1 RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_1_STRENGTH ,STRENGTH RESET:0x10"
          
          
group.long  0x31f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_2, FR_SHARPEN_REGISTER_2 RESET:0x131e4c"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_2_CONTROL_R ,CONTROL_R RESET:0x4c"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_2_CONTROL_B ,CONTROL_B RESET:0x1e"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_2_ALPHA_UNDERSHOOT ,ALPHA_UNDERSHOOT RESET:0x13"
          
          
group.long  0x31fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_3, FR_SHARPEN_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_3_LUMA_THRESH_LOW ,LUMA_THRESH_LOW RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_3_LUMA_OFFSET_LOW ,LUMA_OFFSET_LOW RESET:0x0"
          
          
group.long  0x3200++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_4, FR_SHARPEN_REGISTER_4 RESET:0x33203fc"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_4_LUMA_SLOPE_LOW ,LUMA_SLOPE_LOW RESET:0x3fc"
          
         hexmask.long 0x00 16.--25. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_4_LUMA_THRESH_HIGH ,LUMA_THRESH_HIGH RESET:0x332"
          
          
group.long  0x3204++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_5, FR_SHARPEN_REGISTER_5 RESET:0x6a40000"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_5_LUMA_OFFSET_HIGH ,LUMA_OFFSET_HIGH RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_5_LUMA_SLOPE_HIGH ,LUMA_SLOPE_HIGH RESET:0x6a4"
          
group.long  0x3208++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_6, FR_SHARPEN_REGISTER_6 RESET:0xcd3fff"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_6_CLIP_STR_MAX ,CLIP_STR_MAX RESET:0x3fff"
          
          
         hexmask.long 0x00 16.--29. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_6_CLIP_STR_MIN ,CLIP_STR_MIN RESET:0xcd"
          
          
group.long  0x320c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_7, FR_SHARPEN_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_SHARPEN_REGISTER_7_DEBUG ,DEBUG RESET:0x0"
          
          
group.long  0x3210++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_0, FR_CS_CONV_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_0_ENABLE_MATRIX ,ENABLE_MATRIX RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_0_ENABLE_FILTER ,ENABLE_FILTER RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_0_ENABLE_HORIZONTAL_DOWNSAMPLE ,ENABLE_HORIZONTAL_DOWNSAMPLE RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_0_ENABLE_VERTICAL_DOWNSAMPLE ,ENABLE_VERTICAL_DOWNSAMPLE RESET:0x0"
          
          
group.long  0x3214++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_1, FR_CS_CONV_REGISTER_1 RESET:0x2f"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_1_COEFFT_11 ,COEFFT_11 RESET:0x2f"
          
          
group.long  0x3218++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_2, FR_CS_CONV_REGISTER_2 RESET:0x9d"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_2_COEFFT_12 ,COEFFT_12 RESET:0x9d"
          
          
group.long  0x321c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_3, FR_CS_CONV_REGISTER_3 RESET:0x10"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_3_COEFFT_13 ,COEFFT_13 RESET:0x10"
          
          
group.long  0x3220++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_4, FR_CS_CONV_REGISTER_4 RESET:0x801a"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_4_COEFFT_21 ,COEFFT_21 RESET:0x801a"
          
          
group.long  0x3224++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_5, FR_CS_CONV_REGISTER_5 RESET:0x8057"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_5_COEFFT_22 ,COEFFT_22 RESET:0x8057"
          
          
group.long  0x3228++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_6, FR_CS_CONV_REGISTER_6 RESET:0x70"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_6_COEFFT_23 ,COEFFT_23 RESET:0x70"
          
          
group.long  0x322c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_7, FR_CS_CONV_REGISTER_7 RESET:0x70"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_7_COEFFT_31 ,COEFFT_31 RESET:0x70"
          
          
group.long  0x3230++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_8, FR_CS_CONV_REGISTER_8 RESET:0x8066"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_8_COEFFT_32 ,COEFFT_32 RESET:0x8066"
          
          
group.long  0x3234++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_9, FR_CS_CONV_REGISTER_9 RESET:0x800a"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_9_COEFFT_33 ,COEFFT_33 RESET:0x800a"
          
          
group.long  0x3238++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_10, FR_CS_CONV_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_10_COEFFT_O1 ,COEFFT_O1 RESET:0x0"
          
          
group.long  0x323c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_11, FR_CS_CONV_REGISTER_11 RESET:0x200"
         hexmask.long 0x00 0.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_11_COEFFT_O2 ,COEFFT_O2 RESET:0x200"
          
          
group.long  0x3240++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_12, FR_CS_CONV_REGISTER_12 RESET:0x200"
         hexmask.long 0x00 0.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_12_COEFFT_O3 ,COEFFT_O3 RESET:0x200"
          
          
group.long  0x3244++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_13, FR_CS_CONV_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_13_CLIP_MIN_Y ,CLIP_MIN_Y RESET:0x0"
          
          
group.long  0x3248++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_14, FR_CS_CONV_REGISTER_14 RESET:0x3ff"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_14_CLIP_MAX_Y ,CLIP_MAX_Y RESET:0x3ff"
          
          
group.long  0x324c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_15, FR_CS_CONV_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_15_CLIP_MIN_UV ,CLIP_MIN_UV RESET:0x0"
          
          
group.long  0x3250++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_16, FR_CS_CONV_REGISTER_16 RESET:0x3ff"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_16_CLIP_MAX_UV ,CLIP_MAX_UV RESET:0x3ff"
          
          
group.long  0x3254++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_17, FR_CS_CONV_REGISTER_17 RESET:0x3ff"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_17_DATA_MASK_RY ,DATA_MASK_RY RESET:0x3ff"
          
          
group.long  0x3258++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_18, FR_CS_CONV_REGISTER_18 RESET:0x3ff"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_18_DATA_MASK_GU ,DATA_MASK_GU RESET:0x3ff"
          
          
group.long  0x325c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_19, FR_CS_CONV_REGISTER_19 RESET:0x3ff"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_REGISTER_19_DATA_MASK_BV ,DATA_MASK_BV RESET:0x3ff"
          
          
group.long  0x3260++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_DITHER_REGISTER_0, FR_CS_CONV_DITHER_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_DITHER_REGISTER_0_ENABLE_DITHER ,ENABLE_DITHER RESET:0x0"
          
         hexmask.long 0x00 1.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_DITHER_REGISTER_0_DITHER_AMOUNT ,DITHER_AMOUNT RESET:0x0"
          
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_CS_CONV_DITHER_REGISTER_0_SHIFT_MODE ,SHIFT_MODE RESET:0x0"
          
          
group.long  0x3264++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_0, FR_DMA_WRITER_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_0_FORMAT ,FORMAT RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_0_SINGLE_FRAME ,SINGLE_FRAME RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_0_FRAME_WRITE_ON ,FRAME_WRITE_ON RESET:0x0"
          
          
         bitfld.long 0x00 11. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_0_AXI_XACT_COMP ,AXI_XACT_COMP RESET:0x0"
          
          
group.long  0x3268++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_1, FR_DMA_WRITER_REGISTER_1 RESET:0x4380780"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_1_ACTIVE_WIDTH ,ACTIVE_WIDTH RESET:0x780"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_1_ACTIVE_HEIGHT ,ACTIVE_HEIGHT RESET:0x438"
          
group.long  0x326c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_2, FR_DMA_WRITER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_2_BANK0_BASE ,BANK0_BASE RESET:0x0"
          
group.long  0x3270++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_3, FR_DMA_WRITER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_3_BANK1_BASE ,BANK1_BASE RESET:0x0"
          
group.long  0x3274++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_4, FR_DMA_WRITER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_4_BANK2_BASE ,BANK2_BASE RESET:0x0"
          
group.long  0x3278++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_5, FR_DMA_WRITER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_5_BANK3_BASE ,BANK3_BASE RESET:0x0"
          
group.long  0x327c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_6, FR_DMA_WRITER_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_6_BANK4_BASE ,BANK4_BASE RESET:0x0"
          
group.long  0x3280++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_7, FR_DMA_WRITER_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_7_MAX_BANK ,MAX_BANK RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_7_BANK0_RESTART ,BANK0_RESTART RESET:0x0"
          
          
group.long  0x3284++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_8, FR_DMA_WRITER_REGISTER_8 RESET:0x1000"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_8_LINE_OFFSET ,LINE_OFFSET RESET:0x1000"
          
group.long  0x3288++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_9, FR_DMA_WRITER_REGISTER_9 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_9_WBANK_ACTIVE ,WBANK_ACTIVE RESET:0x0"
          
         hexmask.long 0x00 1.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_9_WBANK_CURR ,WBANK_CURR RESET:0x0"
          
          
rgroup.long 0x3294++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_10, FR_DMA_WRITER_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_10_FRAME_ICOUNT ,FRAME_ICOUNT RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_10_FRAME_WCOUNT ,FRAME_WCOUNT RESET:0x0"
          
group.long  0x329c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_11, FR_DMA_WRITER_REGISTER_11 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_11_AXI_FAIL_BRESP ,AXI_FAIL_BRESP RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_11_AXI_FAIL_AWMAXWAIT ,AXI_FAIL_AWMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_11_AXI_FAIL_WMAXWAIT ,AXI_FAIL_WMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_11_AXI_FAIL_WXACT_OSTAND ,AXI_FAIL_WXACT_OSTAND RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_WIDTH ,VI_FAIL_ACTIVE_WIDTH RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_HEIGHT ,VI_FAIL_ACTIVE_HEIGHT RESET:0x0"
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_11_VI_FAIL_INTERLINE_BLANKS ,VI_FAIL_INTERLINE_BLANKS RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_11_VI_FAIL_INTERFRAME_BLANKS ,VI_FAIL_INTERFRAME_BLANKS RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_11_VIDEO_ALARM ,VIDEO_ALARM RESET:0x0"
          
          
rgroup.long 0x32a0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_12, FR_DMA_WRITER_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_12_BLK_STATUS ,BLK_STATUS RESET:0x0"
          
group.long  0x32a4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_13, FR_DMA_WRITER_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_13_LINES_WRAPPED ,LINES_WRAPPED RESET:0x0"
          
          
group.long  0x32a8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_14, FR_DMA_WRITER_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_14_LINETICK_FIRST ,LINETICK_FIRST RESET:0x0"
          
          
group.long  0x32ac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_15, FR_DMA_WRITER_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_15_LINETICK_REPEAT ,LINETICK_REPEAT RESET:0x0"
          
          
group.long  0x32b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_16, FR_DMA_WRITER_REGISTER_16 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_16_LINETICK_EOL ,LINETICK_EOL RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_16_LINETICK_DELAY ,LINETICK_DELAY RESET:0x0"
          
group.long  0x32b4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_17, FR_DMA_WRITER_REGISTER_17 RESET:0xf000f0c"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_17_PAGEWARM_ON ,PAGEWARM_ON RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_17_AXI_ID_MULTI ,AXI_ID_MULTI RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_17_AXI_BURSTSPLIT ,AXI_BURSTSPLIT RESET:0x3"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_17_AXI_CACHE_VALUE ,AXI_CACHE_VALUE RESET:0xf"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_17_AXI_MAXOSTAND ,AXI_MAXOSTAND RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_17_AXI_MAX_AWLEN ,AXI_MAX_AWLEN RESET:0xf"
          
          
group.long  0x32b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_18, FR_DMA_WRITER_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_DMA_WRITER_REGISTER_18_AXI_ID_VALUE ,AXI_ID_VALUE RESET:0x0"
          
          
group.long  0x32bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_0, FR_UV_DMA_WRITER_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_0_FORMAT ,FORMAT RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_0_SINGLE_FRAME ,SINGLE_FRAME RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_0_FRAME_WRITE_ON ,FRAME_WRITE_ON RESET:0x0"
          
          
         bitfld.long 0x00 11. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_0_AXI_XACT_COMP ,AXI_XACT_COMP RESET:0x0"
          
          
group.long  0x32c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_1, FR_UV_DMA_WRITER_REGISTER_1 RESET:0x4380780"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_1_ACTIVE_WIDTH ,ACTIVE_WIDTH RESET:0x780"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_1_ACTIVE_HEIGHT ,ACTIVE_HEIGHT RESET:0x438"
          
group.long  0x32c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_2, FR_UV_DMA_WRITER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_2_BANK0_BASE ,BANK0_BASE RESET:0x0"
          
group.long  0x32c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_3, FR_UV_DMA_WRITER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_3_BANK1_BASE ,BANK1_BASE RESET:0x0"
          
group.long  0x32cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_4, FR_UV_DMA_WRITER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_4_BANK2_BASE ,BANK2_BASE RESET:0x0"
          
group.long  0x32d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_5, FR_UV_DMA_WRITER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_5_BANK3_BASE ,BANK3_BASE RESET:0x0"
          
group.long  0x32d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_6, FR_UV_DMA_WRITER_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_6_BANK4_BASE ,BANK4_BASE RESET:0x0"
          
group.long  0x32d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_7, FR_UV_DMA_WRITER_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_7_MAX_BANK ,MAX_BANK RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_7_BANK0_RESTART ,BANK0_RESTART RESET:0x0"
          
          
group.long  0x32dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_8, FR_UV_DMA_WRITER_REGISTER_8 RESET:0x1000"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_8_LINE_OFFSET ,LINE_OFFSET RESET:0x1000"
          
group.long  0x32e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_9, FR_UV_DMA_WRITER_REGISTER_9 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_9_WBANK_ACTIVE ,WBANK_ACTIVE RESET:0x0"
          
         hexmask.long 0x00 1.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_9_WBANK_CURR ,WBANK_CURR RESET:0x0"
          
          
rgroup.long 0x32ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_10, FR_UV_DMA_WRITER_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_10_FRAME_ICOUNT ,FRAME_ICOUNT RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_10_FRAME_WCOUNT ,FRAME_WCOUNT RESET:0x0"
          
group.long  0x32f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_11, FR_UV_DMA_WRITER_REGISTER_11 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_BRESP ,AXI_FAIL_BRESP RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_AWMAXWAIT ,AXI_FAIL_AWMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_WMAXWAIT ,AXI_FAIL_WMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_WXACT_OSTAND ,AXI_FAIL_WXACT_OSTAND RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_WIDTH ,VI_FAIL_ACTIVE_WIDTH RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_HEIGHT ,VI_FAIL_ACTIVE_HEIGHT RESET:0x0"
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_11_VI_FAIL_INTERLINE_BLANKS ,VI_FAIL_INTERLINE_BLANKS RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_11_VI_FAIL_INTERFRAME_BLANKS ,VI_FAIL_INTERFRAME_BLANKS RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_11_VIDEO_ALARM ,VIDEO_ALARM RESET:0x0"
          
          
rgroup.long 0x32f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_12, FR_UV_DMA_WRITER_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_12_BLK_STATUS ,BLK_STATUS RESET:0x0"
          
group.long  0x32fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_13, FR_UV_DMA_WRITER_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_13_LINES_WRAPPED ,LINES_WRAPPED RESET:0x0"
          
          
group.long  0x3300++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_14, FR_UV_DMA_WRITER_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_14_LINETICK_FIRST ,LINETICK_FIRST RESET:0x0"
          
          
group.long  0x3304++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_15, FR_UV_DMA_WRITER_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_15_LINETICK_REPEAT ,LINETICK_REPEAT RESET:0x0"
          
          
group.long  0x3308++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_16, FR_UV_DMA_WRITER_REGISTER_16 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_16_LINETICK_EOL ,LINETICK_EOL RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_16_LINETICK_DELAY ,LINETICK_DELAY RESET:0x0"
          
group.long  0x330c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_17, FR_UV_DMA_WRITER_REGISTER_17 RESET:0xf000f0c"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_17_PAGEWARM_ON ,PAGEWARM_ON RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_17_AXI_ID_MULTI ,AXI_ID_MULTI RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_17_AXI_BURSTSPLIT ,AXI_BURSTSPLIT RESET:0x3"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_17_AXI_CACHE_VALUE ,AXI_CACHE_VALUE RESET:0xf"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_17_AXI_MAXOSTAND ,AXI_MAXOSTAND RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_17_AXI_MAX_AWLEN ,AXI_MAX_AWLEN RESET:0xf"
          
          
group.long  0x3310++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_18, FR_UV_DMA_WRITER_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_FR_UV_DMA_WRITER_REGISTER_18_AXI_ID_VALUE ,AXI_ID_VALUE RESET:0x0"
          
          
group.long  0x3314++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CROP_REGISTER_0, DS_CROP_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CROP_REGISTER_0_ENABLE_CROP ,ENABLE_CROP RESET:0x0"
          
          
group.long  0x3318++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CROP_REGISTER_1, DS_CROP_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CROP_REGISTER_1_START_X ,START_X RESET:0x0"
          
          
group.long  0x331c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CROP_REGISTER_2, DS_CROP_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CROP_REGISTER_2_START_Y ,START_Y RESET:0x0"
          
          
group.long  0x3320++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CROP_REGISTER_3, DS_CROP_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CROP_REGISTER_3_SIZE_X ,SIZE_X RESET:0x0"
          
          
group.long  0x3324++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CROP_REGISTER_4, DS_CROP_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CROP_REGISTER_4_SIZE_Y ,SIZE_Y RESET:0x0"
          
          
group.long  0x332c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_0, DS_SCALER_REGISTER_0 RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_0_TIMEOUT_ENABLE ,TIMEOUT_ENABLE RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_0_TIMEOUT_VALUE ,TIMEOUT_VALUE RESET:0x0"
          
group.long  0x3330++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_1, DS_SCALER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_1_WIDTH ,WIDTH RESET:0x0"
          
          
group.long  0x3334++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_2, DS_SCALER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_2_HEIGHT ,HEIGHT RESET:0x0"
          
          
group.long  0x3338++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_3, DS_SCALER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_3_OWIDTH ,OWIDTH RESET:0x0"
          
          
group.long  0x333c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_4, DS_SCALER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_4_OHEIGHT ,OHEIGHT RESET:0x0"
          
          
group.long  0x3340++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_5, DS_SCALER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_5_HFILT_TINC ,HFILT_TINC RESET:0x0"
          
          
group.long  0x3344++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_6, DS_SCALER_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_6_HFILT_COEFSET ,HFILT_COEFSET RESET:0x0"
          
          
group.long  0x3348++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_7, DS_SCALER_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_7_VFILT_TINC ,VFILT_TINC RESET:0x0"
          
          
group.long  0x334c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_8, DS_SCALER_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SCALER_REGISTER_8_VFILT_COEFSET ,VFILT_COEFSET RESET:0x0"
          
          
group.long  0x3350++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_GAMMA_RGB_REGISTER_0, DS_GAMMA_RGB_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_GAMMA_RGB_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
          
group.long  0x3354++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_GAMMA_RGB_REGISTER_1, DS_GAMMA_RGB_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_GAMMA_RGB_REGISTER_1_GAIN_R ,GAIN_R RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_GAMMA_RGB_REGISTER_1_GAIN_G ,GAIN_G RESET:0x0"
          
          
group.long  0x3358++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_GAMMA_RGB_REGISTER_2, DS_GAMMA_RGB_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_GAMMA_RGB_REGISTER_2_GAIN_B ,GAIN_B RESET:0x0"
          
          
group.long  0x335c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_GAMMA_RGB_REGISTER_3, DS_GAMMA_RGB_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_GAMMA_RGB_REGISTER_3_OFFSET_R ,OFFSET_R RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_GAMMA_RGB_REGISTER_3_OFFSET_G ,OFFSET_G RESET:0x0"
          
          
group.long  0x3360++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_GAMMA_RGB_REGISTER_4, DS_GAMMA_RGB_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_GAMMA_RGB_REGISTER_4_OFFSET_B ,OFFSET_B RESET:0x0"
          
          
group.long  0x3364++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_0, DS_SHARPEN_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
          
group.long  0x3368++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_1, DS_SHARPEN_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_1_STRENGTH ,STRENGTH RESET:0x0"
          
          
group.long  0x336c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_2, DS_SHARPEN_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_2_CONTROL_R ,CONTROL_R RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_2_CONTROL_B ,CONTROL_B RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_2_ALPHA_UNDERSHOOT ,ALPHA_UNDERSHOOT RESET:0x0"
          
          
group.long  0x3370++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_3, DS_SHARPEN_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_3_LUMA_THRESH_LOW ,LUMA_THRESH_LOW RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_3_LUMA_OFFSET_LOW ,LUMA_OFFSET_LOW RESET:0x0"
          
          
group.long  0x3374++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_4, DS_SHARPEN_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_4_LUMA_SLOPE_LOW ,LUMA_SLOPE_LOW RESET:0x0"
          
         hexmask.long 0x00 16.--25. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_4_LUMA_THRESH_HIGH ,LUMA_THRESH_HIGH RESET:0x0"
          
          
group.long  0x3378++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_5, DS_SHARPEN_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_5_LUMA_OFFSET_HIGH ,LUMA_OFFSET_HIGH RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_5_LUMA_SLOPE_HIGH ,LUMA_SLOPE_HIGH RESET:0x0"
          
group.long  0x337c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_6, DS_SHARPEN_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_6_CLIP_STR_MAX ,CLIP_STR_MAX RESET:0x0"
          
          
         hexmask.long 0x00 16.--29. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_6_CLIP_STR_MIN ,CLIP_STR_MIN RESET:0x0"
          
          
group.long  0x3380++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_7, DS_SHARPEN_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_SHARPEN_REGISTER_7_DEBUG ,DEBUG RESET:0x0"
          
          
group.long  0x3384++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_0, DS_CS_CONV_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_0_ENABLE_MATRIX ,ENABLE_MATRIX RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_0_ENABLE_FILTER ,ENABLE_FILTER RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_0_ENABLE_HORIZONTAL_DOWNSAMPLE ,ENABLE_HORIZONTAL_DOWNSAMPLE RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_0_ENABLE_VERTICAL_DOWNSAMPLE ,ENABLE_VERTICAL_DOWNSAMPLE RESET:0x0"
          
          
group.long  0x3388++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_1, DS_CS_CONV_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_1_COEFFT_11 ,COEFFT_11 RESET:0x0"
          
          
group.long  0x338c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_2, DS_CS_CONV_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_2_COEFFT_12 ,COEFFT_12 RESET:0x0"
          
          
group.long  0x3390++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_3, DS_CS_CONV_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_3_COEFFT_13 ,COEFFT_13 RESET:0x0"
          
          
group.long  0x3394++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_4, DS_CS_CONV_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_4_COEFFT_21 ,COEFFT_21 RESET:0x0"
          
          
group.long  0x3398++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_5, DS_CS_CONV_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_5_COEFFT_22 ,COEFFT_22 RESET:0x0"
          
          
group.long  0x339c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_6, DS_CS_CONV_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_6_COEFFT_23 ,COEFFT_23 RESET:0x0"
          
          
group.long  0x33a0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_7, DS_CS_CONV_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_7_COEFFT_31 ,COEFFT_31 RESET:0x0"
          
          
group.long  0x33a4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_8, DS_CS_CONV_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_8_COEFFT_32 ,COEFFT_32 RESET:0x0"
          
          
group.long  0x33a8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_9, DS_CS_CONV_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_9_COEFFT_33 ,COEFFT_33 RESET:0x0"
          
          
group.long  0x33ac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_10, DS_CS_CONV_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_10_COEFFT_O1 ,COEFFT_O1 RESET:0x0"
          
          
group.long  0x33b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_11, DS_CS_CONV_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_11_COEFFT_O2 ,COEFFT_O2 RESET:0x0"
          
          
group.long  0x33b4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_12, DS_CS_CONV_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_12_COEFFT_O3 ,COEFFT_O3 RESET:0x0"
          
          
group.long  0x33b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_13, DS_CS_CONV_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_13_CLIP_MIN_Y ,CLIP_MIN_Y RESET:0x0"
          
          
group.long  0x33bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_14, DS_CS_CONV_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_14_CLIP_MAX_Y ,CLIP_MAX_Y RESET:0x0"
          
          
group.long  0x33c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_15, DS_CS_CONV_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_15_CLIP_MIN_UV ,CLIP_MIN_UV RESET:0x0"
          
          
group.long  0x33c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_16, DS_CS_CONV_REGISTER_16 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_16_CLIP_MAX_UV ,CLIP_MAX_UV RESET:0x0"
          
          
group.long  0x33c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_17, DS_CS_CONV_REGISTER_17 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_17_DATA_MASK_RY ,DATA_MASK_RY RESET:0x0"
          
          
group.long  0x33cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_18, DS_CS_CONV_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_18_DATA_MASK_GU ,DATA_MASK_GU RESET:0x0"
          
          
group.long  0x33d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_19, DS_CS_CONV_REGISTER_19 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_REGISTER_19_DATA_MASK_BV ,DATA_MASK_BV RESET:0x0"
          
          
group.long  0x33d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_DITHER_REGISTER_0, DS_CS_CONV_DITHER_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_DITHER_REGISTER_0_ENABLE_DITHER ,ENABLE_DITHER RESET:0x0"
          
         hexmask.long 0x00 1.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_DITHER_REGISTER_0_DITHER_AMOUNT ,DITHER_AMOUNT RESET:0x0"
          
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_CS_CONV_DITHER_REGISTER_0_SHIFT_MODE ,SHIFT_MODE RESET:0x0"
          
          
group.long  0x33d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_0, DS_DMA_WRITER_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_0_FORMAT ,FORMAT RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_0_SINGLE_FRAME ,SINGLE_FRAME RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_0_FRAME_WRITE_ON ,FRAME_WRITE_ON RESET:0x0"
          
          
         bitfld.long 0x00 11. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_0_AXI_XACT_COMP ,AXI_XACT_COMP RESET:0x0"
          
          
group.long  0x33dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_1, DS_DMA_WRITER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_1_ACTIVE_WIDTH ,ACTIVE_WIDTH RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_1_ACTIVE_HEIGHT ,ACTIVE_HEIGHT RESET:0x0"
          
group.long  0x33e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_2, DS_DMA_WRITER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_2_BANK0_BASE ,BANK0_BASE RESET:0x0"
          
group.long  0x33e4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_3, DS_DMA_WRITER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_3_BANK1_BASE ,BANK1_BASE RESET:0x0"
          
group.long  0x33e8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_4, DS_DMA_WRITER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_4_BANK2_BASE ,BANK2_BASE RESET:0x0"
          
group.long  0x33ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_5, DS_DMA_WRITER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_5_BANK3_BASE ,BANK3_BASE RESET:0x0"
          
group.long  0x33f0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_6, DS_DMA_WRITER_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_6_BANK4_BASE ,BANK4_BASE RESET:0x0"
          
group.long  0x33f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_7, DS_DMA_WRITER_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_7_MAX_BANK ,MAX_BANK RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_7_BANK0_RESTART ,BANK0_RESTART RESET:0x0"
          
          
group.long  0x33f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_8, DS_DMA_WRITER_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_8_LINE_OFFSET ,LINE_OFFSET RESET:0x0"
          
group.long  0x33fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_9, DS_DMA_WRITER_REGISTER_9 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_9_WBANK_ACTIVE ,WBANK_ACTIVE RESET:0x0"
          
         hexmask.long 0x00 1.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_9_WBANK_CURR ,WBANK_CURR RESET:0x0"
          
          
rgroup.long 0x3408++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_10, DS_DMA_WRITER_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_10_FRAME_ICOUNT ,FRAME_ICOUNT RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_10_FRAME_WCOUNT ,FRAME_WCOUNT RESET:0x0"
          
group.long  0x3410++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_11, DS_DMA_WRITER_REGISTER_11 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_11_AXI_FAIL_BRESP ,AXI_FAIL_BRESP RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_11_AXI_FAIL_AWMAXWAIT ,AXI_FAIL_AWMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_11_AXI_FAIL_WMAXWAIT ,AXI_FAIL_WMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_11_AXI_FAIL_WXACT_OSTAND ,AXI_FAIL_WXACT_OSTAND RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_WIDTH ,VI_FAIL_ACTIVE_WIDTH RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_HEIGHT ,VI_FAIL_ACTIVE_HEIGHT RESET:0x0"
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_11_VI_FAIL_INTERLINE_BLANKS ,VI_FAIL_INTERLINE_BLANKS RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_11_VI_FAIL_INTERFRAME_BLANKS ,VI_FAIL_INTERFRAME_BLANKS RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_11_VIDEO_ALARM ,VIDEO_ALARM RESET:0x0"
          
          
rgroup.long 0x3414++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_12, DS_DMA_WRITER_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_12_BLK_STATUS ,BLK_STATUS RESET:0x0"
          
group.long  0x3418++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_13, DS_DMA_WRITER_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_13_LINES_WRAPPED ,LINES_WRAPPED RESET:0x0"
          
          
group.long  0x341c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_14, DS_DMA_WRITER_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_14_LINETICK_FIRST ,LINETICK_FIRST RESET:0x0"
          
          
group.long  0x3420++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_15, DS_DMA_WRITER_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_15_LINETICK_REPEAT ,LINETICK_REPEAT RESET:0x0"
          
          
group.long  0x3424++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_16, DS_DMA_WRITER_REGISTER_16 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_16_LINETICK_EOL ,LINETICK_EOL RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_16_LINETICK_DELAY ,LINETICK_DELAY RESET:0x0"
          
group.long  0x3428++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_17, DS_DMA_WRITER_REGISTER_17 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_17_PAGEWARM_ON ,PAGEWARM_ON RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_17_AXI_ID_MULTI ,AXI_ID_MULTI RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_17_AXI_BURSTSPLIT ,AXI_BURSTSPLIT RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_17_AXI_CACHE_VALUE ,AXI_CACHE_VALUE RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_17_AXI_MAXOSTAND ,AXI_MAXOSTAND RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_17_AXI_MAX_AWLEN ,AXI_MAX_AWLEN RESET:0x0"
          
          
group.long  0x342c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_18, DS_DMA_WRITER_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_DMA_WRITER_REGISTER_18_AXI_ID_VALUE ,AXI_ID_VALUE RESET:0x0"
          
          
group.long  0x3430++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_0, DS_UV_DMA_WRITER_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_0_FORMAT ,FORMAT RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_0_SINGLE_FRAME ,SINGLE_FRAME RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_0_FRAME_WRITE_ON ,FRAME_WRITE_ON RESET:0x0"
          
          
         bitfld.long 0x00 11. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_0_AXI_XACT_COMP ,AXI_XACT_COMP RESET:0x0"
          
          
group.long  0x3434++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_1, DS_UV_DMA_WRITER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_1_ACTIVE_WIDTH ,ACTIVE_WIDTH RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_1_ACTIVE_HEIGHT ,ACTIVE_HEIGHT RESET:0x0"
          
group.long  0x3438++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_2, DS_UV_DMA_WRITER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_2_BANK0_BASE ,BANK0_BASE RESET:0x0"
          
group.long  0x343c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_3, DS_UV_DMA_WRITER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_3_BANK1_BASE ,BANK1_BASE RESET:0x0"
          
group.long  0x3440++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_4, DS_UV_DMA_WRITER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_4_BANK2_BASE ,BANK2_BASE RESET:0x0"
          
group.long  0x3444++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_5, DS_UV_DMA_WRITER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_5_BANK3_BASE ,BANK3_BASE RESET:0x0"
          
group.long  0x3448++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_6, DS_UV_DMA_WRITER_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_6_BANK4_BASE ,BANK4_BASE RESET:0x0"
          
group.long  0x344c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_7, DS_UV_DMA_WRITER_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_7_MAX_BANK ,MAX_BANK RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_7_BANK0_RESTART ,BANK0_RESTART RESET:0x0"
          
          
group.long  0x3450++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_8, DS_UV_DMA_WRITER_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_8_LINE_OFFSET ,LINE_OFFSET RESET:0x0"
          
group.long  0x3454++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_9, DS_UV_DMA_WRITER_REGISTER_9 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_9_WBANK_ACTIVE ,WBANK_ACTIVE RESET:0x0"
          
         hexmask.long 0x00 1.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_9_WBANK_CURR ,WBANK_CURR RESET:0x0"
          
          
rgroup.long 0x3460++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_10, DS_UV_DMA_WRITER_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_10_FRAME_ICOUNT ,FRAME_ICOUNT RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_10_FRAME_WCOUNT ,FRAME_WCOUNT RESET:0x0"
          
group.long  0x3468++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_11, DS_UV_DMA_WRITER_REGISTER_11 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_BRESP ,AXI_FAIL_BRESP RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_AWMAXWAIT ,AXI_FAIL_AWMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_WMAXWAIT ,AXI_FAIL_WMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_WXACT_OSTAND ,AXI_FAIL_WXACT_OSTAND RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_WIDTH ,VI_FAIL_ACTIVE_WIDTH RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_HEIGHT ,VI_FAIL_ACTIVE_HEIGHT RESET:0x0"
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_11_VI_FAIL_INTERLINE_BLANKS ,VI_FAIL_INTERLINE_BLANKS RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_11_VI_FAIL_INTERFRAME_BLANKS ,VI_FAIL_INTERFRAME_BLANKS RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_11_VIDEO_ALARM ,VIDEO_ALARM RESET:0x0"
          
          
rgroup.long 0x346c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_12, DS_UV_DMA_WRITER_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_12_BLK_STATUS ,BLK_STATUS RESET:0x0"
          
group.long  0x3470++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_13, DS_UV_DMA_WRITER_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_13_LINES_WRAPPED ,LINES_WRAPPED RESET:0x0"
          
          
group.long  0x3474++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_14, DS_UV_DMA_WRITER_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_14_LINETICK_FIRST ,LINETICK_FIRST RESET:0x0"
          
          
group.long  0x3478++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_15, DS_UV_DMA_WRITER_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_15_LINETICK_REPEAT ,LINETICK_REPEAT RESET:0x0"
          
          
group.long  0x347c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_16, DS_UV_DMA_WRITER_REGISTER_16 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_16_LINETICK_EOL ,LINETICK_EOL RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_16_LINETICK_DELAY ,LINETICK_DELAY RESET:0x0"
          
group.long  0x3480++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_17, DS_UV_DMA_WRITER_REGISTER_17 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_17_PAGEWARM_ON ,PAGEWARM_ON RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_17_AXI_ID_MULTI ,AXI_ID_MULTI RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_17_AXI_BURSTSPLIT ,AXI_BURSTSPLIT RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_17_AXI_CACHE_VALUE ,AXI_CACHE_VALUE RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_17_AXI_MAXOSTAND ,AXI_MAXOSTAND RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_17_AXI_MAX_AWLEN ,AXI_MAX_AWLEN RESET:0x0"
          
          
group.long  0x3484++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_18, DS_UV_DMA_WRITER_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_DS_UV_DMA_WRITER_REGISTER_18_AXI_ID_VALUE ,AXI_ID_VALUE RESET:0x0"
          
          
group.long  0x3488++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MULTI_CTX_REGISTER_0, MULTI_CTX_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PING_MULTI_CTX_REGISTER_0_CONFIG_DONE ,CONFIG_DONE RESET:0x0"
          
          
tree.end

tree "MALIC55__IP_CONFIG_TOP_METERING_STATS_PONG_MEM"
base e:0x4012156c
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_DECOMPANDER0_PONG_MEM"
base e:0x40122b2c
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_DECOMPANDER1_PONG_MEM"
base e:0x40122bb0
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_MESH_SHADING_PONG_MEM"
base e:0x4012b034
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_FR_GAMMA_RGB_PONG_MEM"
base e:0x40130240
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_DS_GAMMA_RGB_PONG_MEM"
base e:0x40130444
width 80.
tree.end

tree "MALIC55__IP_CONFIG_TOP_ISP_CONFIG_PONG"
base e:0x40130e48
width 80.
group.long  0x0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_0, TOP_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_0_ACTIVE_WIDTH ,ACTIVE_WIDTH RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_0_ACTIVE_HEIGHT ,ACTIVE_HEIGHT RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_1, TOP_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_1_RGGB_START ,RGGB_START RESET:0x0"
          
          
         hexmask.long 0x00 16.--17. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_1_CFA_PATTERN ,CFA_PATTERN RESET:0x0"
          
          
         hexmask.long 0x00 24.--25. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_1_LINEAR_DATA_SRC ,LINEAR_DATA_SRC RESET:0x0"
          
          
group.long  0x24++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_2, TOP_REGISTER_2 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_2_BYPASS_VIDEO_TEST_GEN ,BYPASS_VIDEO_TEST_GEN RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_2_BYPASS_INPUT_FORMATTER ,BYPASS_INPUT_FORMATTER RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_2_BYPASS_DECOMPANDER ,BYPASS_DECOMPANDER RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_2_BYPASS_SENSOR_OFFSET_WDR ,BYPASS_SENSOR_OFFSET_WDR RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_2_BYPASS_GAIN_WDR ,BYPASS_GAIN_WDR RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_2_BYPASS_FRAME_STITCH ,BYPASS_FRAME_STITCH RESET:0x0"
          
          
group.long  0x28++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_3, TOP_REGISTER_3 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_3_BYPASS_DIGITAL_GAIN ,BYPASS_DIGITAL_GAIN RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_3_BYPASS_FRONTEND_SENSOR_OFFSET ,BYPASS_FRONTEND_SENSOR_OFFSET RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_3_BYPASS_FE_SQRT ,BYPASS_FE_SQRT RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_3_BYPASS_RAW_FRONTEND ,BYPASS_RAW_FRONTEND RESET:0x0"
          
          
group.long  0x30++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_4, TOP_REGISTER_4 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_4_BYPASS_SINTER ,BYPASS_SINTER RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_4_BYPASS_TEMPER ,BYPASS_TEMPER RESET:0x0"
          
          
group.long  0x34++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_5, TOP_REGISTER_5 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_5_BYPASS_SQUARE_BE ,BYPASS_SQUARE_BE RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_5_BYPASS_SENSOR_OFFSET_PRE_SHADING ,BYPASS_SENSOR_OFFSET_PRE_SHADING RESET:0x0"
          
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_5_BYPASS_MESH_SHADING ,BYPASS_MESH_SHADING RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_5_BYPASS_WHITE_BALANCE ,BYPASS_WHITE_BALANCE RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_5_BYPASS_IRIDIX_GAIN ,BYPASS_IRIDIX_GAIN RESET:0x0"
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_5_BYPASS_IRIDIX ,BYPASS_IRIDIX RESET:0x0"
          
          
group.long  0x38++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_6, TOP_REGISTER_6 RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_6_BYPASS_DEMOSAIC_RGB ,BYPASS_DEMOSAIC_RGB RESET:0x0"
          
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_6_BYPASS_PF_CORRECTION ,BYPASS_PF_CORRECTION RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_6_BYPASS_CCM ,BYPASS_CCM RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_6_BYPASS_CNR ,BYPASS_CNR RESET:0x0"
          
          
group.long  0x3c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_7, TOP_REGISTER_7 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_7_BYPASS_FR_CROP ,BYPASS_FR_CROP RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_7_BYPASS_FR_SCALER ,BYPASS_FR_SCALER RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_7_BYPASS_FR_GAMMA_RGB ,BYPASS_FR_GAMMA_RGB RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_7_BYPASS_FR_SHARPEN ,BYPASS_FR_SHARPEN RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_7_BYPASS_FR_CS_CONV ,BYPASS_FR_CS_CONV RESET:0x0"
          
          
group.long  0x40++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_8, TOP_REGISTER_8 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_8_BYPASS_DS_CROP ,BYPASS_DS_CROP RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_8_BYPASS_DS_SCALER ,BYPASS_DS_SCALER RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_8_BYPASS_DS_GAMMA_RGB ,BYPASS_DS_GAMMA_RGB RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_8_BYPASS_DS_SHARPEN ,BYPASS_DS_SHARPEN RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_8_BYPASS_DS_CS_CONV ,BYPASS_DS_CS_CONV RESET:0x0"
          
          
group.long  0x44++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_9, TOP_REGISTER_9 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_9_ISP_RAW_BYPASS ,ISP_RAW_BYPASS RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_9_ISP_DOWNSCALE_PIPE_DISABLE ,ISP_DOWNSCALE_PIPE_DISABLE RESET:0x0"
          
          
         hexmask.long 0x00 8.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_9_ISP_PROCESSING_FR_BYPASS_MODE ,ISP_PROCESSING_FR_BYPASS_MODE RESET:0x0"
          
          
group.long  0x48++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_10, TOP_REGISTER_10 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_10_AE_5BIN_HIST_DISABLE ,AE_5BIN_HIST_DISABLE RESET:0x0"
          
         hexmask.long 0x00 1.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_10_AE_SWITCH ,AE_SWITCH RESET:0x0"
          
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_10_AF_DISABLE ,AF_DISABLE RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_10_AF_SWITCH ,AF_SWITCH RESET:0x0"
          
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_10_AWB_DISABLE ,AWB_DISABLE RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_10_AWB_SWITCH ,AWB_SWITCH RESET:0x0"
          
          
         bitfld.long 0x00 12. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_10_AEXP_HIST_DISABLE ,AEXP_HIST_DISABLE RESET:0x0"
          
         hexmask.long 0x00 13.--14. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_10_AEXP_HISTOGRAM_SWITCH ,AEXP_HISTOGRAM_SWITCH RESET:0x0"
          
          
         bitfld.long 0x00 16. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_10_IHIST_DISABLE ,IHIST_DISABLE RESET:0x0"
          
          
         bitfld.long 0x00 24. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TOP_REGISTER_10_AEXP_SRC ,AEXP_SRC RESET:0x0"
          
          
group.long  0x4c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CROSSBAR_REGISTER_0, CROSSBAR_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CROSSBAR_REGISTER_0_CHANNEL0_SELECT ,CHANNEL0_SELECT RESET:0x0"
          
          
         hexmask.long 0x00 8.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CROSSBAR_REGISTER_0_CHANNEL1_SELECT ,CHANNEL1_SELECT RESET:0x0"
          
          
         hexmask.long 0x00 16.--17. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CROSSBAR_REGISTER_0_CHANNEL2_SELECT ,CHANNEL2_SELECT RESET:0x0"
          
          
group.long  0x50++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_0, VIDEO_TEST_GEN_CH0_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_0_TEST_PATTERN_OFF_ON ,TEST_PATTERN_OFF_ON RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_0_BAYER_RGB_O_SEL ,BAYER_RGB_O_SEL RESET:0x0"
          
          
group.long  0x54++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_1, VIDEO_TEST_GEN_CH0_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_1_PATTERN_TYPE ,PATTERN_TYPE RESET:0x0"
          
          
group.long  0x58++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_2, VIDEO_TEST_GEN_CH0_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_2_R_BACKGND ,R_BACKGND RESET:0x0"
          
          
group.long  0x5c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_3, VIDEO_TEST_GEN_CH0_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_3_G_BACKGND ,G_BACKGND RESET:0x0"
          
          
group.long  0x60++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_4, VIDEO_TEST_GEN_CH0_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_4_B_BACKGND ,B_BACKGND RESET:0x0"
          
          
group.long  0x64++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_5, VIDEO_TEST_GEN_CH0_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_5_R_FOREGND ,R_FOREGND RESET:0x0"
          
          
group.long  0x68++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_6, VIDEO_TEST_GEN_CH0_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_6_G_FOREGND ,G_FOREGND RESET:0x0"
          
          
group.long  0x6c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_7, VIDEO_TEST_GEN_CH0_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_7_B_FOREGND ,B_FOREGND RESET:0x0"
          
          
group.long  0x70++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_8, VIDEO_TEST_GEN_CH0_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_8_RGB_GRADIENT ,RGB_GRADIENT RESET:0x0"
          
          
group.long  0x74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_9, VIDEO_TEST_GEN_CH0_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_9_RGB_GRADIENT_START ,RGB_GRADIENT_START RESET:0x0"
          
          
group.long  0x78++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_10, VIDEO_TEST_GEN_CH0_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_10_RECT_TOP ,RECT_TOP RESET:0x0"
          
          
         hexmask.long 0x00 16.--29. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_10_RECT_BOT ,RECT_BOT RESET:0x0"
          
          
group.long  0x7c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_11, VIDEO_TEST_GEN_CH0_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_11_RECT_LEFT ,RECT_LEFT RESET:0x0"
          
          
         hexmask.long 0x00 16.--29. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH0_REGISTER_11_RECT_RIGHT ,RECT_RIGHT RESET:0x0"
          
          
group.long  0x80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_0, VIDEO_TEST_GEN_CH1_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_0_TEST_PATTERN_OFF_ON ,TEST_PATTERN_OFF_ON RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_0_BAYER_RGB_O_SEL ,BAYER_RGB_O_SEL RESET:0x0"
          
          
group.long  0x84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_1, VIDEO_TEST_GEN_CH1_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_1_PATTERN_TYPE ,PATTERN_TYPE RESET:0x0"
          
          
group.long  0x88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_2, VIDEO_TEST_GEN_CH1_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_2_R_BACKGND ,R_BACKGND RESET:0x0"
          
          
group.long  0x8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_3, VIDEO_TEST_GEN_CH1_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_3_G_BACKGND ,G_BACKGND RESET:0x0"
          
          
group.long  0x90++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_4, VIDEO_TEST_GEN_CH1_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_4_B_BACKGND ,B_BACKGND RESET:0x0"
          
          
group.long  0x94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_5, VIDEO_TEST_GEN_CH1_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_5_R_FOREGND ,R_FOREGND RESET:0x0"
          
          
group.long  0x98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_6, VIDEO_TEST_GEN_CH1_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_6_G_FOREGND ,G_FOREGND RESET:0x0"
          
          
group.long  0x9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_7, VIDEO_TEST_GEN_CH1_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_7_B_FOREGND ,B_FOREGND RESET:0x0"
          
          
group.long  0xa0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_8, VIDEO_TEST_GEN_CH1_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_8_RGB_GRADIENT ,RGB_GRADIENT RESET:0x0"
          
          
group.long  0xa4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_9, VIDEO_TEST_GEN_CH1_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_9_RGB_GRADIENT_START ,RGB_GRADIENT_START RESET:0x0"
          
          
group.long  0xa8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_10, VIDEO_TEST_GEN_CH1_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_10_RECT_TOP ,RECT_TOP RESET:0x0"
          
          
         hexmask.long 0x00 16.--29. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_10_RECT_BOT ,RECT_BOT RESET:0x0"
          
          
group.long  0xac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_11, VIDEO_TEST_GEN_CH1_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_11_RECT_LEFT ,RECT_LEFT RESET:0x0"
          
          
         hexmask.long 0x00 16.--29. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_VIDEO_TEST_GEN_CH1_REGISTER_11_RECT_RIGHT ,RECT_RIGHT RESET:0x0"
          
          
group.long  0x110++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_0, INPUT_FORMATTER_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_0_MODE_IN ,MODE_IN RESET:0x0"
          
          
         hexmask.long 0x00 16.--18. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_0_INPUT_BITWIDTH_SELECT ,INPUT_BITWIDTH_SELECT RESET:0x0"
          
          
group.long  0x114++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_1, INPUT_FORMATTER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_1_FACTOR_ML ,FACTOR_ML RESET:0x0"
          
          
group.long  0x118++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_2, INPUT_FORMATTER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_2_FACTOR_MS ,FACTOR_MS RESET:0x0"
          
          
group.long  0x11c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_3, INPUT_FORMATTER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_3_BLACK_LEVEL ,BLACK_LEVEL RESET:0x0"
          
          
group.long  0x120++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_4, INPUT_FORMATTER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_4_KNEE_POINT0 ,KNEE_POINT0 RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_4_KNEE_POINT1 ,KNEE_POINT1 RESET:0x0"
          
          
group.long  0x124++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_5, INPUT_FORMATTER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_5_KNEE_POINT2 ,KNEE_POINT2 RESET:0x0"
          
          
group.long  0x128++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_6, INPUT_FORMATTER_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_6_SLOPE0_SELECT ,SLOPE0_SELECT RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_6_SLOPE1_SELECT ,SLOPE1_SELECT RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_6_SLOPE2_SELECT ,SLOPE2_SELECT RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_INPUT_FORMATTER_REGISTER_6_SLOPE3_SELECT ,SLOPE3_SELECT RESET:0x0"
          
          
group.long  0x13c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_WDR_L_REGISTER_0, SENSOR_OFFSET_WDR_L_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_WDR_L_REGISTER_0_OFFSET_00 ,OFFSET_00 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_WDR_L_REGISTER_0_OFFSET_01 ,OFFSET_01 RESET:0x0"
          
          
group.long  0x140++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_WDR_L_REGISTER_1, SENSOR_OFFSET_WDR_L_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_WDR_L_REGISTER_1_OFFSET_10 ,OFFSET_10 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_WDR_L_REGISTER_1_OFFSET_11 ,OFFSET_11 RESET:0x0"
          
          
group.long  0x144++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_WDR_M_REGISTER_0, SENSOR_OFFSET_WDR_M_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_WDR_M_REGISTER_0_OFFSET_00 ,OFFSET_00 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_WDR_M_REGISTER_0_OFFSET_01 ,OFFSET_01 RESET:0x0"
          
          
group.long  0x148++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_WDR_M_REGISTER_1, SENSOR_OFFSET_WDR_M_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_WDR_M_REGISTER_1_OFFSET_10 ,OFFSET_10 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_WDR_M_REGISTER_1_OFFSET_11 ,OFFSET_11 RESET:0x0"
          
          
group.long  0x150++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_GAIN_WDR_REGISTER_0, GAIN_WDR_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_GAIN_WDR_REGISTER_0_GAIN_L ,GAIN_L RESET:0x0"
          
          
         hexmask.long 0x00 16.--28. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_GAIN_WDR_REGISTER_0_GAIN_M ,GAIN_M RESET:0x0"
          
          
group.long  0x158++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_GAIN_WDR_REGISTER_1, GAIN_WDR_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_GAIN_WDR_REGISTER_1_BLACK_LEVEL_L ,BLACK_LEVEL_L RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_GAIN_WDR_REGISTER_1_BLACK_LEVEL_M ,BLACK_LEVEL_M RESET:0x0"
          
          
group.long  0x160++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_0, FRAME_STITCH_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_0_LM_EXPOSURE_RATIO ,LM_EXPOSURE_RATIO RESET:0x0"
          
          
group.long  0x168++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_1, FRAME_STITCH_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_1_LM_THRESH_HIGH ,LM_THRESH_HIGH RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_1_LM_THRESH_LOW ,LM_THRESH_LOW RESET:0x0"
          
          
group.long  0x174++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_2, FRAME_STITCH_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_2_BLACK_LEVEL_LONG ,BLACK_LEVEL_LONG RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_2_BLACK_LEVEL_MEDIUM ,BLACK_LEVEL_MEDIUM RESET:0x0"
          
          
group.long  0x17c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_3, FRAME_STITCH_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_3_BLACK_LEVEL_OUT ,BLACK_LEVEL_OUT RESET:0x0"
          
          
group.long  0x180++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_4, FRAME_STITCH_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_4_LM_NP_MULT ,LM_NP_MULT RESET:0x0"
          
          
group.long  0x184++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_5, FRAME_STITCH_REGISTER_5 RESET:0x0"
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_5_LM_ALPHA_MOV_SLOPE ,LM_ALPHA_MOV_SLOPE RESET:0x0"
          
          
group.long  0x18c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_6, FRAME_STITCH_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_6_GAIN_R ,GAIN_R RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_6_GAIN_B ,GAIN_B RESET:0x0"
          
          
group.long  0x198++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_7, FRAME_STITCH_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_7_LM_NOISE_THRESH ,LM_NOISE_THRESH RESET:0x0"
          
          
         hexmask.long 0x00 8.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_7_LM_POS_WEIGHT ,LM_POS_WEIGHT RESET:0x0"
          
          
         hexmask.long 0x00 16.--21. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_7_LM_NEG_WEIGHT ,LM_NEG_WEIGHT RESET:0x0"
          
          
group.long  0x19c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_8, FRAME_STITCH_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_8_LM_MED_NOISE_ALPHA_THRESH ,LM_MED_NOISE_ALPHA_THRESH RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_8_LM_MED_NOISE_INTENSITY_THRESH ,LM_MED_NOISE_INTENSITY_THRESH RESET:0x0"
          
          
group.long  0x1c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_9, FRAME_STITCH_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_9_MCOFF_WB_OFFSET ,MCOFF_WB_OFFSET RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_9_EXPOSURE_MASK_THRESH ,EXPOSURE_MASK_THRESH RESET:0x0"
          
          
group.long  0x1c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_10, FRAME_STITCH_REGISTER_10 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_10_BWB_SELECT ,BWB_SELECT RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_10_USE_3X3_MAX ,USE_3X3_MAX RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_10_MCOFF_NC_ENABLE ,MCOFF_NC_ENABLE RESET:0x0"
          
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_10_MCOFF_MODE_ENABLE ,MCOFF_MODE_ENABLE RESET:0x0"
          
          
group.long  0x1c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_11, FRAME_STITCH_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_11_MCOFF_L_MAX ,MCOFF_L_MAX RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_11_MCOFF_M_MAX ,MCOFF_M_MAX RESET:0x0"
          
          
group.long  0x1d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_12, FRAME_STITCH_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_12_MCOFF_L_SCALER ,MCOFF_L_SCALER RESET:0x0"
          
          
group.long  0x1d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_13, FRAME_STITCH_REGISTER_13 RESET:0x0"
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_13_MCOFF_NC_THRESH_LOW ,MCOFF_NC_THRESH_LOW RESET:0x0"
          
          
group.long  0x1d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_14, FRAME_STITCH_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_14_MCOFF_NC_THRESH_HIGH ,MCOFF_NC_THRESH_HIGH RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_REGISTER_14_MCOFF_NC_SCALE ,MCOFF_NC_SCALE RESET:0x0"
          
          
group.long  0x35c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_0, FRAME_STITCH_NP_LUT_L_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT0 ,WEIGHT_LUT_REG0_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT1 ,WEIGHT_LUT_REG0_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT2 ,WEIGHT_LUT_REG0_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT3 ,WEIGHT_LUT_REG0_SEGMENT3 RESET:0x0"
          
group.long  0x360++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_1, FRAME_STITCH_NP_LUT_L_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT0 ,WEIGHT_LUT_REG1_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT1 ,WEIGHT_LUT_REG1_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT2 ,WEIGHT_LUT_REG1_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT3 ,WEIGHT_LUT_REG1_SEGMENT3 RESET:0x0"
          
group.long  0x364++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_2, FRAME_STITCH_NP_LUT_L_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT0 ,WEIGHT_LUT_REG2_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT1 ,WEIGHT_LUT_REG2_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT2 ,WEIGHT_LUT_REG2_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT3 ,WEIGHT_LUT_REG2_SEGMENT3 RESET:0x0"
          
group.long  0x368++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_3, FRAME_STITCH_NP_LUT_L_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT0 ,WEIGHT_LUT_REG3_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT1 ,WEIGHT_LUT_REG3_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT2 ,WEIGHT_LUT_REG3_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT3 ,WEIGHT_LUT_REG3_SEGMENT3 RESET:0x0"
          
group.long  0x36c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_4, FRAME_STITCH_NP_LUT_L_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT0 ,WEIGHT_LUT_REG4_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT1 ,WEIGHT_LUT_REG4_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT2 ,WEIGHT_LUT_REG4_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT3 ,WEIGHT_LUT_REG4_SEGMENT3 RESET:0x0"
          
group.long  0x370++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_5, FRAME_STITCH_NP_LUT_L_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT0 ,WEIGHT_LUT_REG5_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT1 ,WEIGHT_LUT_REG5_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT2 ,WEIGHT_LUT_REG5_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT3 ,WEIGHT_LUT_REG5_SEGMENT3 RESET:0x0"
          
group.long  0x374++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_6, FRAME_STITCH_NP_LUT_L_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT0 ,WEIGHT_LUT_REG6_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT1 ,WEIGHT_LUT_REG6_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT2 ,WEIGHT_LUT_REG6_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT3 ,WEIGHT_LUT_REG6_SEGMENT3 RESET:0x0"
          
group.long  0x378++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_7, FRAME_STITCH_NP_LUT_L_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT0 ,WEIGHT_LUT_REG7_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT1 ,WEIGHT_LUT_REG7_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT2 ,WEIGHT_LUT_REG7_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT3 ,WEIGHT_LUT_REG7_SEGMENT3 RESET:0x0"
          
group.long  0x37c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_8, FRAME_STITCH_NP_LUT_L_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT0 ,WEIGHT_LUT_REG8_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT1 ,WEIGHT_LUT_REG8_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT2 ,WEIGHT_LUT_REG8_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT3 ,WEIGHT_LUT_REG8_SEGMENT3 RESET:0x0"
          
group.long  0x380++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_9, FRAME_STITCH_NP_LUT_L_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT0 ,WEIGHT_LUT_REG9_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT1 ,WEIGHT_LUT_REG9_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT2 ,WEIGHT_LUT_REG9_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT3 ,WEIGHT_LUT_REG9_SEGMENT3 RESET:0x0"
          
group.long  0x384++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_10, FRAME_STITCH_NP_LUT_L_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT0 ,WEIGHT_LUT_REG10_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT1 ,WEIGHT_LUT_REG10_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT2 ,WEIGHT_LUT_REG10_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT3 ,WEIGHT_LUT_REG10_SEGMENT3 RESET:0x0"
          
group.long  0x388++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_11, FRAME_STITCH_NP_LUT_L_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT0 ,WEIGHT_LUT_REG11_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT1 ,WEIGHT_LUT_REG11_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT2 ,WEIGHT_LUT_REG11_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT3 ,WEIGHT_LUT_REG11_SEGMENT3 RESET:0x0"
          
group.long  0x38c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_12, FRAME_STITCH_NP_LUT_L_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT0 ,WEIGHT_LUT_REG12_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT1 ,WEIGHT_LUT_REG12_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT2 ,WEIGHT_LUT_REG12_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT3 ,WEIGHT_LUT_REG12_SEGMENT3 RESET:0x0"
          
group.long  0x390++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_13, FRAME_STITCH_NP_LUT_L_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT0 ,WEIGHT_LUT_REG13_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT1 ,WEIGHT_LUT_REG13_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT2 ,WEIGHT_LUT_REG13_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT3 ,WEIGHT_LUT_REG13_SEGMENT3 RESET:0x0"
          
group.long  0x394++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_14, FRAME_STITCH_NP_LUT_L_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT0 ,WEIGHT_LUT_REG14_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT1 ,WEIGHT_LUT_REG14_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT2 ,WEIGHT_LUT_REG14_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT3 ,WEIGHT_LUT_REG14_SEGMENT3 RESET:0x0"
          
group.long  0x398++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_15, FRAME_STITCH_NP_LUT_L_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT0 ,WEIGHT_LUT_REG15_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT1 ,WEIGHT_LUT_REG15_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT2 ,WEIGHT_LUT_REG15_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT3 ,WEIGHT_LUT_REG15_SEGMENT3 RESET:0x0"
          
group.long  0x39c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_16, FRAME_STITCH_NP_LUT_L_REGISTER_16 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT0 ,WEIGHT_LUT_REG16_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT1 ,WEIGHT_LUT_REG16_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT2 ,WEIGHT_LUT_REG16_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT3 ,WEIGHT_LUT_REG16_SEGMENT3 RESET:0x0"
          
group.long  0x3a0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_17, FRAME_STITCH_NP_LUT_L_REGISTER_17 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT0 ,WEIGHT_LUT_REG17_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT1 ,WEIGHT_LUT_REG17_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT2 ,WEIGHT_LUT_REG17_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT3 ,WEIGHT_LUT_REG17_SEGMENT3 RESET:0x0"
          
group.long  0x3a4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_18, FRAME_STITCH_NP_LUT_L_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT0 ,WEIGHT_LUT_REG18_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT1 ,WEIGHT_LUT_REG18_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT2 ,WEIGHT_LUT_REG18_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT3 ,WEIGHT_LUT_REG18_SEGMENT3 RESET:0x0"
          
group.long  0x3a8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_19, FRAME_STITCH_NP_LUT_L_REGISTER_19 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT0 ,WEIGHT_LUT_REG19_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT1 ,WEIGHT_LUT_REG19_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT2 ,WEIGHT_LUT_REG19_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT3 ,WEIGHT_LUT_REG19_SEGMENT3 RESET:0x0"
          
group.long  0x3ac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_20, FRAME_STITCH_NP_LUT_L_REGISTER_20 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT0 ,WEIGHT_LUT_REG20_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT1 ,WEIGHT_LUT_REG20_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT2 ,WEIGHT_LUT_REG20_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT3 ,WEIGHT_LUT_REG20_SEGMENT3 RESET:0x0"
          
group.long  0x3b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_21, FRAME_STITCH_NP_LUT_L_REGISTER_21 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT0 ,WEIGHT_LUT_REG21_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT1 ,WEIGHT_LUT_REG21_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT2 ,WEIGHT_LUT_REG21_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT3 ,WEIGHT_LUT_REG21_SEGMENT3 RESET:0x0"
          
group.long  0x3b4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_22, FRAME_STITCH_NP_LUT_L_REGISTER_22 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT0 ,WEIGHT_LUT_REG22_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT1 ,WEIGHT_LUT_REG22_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT2 ,WEIGHT_LUT_REG22_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT3 ,WEIGHT_LUT_REG22_SEGMENT3 RESET:0x0"
          
group.long  0x3b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_23, FRAME_STITCH_NP_LUT_L_REGISTER_23 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT0 ,WEIGHT_LUT_REG23_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT1 ,WEIGHT_LUT_REG23_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT2 ,WEIGHT_LUT_REG23_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT3 ,WEIGHT_LUT_REG23_SEGMENT3 RESET:0x0"
          
group.long  0x3bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_24, FRAME_STITCH_NP_LUT_L_REGISTER_24 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT0 ,WEIGHT_LUT_REG24_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT1 ,WEIGHT_LUT_REG24_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT2 ,WEIGHT_LUT_REG24_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT3 ,WEIGHT_LUT_REG24_SEGMENT3 RESET:0x0"
          
group.long  0x3c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_25, FRAME_STITCH_NP_LUT_L_REGISTER_25 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT0 ,WEIGHT_LUT_REG25_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT1 ,WEIGHT_LUT_REG25_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT2 ,WEIGHT_LUT_REG25_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT3 ,WEIGHT_LUT_REG25_SEGMENT3 RESET:0x0"
          
group.long  0x3c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_26, FRAME_STITCH_NP_LUT_L_REGISTER_26 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT0 ,WEIGHT_LUT_REG26_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT1 ,WEIGHT_LUT_REG26_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT2 ,WEIGHT_LUT_REG26_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT3 ,WEIGHT_LUT_REG26_SEGMENT3 RESET:0x0"
          
group.long  0x3c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_27, FRAME_STITCH_NP_LUT_L_REGISTER_27 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT0 ,WEIGHT_LUT_REG27_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT1 ,WEIGHT_LUT_REG27_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT2 ,WEIGHT_LUT_REG27_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT3 ,WEIGHT_LUT_REG27_SEGMENT3 RESET:0x0"
          
group.long  0x3cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_28, FRAME_STITCH_NP_LUT_L_REGISTER_28 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT0 ,WEIGHT_LUT_REG28_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT1 ,WEIGHT_LUT_REG28_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT2 ,WEIGHT_LUT_REG28_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT3 ,WEIGHT_LUT_REG28_SEGMENT3 RESET:0x0"
          
group.long  0x3d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_29, FRAME_STITCH_NP_LUT_L_REGISTER_29 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT0 ,WEIGHT_LUT_REG29_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT1 ,WEIGHT_LUT_REG29_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT2 ,WEIGHT_LUT_REG29_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT3 ,WEIGHT_LUT_REG29_SEGMENT3 RESET:0x0"
          
group.long  0x3d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_30, FRAME_STITCH_NP_LUT_L_REGISTER_30 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT0 ,WEIGHT_LUT_REG30_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT1 ,WEIGHT_LUT_REG30_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT2 ,WEIGHT_LUT_REG30_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT3 ,WEIGHT_LUT_REG30_SEGMENT3 RESET:0x0"
          
group.long  0x3d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_31, FRAME_STITCH_NP_LUT_L_REGISTER_31 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT0 ,WEIGHT_LUT_REG31_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT1 ,WEIGHT_LUT_REG31_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT2 ,WEIGHT_LUT_REG31_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FRAME_STITCH_NP_LUT_L_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT3 ,WEIGHT_LUT_REG31_SEGMENT3 RESET:0x0"
          
group.long  0x3dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DECOMPANDER0_REGISTER_0, DECOMPANDER0_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DECOMPANDER0_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DECOMPANDER0_REGISTER_0_OFFSET_MODE ,OFFSET_MODE RESET:0x0"
          
          
group.long  0x3e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DECOMPANDER1_REGISTER_0, DECOMPANDER1_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DECOMPANDER1_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DECOMPANDER1_REGISTER_0_OFFSET_MODE ,OFFSET_MODE RESET:0x0"
          
          
group.long  0x3e4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DIGITAL_GAIN_REGISTER_0, DIGITAL_GAIN_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DIGITAL_GAIN_REGISTER_0_GAIN ,GAIN RESET:0x0"
          
          
group.long  0x3e8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DIGITAL_GAIN_REGISTER_1, DIGITAL_GAIN_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DIGITAL_GAIN_REGISTER_1_OFFSET ,OFFSET RESET:0x0"
          
          
group.long  0x3ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_FE_REGISTER_0, SENSOR_OFFSET_FE_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_FE_REGISTER_0_OFFSET_00 ,OFFSET_00 RESET:0x0"
          
          
group.long  0x3f0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_FE_REGISTER_1, SENSOR_OFFSET_FE_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_FE_REGISTER_1_OFFSET_01 ,OFFSET_01 RESET:0x0"
          
          
group.long  0x3f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_FE_REGISTER_2, SENSOR_OFFSET_FE_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_FE_REGISTER_2_OFFSET_10 ,OFFSET_10 RESET:0x0"
          
          
group.long  0x3f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_FE_REGISTER_3, SENSOR_OFFSET_FE_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_FE_REGISTER_3_OFFSET_11 ,OFFSET_11 RESET:0x0"
          
          
group.long  0x3fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SQRT_REGISTER_0, SQRT_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SQRT_REGISTER_0_BLACK_LEVEL_IN ,BLACK_LEVEL_IN RESET:0x0"
          
          
group.long  0x400++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SQRT_REGISTER_1, SQRT_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SQRT_REGISTER_1_BLACK_LEVEL_OUT ,BLACK_LEVEL_OUT RESET:0x0"
          
          
         hexmask.long 0x00 15.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SQRT_REGISTER_1_NORMALIZATION ,NORMALIZATION RESET:0x0"
          
group.long  0x404++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_RAW_FRONTEND_REGISTER_0, RAW_FRONTEND_REGISTER_0 RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_RAW_FRONTEND_REGISTER_0_DP_ENABLE ,DP_ENABLE RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_RAW_FRONTEND_REGISTER_0_SHOW_DYNAMIC_DEFECT_PIXEL ,SHOW_DYNAMIC_DEFECT_PIXEL RESET:0x0"
          
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_RAW_FRONTEND_REGISTER_0_DARK_DISABLE ,DARK_DISABLE RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_RAW_FRONTEND_REGISTER_0_BRIGHT_DISABLE ,BRIGHT_DISABLE RESET:0x0"
          
          
group.long  0x40c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_RAW_FRONTEND_REGISTER_1, RAW_FRONTEND_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_RAW_FRONTEND_REGISTER_1_DP_SLOPE ,DP_SLOPE RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_RAW_FRONTEND_REGISTER_1_DP_THRESHOLD ,DP_THRESHOLD RESET:0x0"
          
          
group.long  0x410++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_RAW_FRONTEND_REGISTER_2, RAW_FRONTEND_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_RAW_FRONTEND_REGISTER_2_DPDEV_THRESHOLD ,DPDEV_THRESHOLD RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_RAW_FRONTEND_REGISTER_2_DP_BLEND ,DP_BLEND RESET:0x0"
          
          
group.long  0x41c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_RAW_FRONTEND_REGISTER_3, RAW_FRONTEND_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_RAW_FRONTEND_REGISTER_3_LINE_THRESH ,LINE_THRESH RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_RAW_FRONTEND_REGISTER_3_SIGMA_IN ,SIGMA_IN RESET:0x0"
          
          
group.long  0x4c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_0, SINTER_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_0_CONFIG1 ,CONFIG1 RESET:0x0"
          
          
group.long  0x4c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_1, SINTER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_1_CONFIG2 ,CONFIG2 RESET:0x0"
          
          
group.long  0x4c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_2, SINTER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_2_RM_CENTER_X ,RM_CENTER_X RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_2_RM_CENTER_Y ,RM_CENTER_Y RESET:0x0"
          
group.long  0x4cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_3, SINTER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_3_RM_OFF_CENTER_MULT ,RM_OFF_CENTER_MULT RESET:0x0"
          
          
group.long  0x4d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_4, SINTER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_4_THRESH_1H ,THRESH_1H RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_4_THRESH_4H ,THRESH_4H RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_4_THRESH_1V ,THRESH_1V RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_4_THRESH_4V ,THRESH_4V RESET:0x0"
          
group.long  0x4d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_5, SINTER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_5_STRENGTH_1 ,STRENGTH_1 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_REGISTER_5_STRENGTH_4 ,STRENGTH_4 RESET:0x0"
          
          
group.long  0x4d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_0, SINTER_NOISE_PROFILE_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_0_BLACK_REFLECT ,BLACK_REFLECT RESET:0x0"
          
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_0_GLOBAL_OFFSET ,GLOBAL_OFFSET RESET:0x0"
          
          
group.long  0x4dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_1, SINTER_NOISE_PROFILE_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_1_BLACK_LEVEL ,BLACK_LEVEL RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_1_THRESH1 ,THRESH1 RESET:0x0"
          
          
group.long  0x4e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_2, SINTER_NOISE_PROFILE_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_2_THRESH2 ,THRESH2 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_2_THRESH3 ,THRESH3 RESET:0x0"
          
          
group.long  0x4e4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_3, SINTER_NOISE_PROFILE_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_3_NOISE_LEVEL_R ,NOISE_LEVEL_R RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_3_NOISE_LEVEL_B ,NOISE_LEVEL_B RESET:0x0"
          
          
group.long  0x4e8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_4, SINTER_NOISE_PROFILE_REGISTER_4 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_4_ADD_LUT ,ADD_LUT RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_4_EXP_MASK_FROM_THRESH ,EXP_MASK_FROM_THRESH RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_4_ADD_EXP_OFFSET ,ADD_EXP_OFFSET RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_4_ADD_MOTION_OFFSET ,ADD_MOTION_OFFSET RESET:0x0"
          
          
group.long  0x4ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_5, SINTER_NOISE_PROFILE_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_5_EXP_OFFSET_0 ,EXP_OFFSET_0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_5_EXP_OFFSET_1 ,EXP_OFFSET_1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_5_EXP_OFFSET_2 ,EXP_OFFSET_2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_5_EXP_OFFSET_3 ,EXP_OFFSET_3 RESET:0x0"
          
group.long  0x4f0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_6, SINTER_NOISE_PROFILE_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_6_MOTION_OFFSET_0 ,MOTION_OFFSET_0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_6_MOTION_OFFSET_1 ,MOTION_OFFSET_1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_6_MOTION_OFFSET_2 ,MOTION_OFFSET_2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_REGISTER_6_MOTION_OFFSET_3 ,MOTION_OFFSET_3 RESET:0x0"
          
group.long  0x5b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_0, SINTER_NOISE_PROFILE_LUT_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT0 ,WEIGHT_LUT_REG0_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT1 ,WEIGHT_LUT_REG0_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT2 ,WEIGHT_LUT_REG0_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT3 ,WEIGHT_LUT_REG0_SEGMENT3 RESET:0x0"
          
group.long  0x5b4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_1, SINTER_NOISE_PROFILE_LUT_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT0 ,WEIGHT_LUT_REG1_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT1 ,WEIGHT_LUT_REG1_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT2 ,WEIGHT_LUT_REG1_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT3 ,WEIGHT_LUT_REG1_SEGMENT3 RESET:0x0"
          
group.long  0x5b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_2, SINTER_NOISE_PROFILE_LUT_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT0 ,WEIGHT_LUT_REG2_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT1 ,WEIGHT_LUT_REG2_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT2 ,WEIGHT_LUT_REG2_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT3 ,WEIGHT_LUT_REG2_SEGMENT3 RESET:0x0"
          
group.long  0x5bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_3, SINTER_NOISE_PROFILE_LUT_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT0 ,WEIGHT_LUT_REG3_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT1 ,WEIGHT_LUT_REG3_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT2 ,WEIGHT_LUT_REG3_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT3 ,WEIGHT_LUT_REG3_SEGMENT3 RESET:0x0"
          
group.long  0x5c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_4, SINTER_NOISE_PROFILE_LUT_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT0 ,WEIGHT_LUT_REG4_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT1 ,WEIGHT_LUT_REG4_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT2 ,WEIGHT_LUT_REG4_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT3 ,WEIGHT_LUT_REG4_SEGMENT3 RESET:0x0"
          
group.long  0x5c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_5, SINTER_NOISE_PROFILE_LUT_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT0 ,WEIGHT_LUT_REG5_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT1 ,WEIGHT_LUT_REG5_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT2 ,WEIGHT_LUT_REG5_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT3 ,WEIGHT_LUT_REG5_SEGMENT3 RESET:0x0"
          
group.long  0x5c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_6, SINTER_NOISE_PROFILE_LUT_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT0 ,WEIGHT_LUT_REG6_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT1 ,WEIGHT_LUT_REG6_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT2 ,WEIGHT_LUT_REG6_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT3 ,WEIGHT_LUT_REG6_SEGMENT3 RESET:0x0"
          
group.long  0x5cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_7, SINTER_NOISE_PROFILE_LUT_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT0 ,WEIGHT_LUT_REG7_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT1 ,WEIGHT_LUT_REG7_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT2 ,WEIGHT_LUT_REG7_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT3 ,WEIGHT_LUT_REG7_SEGMENT3 RESET:0x0"
          
group.long  0x5d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_8, SINTER_NOISE_PROFILE_LUT_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT0 ,WEIGHT_LUT_REG8_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT1 ,WEIGHT_LUT_REG8_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT2 ,WEIGHT_LUT_REG8_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT3 ,WEIGHT_LUT_REG8_SEGMENT3 RESET:0x0"
          
group.long  0x5d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_9, SINTER_NOISE_PROFILE_LUT_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT0 ,WEIGHT_LUT_REG9_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT1 ,WEIGHT_LUT_REG9_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT2 ,WEIGHT_LUT_REG9_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT3 ,WEIGHT_LUT_REG9_SEGMENT3 RESET:0x0"
          
group.long  0x5d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_10, SINTER_NOISE_PROFILE_LUT_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT0 ,WEIGHT_LUT_REG10_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT1 ,WEIGHT_LUT_REG10_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT2 ,WEIGHT_LUT_REG10_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT3 ,WEIGHT_LUT_REG10_SEGMENT3 RESET:0x0"
          
group.long  0x5dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_11, SINTER_NOISE_PROFILE_LUT_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT0 ,WEIGHT_LUT_REG11_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT1 ,WEIGHT_LUT_REG11_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT2 ,WEIGHT_LUT_REG11_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT3 ,WEIGHT_LUT_REG11_SEGMENT3 RESET:0x0"
          
group.long  0x5e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_12, SINTER_NOISE_PROFILE_LUT_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT0 ,WEIGHT_LUT_REG12_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT1 ,WEIGHT_LUT_REG12_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT2 ,WEIGHT_LUT_REG12_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT3 ,WEIGHT_LUT_REG12_SEGMENT3 RESET:0x0"
          
group.long  0x5e4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_13, SINTER_NOISE_PROFILE_LUT_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT0 ,WEIGHT_LUT_REG13_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT1 ,WEIGHT_LUT_REG13_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT2 ,WEIGHT_LUT_REG13_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT3 ,WEIGHT_LUT_REG13_SEGMENT3 RESET:0x0"
          
group.long  0x5e8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_14, SINTER_NOISE_PROFILE_LUT_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT0 ,WEIGHT_LUT_REG14_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT1 ,WEIGHT_LUT_REG14_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT2 ,WEIGHT_LUT_REG14_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT3 ,WEIGHT_LUT_REG14_SEGMENT3 RESET:0x0"
          
group.long  0x5ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_15, SINTER_NOISE_PROFILE_LUT_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT0 ,WEIGHT_LUT_REG15_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT1 ,WEIGHT_LUT_REG15_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT2 ,WEIGHT_LUT_REG15_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT3 ,WEIGHT_LUT_REG15_SEGMENT3 RESET:0x0"
          
group.long  0x5f0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_16, SINTER_NOISE_PROFILE_LUT_REGISTER_16 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT0 ,WEIGHT_LUT_REG16_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT1 ,WEIGHT_LUT_REG16_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT2 ,WEIGHT_LUT_REG16_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT3 ,WEIGHT_LUT_REG16_SEGMENT3 RESET:0x0"
          
group.long  0x5f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_17, SINTER_NOISE_PROFILE_LUT_REGISTER_17 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT0 ,WEIGHT_LUT_REG17_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT1 ,WEIGHT_LUT_REG17_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT2 ,WEIGHT_LUT_REG17_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT3 ,WEIGHT_LUT_REG17_SEGMENT3 RESET:0x0"
          
group.long  0x5f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_18, SINTER_NOISE_PROFILE_LUT_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT0 ,WEIGHT_LUT_REG18_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT1 ,WEIGHT_LUT_REG18_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT2 ,WEIGHT_LUT_REG18_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT3 ,WEIGHT_LUT_REG18_SEGMENT3 RESET:0x0"
          
group.long  0x5fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_19, SINTER_NOISE_PROFILE_LUT_REGISTER_19 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT0 ,WEIGHT_LUT_REG19_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT1 ,WEIGHT_LUT_REG19_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT2 ,WEIGHT_LUT_REG19_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT3 ,WEIGHT_LUT_REG19_SEGMENT3 RESET:0x0"
          
group.long  0x600++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_20, SINTER_NOISE_PROFILE_LUT_REGISTER_20 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT0 ,WEIGHT_LUT_REG20_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT1 ,WEIGHT_LUT_REG20_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT2 ,WEIGHT_LUT_REG20_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT3 ,WEIGHT_LUT_REG20_SEGMENT3 RESET:0x0"
          
group.long  0x604++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_21, SINTER_NOISE_PROFILE_LUT_REGISTER_21 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT0 ,WEIGHT_LUT_REG21_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT1 ,WEIGHT_LUT_REG21_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT2 ,WEIGHT_LUT_REG21_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT3 ,WEIGHT_LUT_REG21_SEGMENT3 RESET:0x0"
          
group.long  0x608++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_22, SINTER_NOISE_PROFILE_LUT_REGISTER_22 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT0 ,WEIGHT_LUT_REG22_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT1 ,WEIGHT_LUT_REG22_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT2 ,WEIGHT_LUT_REG22_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT3 ,WEIGHT_LUT_REG22_SEGMENT3 RESET:0x0"
          
group.long  0x60c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_23, SINTER_NOISE_PROFILE_LUT_REGISTER_23 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT0 ,WEIGHT_LUT_REG23_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT1 ,WEIGHT_LUT_REG23_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT2 ,WEIGHT_LUT_REG23_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT3 ,WEIGHT_LUT_REG23_SEGMENT3 RESET:0x0"
          
group.long  0x610++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_24, SINTER_NOISE_PROFILE_LUT_REGISTER_24 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT0 ,WEIGHT_LUT_REG24_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT1 ,WEIGHT_LUT_REG24_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT2 ,WEIGHT_LUT_REG24_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT3 ,WEIGHT_LUT_REG24_SEGMENT3 RESET:0x0"
          
group.long  0x614++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_25, SINTER_NOISE_PROFILE_LUT_REGISTER_25 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT0 ,WEIGHT_LUT_REG25_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT1 ,WEIGHT_LUT_REG25_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT2 ,WEIGHT_LUT_REG25_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT3 ,WEIGHT_LUT_REG25_SEGMENT3 RESET:0x0"
          
group.long  0x618++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_26, SINTER_NOISE_PROFILE_LUT_REGISTER_26 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT0 ,WEIGHT_LUT_REG26_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT1 ,WEIGHT_LUT_REG26_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT2 ,WEIGHT_LUT_REG26_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT3 ,WEIGHT_LUT_REG26_SEGMENT3 RESET:0x0"
          
group.long  0x61c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_27, SINTER_NOISE_PROFILE_LUT_REGISTER_27 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT0 ,WEIGHT_LUT_REG27_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT1 ,WEIGHT_LUT_REG27_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT2 ,WEIGHT_LUT_REG27_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT3 ,WEIGHT_LUT_REG27_SEGMENT3 RESET:0x0"
          
group.long  0x620++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_28, SINTER_NOISE_PROFILE_LUT_REGISTER_28 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT0 ,WEIGHT_LUT_REG28_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT1 ,WEIGHT_LUT_REG28_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT2 ,WEIGHT_LUT_REG28_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT3 ,WEIGHT_LUT_REG28_SEGMENT3 RESET:0x0"
          
group.long  0x624++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_29, SINTER_NOISE_PROFILE_LUT_REGISTER_29 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT0 ,WEIGHT_LUT_REG29_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT1 ,WEIGHT_LUT_REG29_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT2 ,WEIGHT_LUT_REG29_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT3 ,WEIGHT_LUT_REG29_SEGMENT3 RESET:0x0"
          
group.long  0x628++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_30, SINTER_NOISE_PROFILE_LUT_REGISTER_30 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT0 ,WEIGHT_LUT_REG30_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT1 ,WEIGHT_LUT_REG30_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT2 ,WEIGHT_LUT_REG30_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT3 ,WEIGHT_LUT_REG30_SEGMENT3 RESET:0x0"
          
group.long  0x62c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_31, SINTER_NOISE_PROFILE_LUT_REGISTER_31 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT0 ,WEIGHT_LUT_REG31_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT1 ,WEIGHT_LUT_REG31_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT2 ,WEIGHT_LUT_REG31_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT3 ,WEIGHT_LUT_REG31_SEGMENT3 RESET:0x0"
          
group.long  0x1b70++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_0, SINTER_SHADING_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_0_RM_SHADING_LUT_REG0_SEGMENT0 ,RM_SHADING_LUT_REG0_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_0_RM_SHADING_LUT_REG0_SEGMENT1 ,RM_SHADING_LUT_REG0_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_0_RM_SHADING_LUT_REG0_SEGMENT2 ,RM_SHADING_LUT_REG0_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_0_RM_SHADING_LUT_REG0_SEGMENT3 ,RM_SHADING_LUT_REG0_SEGMENT3 RESET:0x0"
          
group.long  0x1b74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_1, SINTER_SHADING_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_1_RM_SHADING_LUT_REG1_SEGMENT0 ,RM_SHADING_LUT_REG1_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_1_RM_SHADING_LUT_REG1_SEGMENT1 ,RM_SHADING_LUT_REG1_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_1_RM_SHADING_LUT_REG1_SEGMENT2 ,RM_SHADING_LUT_REG1_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_1_RM_SHADING_LUT_REG1_SEGMENT3 ,RM_SHADING_LUT_REG1_SEGMENT3 RESET:0x0"
          
group.long  0x1b78++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_2, SINTER_SHADING_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_2_RM_SHADING_LUT_REG2_SEGMENT0 ,RM_SHADING_LUT_REG2_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_2_RM_SHADING_LUT_REG2_SEGMENT1 ,RM_SHADING_LUT_REG2_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_2_RM_SHADING_LUT_REG2_SEGMENT2 ,RM_SHADING_LUT_REG2_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_2_RM_SHADING_LUT_REG2_SEGMENT3 ,RM_SHADING_LUT_REG2_SEGMENT3 RESET:0x0"
          
group.long  0x1b7c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_3, SINTER_SHADING_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_3_RM_SHADING_LUT_REG3_SEGMENT0 ,RM_SHADING_LUT_REG3_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_3_RM_SHADING_LUT_REG3_SEGMENT1 ,RM_SHADING_LUT_REG3_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_3_RM_SHADING_LUT_REG3_SEGMENT2 ,RM_SHADING_LUT_REG3_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_3_RM_SHADING_LUT_REG3_SEGMENT3 ,RM_SHADING_LUT_REG3_SEGMENT3 RESET:0x0"
          
group.long  0x1b80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_4, SINTER_SHADING_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_4_RM_SHADING_LUT_REG4_SEGMENT0 ,RM_SHADING_LUT_REG4_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_4_RM_SHADING_LUT_REG4_SEGMENT1 ,RM_SHADING_LUT_REG4_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_4_RM_SHADING_LUT_REG4_SEGMENT2 ,RM_SHADING_LUT_REG4_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_4_RM_SHADING_LUT_REG4_SEGMENT3 ,RM_SHADING_LUT_REG4_SEGMENT3 RESET:0x0"
          
group.long  0x1b84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_5, SINTER_SHADING_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_5_RM_SHADING_LUT_REG5_SEGMENT0 ,RM_SHADING_LUT_REG5_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_5_RM_SHADING_LUT_REG5_SEGMENT1 ,RM_SHADING_LUT_REG5_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_5_RM_SHADING_LUT_REG5_SEGMENT2 ,RM_SHADING_LUT_REG5_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_5_RM_SHADING_LUT_REG5_SEGMENT3 ,RM_SHADING_LUT_REG5_SEGMENT3 RESET:0x0"
          
group.long  0x1b88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_6, SINTER_SHADING_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_6_RM_SHADING_LUT_REG6_SEGMENT0 ,RM_SHADING_LUT_REG6_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_6_RM_SHADING_LUT_REG6_SEGMENT1 ,RM_SHADING_LUT_REG6_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_6_RM_SHADING_LUT_REG6_SEGMENT2 ,RM_SHADING_LUT_REG6_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_6_RM_SHADING_LUT_REG6_SEGMENT3 ,RM_SHADING_LUT_REG6_SEGMENT3 RESET:0x0"
          
group.long  0x1b8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_7, SINTER_SHADING_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_7_RM_SHADING_LUT_REG7_SEGMENT0 ,RM_SHADING_LUT_REG7_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_7_RM_SHADING_LUT_REG7_SEGMENT1 ,RM_SHADING_LUT_REG7_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_7_RM_SHADING_LUT_REG7_SEGMENT2 ,RM_SHADING_LUT_REG7_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SINTER_SHADING_REGISTER_7_RM_SHADING_LUT_REG7_SEGMENT3 ,RM_SHADING_LUT_REG7_SEGMENT3 RESET:0x0"
          
group.long  0x1b94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_REGISTER_0, TEMPER_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_REGISTER_0_SHOW_ALPHA ,SHOW_ALPHA RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_REGISTER_0_MIXER_SELECT ,MIXER_SELECT RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_REGISTER_0_COMPRESS_PIXEL_DATA ,COMPRESS_PIXEL_DATA RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_REGISTER_0_COMPRESS_META_DATA ,COMPRESS_META_DATA RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_REGISTER_0_SHOW_MOTION ,SHOW_MOTION RESET:0x0"
          
          
         hexmask.long 0x00 8.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_REGISTER_0_MODE ,MODE RESET:0x0"
          
          
group.long  0x1b98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_REGISTER_1, TEMPER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_REGISTER_1_RECURSION_LIMIT ,RECURSION_LIMIT RESET:0x0"
          
          
group.long  0x1b9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_REGISTER_2, TEMPER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_REGISTER_2_MOT_THRESH ,MOT_THRESH RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_REGISTER_2_MOT_SLOPE ,MOT_SLOPE RESET:0x0"
          
          
group.long  0x1ba0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_0, TEMPER_NOISE_PROFILE_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_0_USE_LUT ,USE_LUT RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_0_USE_EXP_MASK ,USE_EXP_MASK RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_0_BLACK_REFLECT ,BLACK_REFLECT RESET:0x0"
          
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_0_GLOBAL_OFFSET ,GLOBAL_OFFSET RESET:0x0"
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_0_BLACK_LEVEL ,BLACK_LEVEL RESET:0x0"
          
          
group.long  0x1ba4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_1, TEMPER_NOISE_PROFILE_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_1_THRESH1 ,THRESH1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_1_THRESH2 ,THRESH2 RESET:0x0"
          
          
group.long  0x1ba8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_2, TEMPER_NOISE_PROFILE_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_2_THRESH3 ,THRESH3 RESET:0x0"
          
          
group.long  0x1bac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_3, TEMPER_NOISE_PROFILE_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_3_NOISE_LEVEL_0 ,NOISE_LEVEL_0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_3_NOISE_LEVEL_1 ,NOISE_LEVEL_1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_3_NOISE_LEVEL_2 ,NOISE_LEVEL_2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_3_NOISE_LEVEL_3 ,NOISE_LEVEL_3 RESET:0x0"
          
group.long  0x1bb0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_4, TEMPER_NOISE_PROFILE_REGISTER_4 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_4_RGGB_MODE_ENABLE ,RGGB_MODE_ENABLE RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_4_SQRT_MODE_ENABLE ,SQRT_MODE_ENABLE RESET:0x0"
          
          
         hexmask.long 0x00 8.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_4_RECURSION_STRENGTH ,RECURSION_STRENGTH RESET:0x0"
          
          
         hexmask.long 0x00 16.--21. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_4_SMOOTHNESS ,SMOOTHNESS RESET:0x0"
          
          
group.long  0x1bb4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_5, TEMPER_NOISE_PROFILE_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_5_MOTION_THRESH_0 ,MOTION_THRESH_0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_5_MOTION_THRESH_1 ,MOTION_THRESH_1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--21. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_REGISTER_5_MOTION_THRESH_2 ,MOTION_THRESH_2 RESET:0x0"
          
          
group.long  0x1c70++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_0, TEMPER_NOISE_PROFILE_LUT_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT0 ,WEIGHT_LUT_REG0_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT1 ,WEIGHT_LUT_REG0_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT2 ,WEIGHT_LUT_REG0_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_0_WEIGHT_LUT_REG0_SEGMENT3 ,WEIGHT_LUT_REG0_SEGMENT3 RESET:0x0"
          
group.long  0x1c74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_1, TEMPER_NOISE_PROFILE_LUT_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT0 ,WEIGHT_LUT_REG1_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT1 ,WEIGHT_LUT_REG1_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT2 ,WEIGHT_LUT_REG1_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_1_WEIGHT_LUT_REG1_SEGMENT3 ,WEIGHT_LUT_REG1_SEGMENT3 RESET:0x0"
          
group.long  0x1c78++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_2, TEMPER_NOISE_PROFILE_LUT_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT0 ,WEIGHT_LUT_REG2_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT1 ,WEIGHT_LUT_REG2_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT2 ,WEIGHT_LUT_REG2_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_2_WEIGHT_LUT_REG2_SEGMENT3 ,WEIGHT_LUT_REG2_SEGMENT3 RESET:0x0"
          
group.long  0x1c7c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_3, TEMPER_NOISE_PROFILE_LUT_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT0 ,WEIGHT_LUT_REG3_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT1 ,WEIGHT_LUT_REG3_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT2 ,WEIGHT_LUT_REG3_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_3_WEIGHT_LUT_REG3_SEGMENT3 ,WEIGHT_LUT_REG3_SEGMENT3 RESET:0x0"
          
group.long  0x1c80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_4, TEMPER_NOISE_PROFILE_LUT_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT0 ,WEIGHT_LUT_REG4_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT1 ,WEIGHT_LUT_REG4_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT2 ,WEIGHT_LUT_REG4_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_4_WEIGHT_LUT_REG4_SEGMENT3 ,WEIGHT_LUT_REG4_SEGMENT3 RESET:0x0"
          
group.long  0x1c84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_5, TEMPER_NOISE_PROFILE_LUT_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT0 ,WEIGHT_LUT_REG5_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT1 ,WEIGHT_LUT_REG5_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT2 ,WEIGHT_LUT_REG5_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_5_WEIGHT_LUT_REG5_SEGMENT3 ,WEIGHT_LUT_REG5_SEGMENT3 RESET:0x0"
          
group.long  0x1c88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_6, TEMPER_NOISE_PROFILE_LUT_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT0 ,WEIGHT_LUT_REG6_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT1 ,WEIGHT_LUT_REG6_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT2 ,WEIGHT_LUT_REG6_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_6_WEIGHT_LUT_REG6_SEGMENT3 ,WEIGHT_LUT_REG6_SEGMENT3 RESET:0x0"
          
group.long  0x1c8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_7, TEMPER_NOISE_PROFILE_LUT_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT0 ,WEIGHT_LUT_REG7_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT1 ,WEIGHT_LUT_REG7_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT2 ,WEIGHT_LUT_REG7_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_7_WEIGHT_LUT_REG7_SEGMENT3 ,WEIGHT_LUT_REG7_SEGMENT3 RESET:0x0"
          
group.long  0x1c90++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_8, TEMPER_NOISE_PROFILE_LUT_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT0 ,WEIGHT_LUT_REG8_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT1 ,WEIGHT_LUT_REG8_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT2 ,WEIGHT_LUT_REG8_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_8_WEIGHT_LUT_REG8_SEGMENT3 ,WEIGHT_LUT_REG8_SEGMENT3 RESET:0x0"
          
group.long  0x1c94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_9, TEMPER_NOISE_PROFILE_LUT_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT0 ,WEIGHT_LUT_REG9_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT1 ,WEIGHT_LUT_REG9_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT2 ,WEIGHT_LUT_REG9_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_9_WEIGHT_LUT_REG9_SEGMENT3 ,WEIGHT_LUT_REG9_SEGMENT3 RESET:0x0"
          
group.long  0x1c98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_10, TEMPER_NOISE_PROFILE_LUT_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT0 ,WEIGHT_LUT_REG10_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT1 ,WEIGHT_LUT_REG10_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT2 ,WEIGHT_LUT_REG10_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_10_WEIGHT_LUT_REG10_SEGMENT3 ,WEIGHT_LUT_REG10_SEGMENT3 RESET:0x0"
          
group.long  0x1c9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_11, TEMPER_NOISE_PROFILE_LUT_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT0 ,WEIGHT_LUT_REG11_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT1 ,WEIGHT_LUT_REG11_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT2 ,WEIGHT_LUT_REG11_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_11_WEIGHT_LUT_REG11_SEGMENT3 ,WEIGHT_LUT_REG11_SEGMENT3 RESET:0x0"
          
group.long  0x1ca0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_12, TEMPER_NOISE_PROFILE_LUT_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT0 ,WEIGHT_LUT_REG12_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT1 ,WEIGHT_LUT_REG12_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT2 ,WEIGHT_LUT_REG12_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_12_WEIGHT_LUT_REG12_SEGMENT3 ,WEIGHT_LUT_REG12_SEGMENT3 RESET:0x0"
          
group.long  0x1ca4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_13, TEMPER_NOISE_PROFILE_LUT_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT0 ,WEIGHT_LUT_REG13_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT1 ,WEIGHT_LUT_REG13_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT2 ,WEIGHT_LUT_REG13_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_13_WEIGHT_LUT_REG13_SEGMENT3 ,WEIGHT_LUT_REG13_SEGMENT3 RESET:0x0"
          
group.long  0x1ca8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_14, TEMPER_NOISE_PROFILE_LUT_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT0 ,WEIGHT_LUT_REG14_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT1 ,WEIGHT_LUT_REG14_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT2 ,WEIGHT_LUT_REG14_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_14_WEIGHT_LUT_REG14_SEGMENT3 ,WEIGHT_LUT_REG14_SEGMENT3 RESET:0x0"
          
group.long  0x1cac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_15, TEMPER_NOISE_PROFILE_LUT_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT0 ,WEIGHT_LUT_REG15_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT1 ,WEIGHT_LUT_REG15_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT2 ,WEIGHT_LUT_REG15_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_15_WEIGHT_LUT_REG15_SEGMENT3 ,WEIGHT_LUT_REG15_SEGMENT3 RESET:0x0"
          
group.long  0x1cb0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_16, TEMPER_NOISE_PROFILE_LUT_REGISTER_16 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT0 ,WEIGHT_LUT_REG16_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT1 ,WEIGHT_LUT_REG16_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT2 ,WEIGHT_LUT_REG16_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_16_WEIGHT_LUT_REG16_SEGMENT3 ,WEIGHT_LUT_REG16_SEGMENT3 RESET:0x0"
          
group.long  0x1cb4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_17, TEMPER_NOISE_PROFILE_LUT_REGISTER_17 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT0 ,WEIGHT_LUT_REG17_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT1 ,WEIGHT_LUT_REG17_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT2 ,WEIGHT_LUT_REG17_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_17_WEIGHT_LUT_REG17_SEGMENT3 ,WEIGHT_LUT_REG17_SEGMENT3 RESET:0x0"
          
group.long  0x1cb8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_18, TEMPER_NOISE_PROFILE_LUT_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT0 ,WEIGHT_LUT_REG18_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT1 ,WEIGHT_LUT_REG18_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT2 ,WEIGHT_LUT_REG18_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_18_WEIGHT_LUT_REG18_SEGMENT3 ,WEIGHT_LUT_REG18_SEGMENT3 RESET:0x0"
          
group.long  0x1cbc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_19, TEMPER_NOISE_PROFILE_LUT_REGISTER_19 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT0 ,WEIGHT_LUT_REG19_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT1 ,WEIGHT_LUT_REG19_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT2 ,WEIGHT_LUT_REG19_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_19_WEIGHT_LUT_REG19_SEGMENT3 ,WEIGHT_LUT_REG19_SEGMENT3 RESET:0x0"
          
group.long  0x1cc0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_20, TEMPER_NOISE_PROFILE_LUT_REGISTER_20 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT0 ,WEIGHT_LUT_REG20_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT1 ,WEIGHT_LUT_REG20_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT2 ,WEIGHT_LUT_REG20_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_20_WEIGHT_LUT_REG20_SEGMENT3 ,WEIGHT_LUT_REG20_SEGMENT3 RESET:0x0"
          
group.long  0x1cc4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_21, TEMPER_NOISE_PROFILE_LUT_REGISTER_21 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT0 ,WEIGHT_LUT_REG21_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT1 ,WEIGHT_LUT_REG21_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT2 ,WEIGHT_LUT_REG21_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_21_WEIGHT_LUT_REG21_SEGMENT3 ,WEIGHT_LUT_REG21_SEGMENT3 RESET:0x0"
          
group.long  0x1cc8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_22, TEMPER_NOISE_PROFILE_LUT_REGISTER_22 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT0 ,WEIGHT_LUT_REG22_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT1 ,WEIGHT_LUT_REG22_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT2 ,WEIGHT_LUT_REG22_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_22_WEIGHT_LUT_REG22_SEGMENT3 ,WEIGHT_LUT_REG22_SEGMENT3 RESET:0x0"
          
group.long  0x1ccc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_23, TEMPER_NOISE_PROFILE_LUT_REGISTER_23 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT0 ,WEIGHT_LUT_REG23_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT1 ,WEIGHT_LUT_REG23_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT2 ,WEIGHT_LUT_REG23_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_23_WEIGHT_LUT_REG23_SEGMENT3 ,WEIGHT_LUT_REG23_SEGMENT3 RESET:0x0"
          
group.long  0x1cd0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_24, TEMPER_NOISE_PROFILE_LUT_REGISTER_24 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT0 ,WEIGHT_LUT_REG24_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT1 ,WEIGHT_LUT_REG24_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT2 ,WEIGHT_LUT_REG24_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_24_WEIGHT_LUT_REG24_SEGMENT3 ,WEIGHT_LUT_REG24_SEGMENT3 RESET:0x0"
          
group.long  0x1cd4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_25, TEMPER_NOISE_PROFILE_LUT_REGISTER_25 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT0 ,WEIGHT_LUT_REG25_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT1 ,WEIGHT_LUT_REG25_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT2 ,WEIGHT_LUT_REG25_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_25_WEIGHT_LUT_REG25_SEGMENT3 ,WEIGHT_LUT_REG25_SEGMENT3 RESET:0x0"
          
group.long  0x1cd8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_26, TEMPER_NOISE_PROFILE_LUT_REGISTER_26 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT0 ,WEIGHT_LUT_REG26_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT1 ,WEIGHT_LUT_REG26_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT2 ,WEIGHT_LUT_REG26_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_26_WEIGHT_LUT_REG26_SEGMENT3 ,WEIGHT_LUT_REG26_SEGMENT3 RESET:0x0"
          
group.long  0x1cdc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_27, TEMPER_NOISE_PROFILE_LUT_REGISTER_27 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT0 ,WEIGHT_LUT_REG27_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT1 ,WEIGHT_LUT_REG27_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT2 ,WEIGHT_LUT_REG27_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_27_WEIGHT_LUT_REG27_SEGMENT3 ,WEIGHT_LUT_REG27_SEGMENT3 RESET:0x0"
          
group.long  0x1ce0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_28, TEMPER_NOISE_PROFILE_LUT_REGISTER_28 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT0 ,WEIGHT_LUT_REG28_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT1 ,WEIGHT_LUT_REG28_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT2 ,WEIGHT_LUT_REG28_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_28_WEIGHT_LUT_REG28_SEGMENT3 ,WEIGHT_LUT_REG28_SEGMENT3 RESET:0x0"
          
group.long  0x1ce4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_29, TEMPER_NOISE_PROFILE_LUT_REGISTER_29 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT0 ,WEIGHT_LUT_REG29_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT1 ,WEIGHT_LUT_REG29_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT2 ,WEIGHT_LUT_REG29_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_29_WEIGHT_LUT_REG29_SEGMENT3 ,WEIGHT_LUT_REG29_SEGMENT3 RESET:0x0"
          
group.long  0x1ce8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_30, TEMPER_NOISE_PROFILE_LUT_REGISTER_30 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT0 ,WEIGHT_LUT_REG30_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT1 ,WEIGHT_LUT_REG30_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT2 ,WEIGHT_LUT_REG30_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_30_WEIGHT_LUT_REG30_SEGMENT3 ,WEIGHT_LUT_REG30_SEGMENT3 RESET:0x0"
          
group.long  0x1cec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_31, TEMPER_NOISE_PROFILE_LUT_REGISTER_31 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT0 ,WEIGHT_LUT_REG31_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT1 ,WEIGHT_LUT_REG31_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT2 ,WEIGHT_LUT_REG31_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_NOISE_PROFILE_LUT_REGISTER_31_WEIGHT_LUT_REG31_SEGMENT3 ,WEIGHT_LUT_REG31_SEGMENT3 RESET:0x0"
          
group.long  0x1cf0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_0, TEMPER_DMA_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_0_FRAME_WRITE_ON_DMA ,FRAME_WRITE_ON_DMA RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_0_FRAME_READ_ON_DMA ,FRAME_READ_ON_DMA RESET:0x0"
          
          
group.long  0x1cf4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_1, TEMPER_DMA_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_1_FORMAT ,FORMAT RESET:0x0"
          
          
rgroup.long 0x1cf8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_2, TEMPER_DMA_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_2_BLK_STATUS ,BLK_STATUS RESET:0x0"
          
group.long  0x1cfc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_3, TEMPER_DMA_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_3_BANK_BASE_WRITER ,BANK_BASE_WRITER RESET:0x0"
          
group.long  0x1d04++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_4, TEMPER_DMA_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_4_BANK_BASE_READER ,BANK_BASE_READER RESET:0x0"
          
group.long  0x1d0c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_5, TEMPER_DMA_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_5_LINE_OFFSET ,LINE_OFFSET RESET:0x0"
          
group.long  0x1d10++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_6, TEMPER_DMA_REGISTER_6 RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_6_LINETICK_EOL ,LINETICK_EOL RESET:0x0"
          
          
group.long  0x1d14++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_7, TEMPER_DMA_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_7_WRITER_LINES_WRAPPED ,WRITER_LINES_WRAPPED RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_7_READER_LINES_WRAPPED ,READER_LINES_WRAPPED RESET:0x0"
          
group.long  0x1d18++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_8, TEMPER_DMA_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_8_LINETICK_FIRST ,LINETICK_FIRST RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_8_LINETICK_REPEAT ,LINETICK_REPEAT RESET:0x0"
          
group.long  0x1d1c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_9, TEMPER_DMA_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_9_LINETICK_DELAY ,LINETICK_DELAY RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_9_FIFO_MAXFILL ,FIFO_MAXFILL RESET:0x0"
          
group.long  0x1d20++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_10, TEMPER_DMA_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_10_WRITER_AXI_ID_VALUE ,WRITER_AXI_ID_VALUE RESET:0x0"
          
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_10_WRITER_AXI_ID_MULTI ,WRITER_AXI_ID_MULTI RESET:0x0"
          
         hexmask.long 0x00 9.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_10_WRITER_AXI_BURSTSPLIT ,WRITER_AXI_BURSTSPLIT RESET:0x0"
          
         hexmask.long 0x00 11.--14. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_10_WRITER_AXI_CACHE_VALUE ,WRITER_AXI_CACHE_VALUE RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_10_WRITER_AXI_MAXOSTAND ,WRITER_AXI_MAXOSTAND RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_10_WRITER_AXI_MAX_AWLEN ,WRITER_AXI_MAX_AWLEN RESET:0x0"
          
         bitfld.long 0x00 28. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_10_WRITER_PAGEWARM_ON ,WRITER_PAGEWARM_ON RESET:0x0"
          
          
group.long  0x1d24++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_11, TEMPER_DMA_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_11_READER_AXI_ID_VALUE ,READER_AXI_ID_VALUE RESET:0x0"
          
          
         hexmask.long 0x00 9.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_11_READER_AXI_BURSTSPLIT ,READER_AXI_BURSTSPLIT RESET:0x0"
          
         hexmask.long 0x00 11.--14. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_11_READER_AXI_CACHE_VALUE ,READER_AXI_CACHE_VALUE RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_11_READER_AXI_MAXOSTAND ,READER_AXI_MAXOSTAND RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_11_READER_AXI_MAX_ARLEN ,READER_AXI_MAX_ARLEN RESET:0x0"
          
         bitfld.long 0x00 28. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TEMPER_DMA_REGISTER_11_READER_PAGEWARM_ON ,READER_PAGEWARM_ON RESET:0x0"
          
          
group.long  0x1d38++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SQUARE_BE_REGISTER_0, SQUARE_BE_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SQUARE_BE_REGISTER_0_BLACK_LEVEL_IN ,BLACK_LEVEL_IN RESET:0x0"
          
          
group.long  0x1d3c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SQUARE_BE_REGISTER_1, SQUARE_BE_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SQUARE_BE_REGISTER_1_BLACK_LEVEL_OUT ,BLACK_LEVEL_OUT RESET:0x0"
          
          
group.long  0x1d40++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SQUARE_BE_REGISTER_2, SQUARE_BE_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--16. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SQUARE_BE_REGISTER_2_NORMALIZATION ,NORMALIZATION RESET:0x0"
          
          
group.long  0x1d44++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_PRE_SHADING_REGISTER_0, SENSOR_OFFSET_PRE_SHADING_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_PRE_SHADING_REGISTER_0_OFFSET_00 ,OFFSET_00 RESET:0x0"
          
          
group.long  0x1d48++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_PRE_SHADING_REGISTER_1, SENSOR_OFFSET_PRE_SHADING_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_PRE_SHADING_REGISTER_1_OFFSET_01 ,OFFSET_01 RESET:0x0"
          
          
group.long  0x1d4c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_PRE_SHADING_REGISTER_2, SENSOR_OFFSET_PRE_SHADING_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_PRE_SHADING_REGISTER_2_OFFSET_10 ,OFFSET_10 RESET:0x0"
          
          
group.long  0x1d50++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_PRE_SHADING_REGISTER_3, SENSOR_OFFSET_PRE_SHADING_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_SENSOR_OFFSET_PRE_SHADING_REGISTER_3_OFFSET_11 ,OFFSET_11 RESET:0x0"
          
          
group.long  0x1d74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_0, MESH_SHADING_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_0_MESH_SHOW ,MESH_SHOW RESET:0x0"
          
         hexmask.long 0x00 2.--4. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_0_MESH_SCALE ,MESH_SCALE RESET:0x0"
          
          
         hexmask.long 0x00 8.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_0_MESH_PAGE_R ,MESH_PAGE_R RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_0_MESH_PAGE_G ,MESH_PAGE_G RESET:0x0"
          
         hexmask.long 0x00 12.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_0_MESH_PAGE_B ,MESH_PAGE_B RESET:0x0"
          
         hexmask.long 0x00 14.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_0_MESH_PAGE_IR ,MESH_PAGE_IR RESET:0x0"
          
         hexmask.long 0x00 16.--21. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_0_MESH_WIDTH ,MESH_WIDTH RESET:0x0"
          
          
         hexmask.long 0x00 24.--29. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_0_MESH_HEIGHT ,MESH_HEIGHT RESET:0x0"
          
          
group.long  0x1d78++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_1, MESH_SHADING_REGISTER_1 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_1_MESH_RELOAD ,MESH_RELOAD RESET:0x0"
          
          
group.long  0x1d7c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_2, MESH_SHADING_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_2_MESH_ALPHA_BANK_R ,MESH_ALPHA_BANK_R RESET:0x0"
          
         hexmask.long 0x00 3.--5. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_2_MESH_ALPHA_BANK_G ,MESH_ALPHA_BANK_G RESET:0x0"
          
         hexmask.long 0x00 6.--8. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_2_MESH_ALPHA_BANK_B ,MESH_ALPHA_BANK_B RESET:0x0"
          
         hexmask.long 0x00 9.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_2_MESH_ALPHA_BANK_IR ,MESH_ALPHA_BANK_IR RESET:0x0"
          
          
group.long  0x1d80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_3, MESH_SHADING_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_3_MESH_ALPHA_R ,MESH_ALPHA_R RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_3_MESH_ALPHA_G ,MESH_ALPHA_G RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_3_MESH_ALPHA_B ,MESH_ALPHA_B RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_3_MESH_ALPHA_IR ,MESH_ALPHA_IR RESET:0x0"
          
group.long  0x1d84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_4, MESH_SHADING_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MESH_SHADING_REGISTER_4_MESH_STRENGTH ,MESH_STRENGTH RESET:0x0"
          
          
group.long  0x1d88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_WHITE_BALANCE_REGISTER_0, WHITE_BALANCE_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_WHITE_BALANCE_REGISTER_0_GAIN_00 ,GAIN_00 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_WHITE_BALANCE_REGISTER_0_GAIN_01 ,GAIN_01 RESET:0x0"
          
          
group.long  0x1d8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_WHITE_BALANCE_REGISTER_1, WHITE_BALANCE_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_WHITE_BALANCE_REGISTER_1_GAIN_10 ,GAIN_10 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_WHITE_BALANCE_REGISTER_1_GAIN_11 ,GAIN_11 RESET:0x0"
          
          
group.long  0x1d90++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_WHITE_BALANCE_AEXP_REGISTER_0, WHITE_BALANCE_AEXP_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_WHITE_BALANCE_AEXP_REGISTER_0_GAIN_00 ,GAIN_00 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_WHITE_BALANCE_AEXP_REGISTER_0_GAIN_01 ,GAIN_01 RESET:0x0"
          
          
group.long  0x1d94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_WHITE_BALANCE_AEXP_REGISTER_1, WHITE_BALANCE_AEXP_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_WHITE_BALANCE_AEXP_REGISTER_1_GAIN_10 ,GAIN_10 RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_WHITE_BALANCE_AEXP_REGISTER_1_GAIN_11 ,GAIN_11 RESET:0x0"
          
          
group.long  0x1d98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_GAIN_REGISTER_0, IRIDIX_GAIN_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_GAIN_REGISTER_0_GAIN ,GAIN RESET:0x0"
          
          
group.long  0x1d9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_GAIN_REGISTER_1, IRIDIX_GAIN_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_GAIN_REGISTER_1_OFFSET ,OFFSET RESET:0x0"
          
          
group.long  0x1da0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_0, IRIDIX_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_0_IRIDIX_ON ,IRIDIX_ON RESET:0x0"
          
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_0_MAX_ALG_TYPE ,MAX_ALG_TYPE RESET:0x0"
          
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_0_BLACK_LEVEL_AMP0 ,BLACK_LEVEL_AMP0 RESET:0x0"
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_0_POSTGAMMA_POS ,POSTGAMMA_POS RESET:0x0"
          
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_0_COLLECT_OVL ,COLLECT_OVL RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_0_COLLECT_RND ,COLLECT_RND RESET:0x0"
          
          
         hexmask.long 0x00 14.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_0_STAT_MULT ,STAT_MULT RESET:0x0"
          
          
group.long  0x1da4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_1, IRIDIX_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_1_IVARIANCE1 ,IVARIANCE1 RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_1_IVARIANCE2 ,IVARIANCE2 RESET:0x0"
          
          
group.long  0x1da8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_2, IRIDIX_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_2_BLACK_LEVEL ,BLACK_LEVEL RESET:0x0"
          
          
group.long  0x1dac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_3, IRIDIX_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_3_WHITE_LEVEL ,WHITE_LEVEL RESET:0x0"
          
          
group.long  0x1db0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_4, IRIDIX_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_4_COLLECTION_CORRECTION ,COLLECTION_CORRECTION RESET:0x0"
          
          
group.long  0x1db4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_5, IRIDIX_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_5_FWD_PERCEPT_CONTROL ,FWD_PERCEPT_CONTROL RESET:0x0"
          
          
         hexmask.long 0x00 8.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_5_REV_PERCEPT_CONTROL ,REV_PERCEPT_CONTROL RESET:0x0"
          
          
         hexmask.long 0x00 16.--25. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_5_STRENGTH_INROI ,STRENGTH_INROI RESET:0x0"
          
          
group.long  0x1db8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_6, IRIDIX_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_6_STRENGTH_OUTROI ,STRENGTH_OUTROI RESET:0x0"
          
          
group.long  0x1dbc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_7, IRIDIX_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_7_ROI_HOR_START ,ROI_HOR_START RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_7_ROI_HOR_END ,ROI_HOR_END RESET:0x0"
          
group.long  0x1dc0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_8, IRIDIX_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_8_ROI_VER_START ,ROI_VER_START RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_8_ROI_VER_END ,ROI_VER_END RESET:0x0"
          
group.long  0x1dc4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_9, IRIDIX_REGISTER_9 RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_9_SVARIANCE ,SVARIANCE RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_9_BRIGHT_PR ,BRIGHT_PR RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_9_CONTRAST ,CONTRAST RESET:0x0"
          
group.long  0x1dc8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_10, IRIDIX_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_10_DARK_ENH ,DARK_ENH RESET:0x0"
          
          
group.long  0x1dd4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_11, IRIDIX_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_11_CONTEXT_NO ,CONTEXT_NO RESET:0x0"
          
          
group.long  0x1dd8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_12, IRIDIX_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_12_WB_OFFSET ,WB_OFFSET RESET:0x0"
          
          
group.long  0x1ddc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_13, IRIDIX_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_13_GAIN_R ,GAIN_R RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_13_GAIN_GR ,GAIN_GR RESET:0x0"
          
          
group.long  0x1de0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_14, IRIDIX_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_14_GAIN_GB ,GAIN_GB RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_14_GAIN_B ,GAIN_B RESET:0x0"
          
          
group.long  0x1de4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_15, IRIDIX_REGISTER_15 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_REGISTER_15_GTM_SELECT ,GTM_SELECT RESET:0x0"
          
          
group.long  0x1de8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_0, IRIDIX_LUT_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_0_ASYMMETRY_LUT_REG0_SEGMENT0 ,ASYMMETRY_LUT_REG0_SEGMENT0 RESET:0x0"
          
          
group.long  0x1dec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_1, IRIDIX_LUT_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_1_ASYMMETRY_LUT_REG1_SEGMENT0 ,ASYMMETRY_LUT_REG1_SEGMENT0 RESET:0x0"
          
          
group.long  0x1df0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_2, IRIDIX_LUT_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_2_ASYMMETRY_LUT_REG2_SEGMENT0 ,ASYMMETRY_LUT_REG2_SEGMENT0 RESET:0x0"
          
          
group.long  0x1df4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_3, IRIDIX_LUT_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_3_ASYMMETRY_LUT_REG3_SEGMENT0 ,ASYMMETRY_LUT_REG3_SEGMENT0 RESET:0x0"
          
          
group.long  0x1df8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_4, IRIDIX_LUT_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_4_ASYMMETRY_LUT_REG4_SEGMENT0 ,ASYMMETRY_LUT_REG4_SEGMENT0 RESET:0x0"
          
          
group.long  0x1dfc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_5, IRIDIX_LUT_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_5_ASYMMETRY_LUT_REG5_SEGMENT0 ,ASYMMETRY_LUT_REG5_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e00++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_6, IRIDIX_LUT_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_6_ASYMMETRY_LUT_REG6_SEGMENT0 ,ASYMMETRY_LUT_REG6_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e04++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_7, IRIDIX_LUT_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_7_ASYMMETRY_LUT_REG7_SEGMENT0 ,ASYMMETRY_LUT_REG7_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e08++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_8, IRIDIX_LUT_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_8_ASYMMETRY_LUT_REG8_SEGMENT0 ,ASYMMETRY_LUT_REG8_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e0c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_9, IRIDIX_LUT_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_9_ASYMMETRY_LUT_REG9_SEGMENT0 ,ASYMMETRY_LUT_REG9_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e10++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_10, IRIDIX_LUT_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_10_ASYMMETRY_LUT_REG10_SEGMENT0 ,ASYMMETRY_LUT_REG10_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e14++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_11, IRIDIX_LUT_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_11_ASYMMETRY_LUT_REG11_SEGMENT0 ,ASYMMETRY_LUT_REG11_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e18++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_12, IRIDIX_LUT_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_12_ASYMMETRY_LUT_REG12_SEGMENT0 ,ASYMMETRY_LUT_REG12_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e1c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_13, IRIDIX_LUT_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_13_ASYMMETRY_LUT_REG13_SEGMENT0 ,ASYMMETRY_LUT_REG13_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e20++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_14, IRIDIX_LUT_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_14_ASYMMETRY_LUT_REG14_SEGMENT0 ,ASYMMETRY_LUT_REG14_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e24++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_15, IRIDIX_LUT_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_15_ASYMMETRY_LUT_REG15_SEGMENT0 ,ASYMMETRY_LUT_REG15_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e28++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_16, IRIDIX_LUT_REGISTER_16 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_16_ASYMMETRY_LUT_REG16_SEGMENT0 ,ASYMMETRY_LUT_REG16_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e2c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_17, IRIDIX_LUT_REGISTER_17 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_17_ASYMMETRY_LUT_REG17_SEGMENT0 ,ASYMMETRY_LUT_REG17_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e30++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_18, IRIDIX_LUT_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_18_ASYMMETRY_LUT_REG18_SEGMENT0 ,ASYMMETRY_LUT_REG18_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e34++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_19, IRIDIX_LUT_REGISTER_19 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_19_ASYMMETRY_LUT_REG19_SEGMENT0 ,ASYMMETRY_LUT_REG19_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e38++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_20, IRIDIX_LUT_REGISTER_20 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_20_ASYMMETRY_LUT_REG20_SEGMENT0 ,ASYMMETRY_LUT_REG20_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e3c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_21, IRIDIX_LUT_REGISTER_21 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_21_ASYMMETRY_LUT_REG21_SEGMENT0 ,ASYMMETRY_LUT_REG21_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e40++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_22, IRIDIX_LUT_REGISTER_22 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_22_ASYMMETRY_LUT_REG22_SEGMENT0 ,ASYMMETRY_LUT_REG22_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e44++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_23, IRIDIX_LUT_REGISTER_23 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_23_ASYMMETRY_LUT_REG23_SEGMENT0 ,ASYMMETRY_LUT_REG23_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e48++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_24, IRIDIX_LUT_REGISTER_24 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_24_ASYMMETRY_LUT_REG24_SEGMENT0 ,ASYMMETRY_LUT_REG24_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e4c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_25, IRIDIX_LUT_REGISTER_25 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_25_ASYMMETRY_LUT_REG25_SEGMENT0 ,ASYMMETRY_LUT_REG25_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e50++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_26, IRIDIX_LUT_REGISTER_26 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_26_ASYMMETRY_LUT_REG26_SEGMENT0 ,ASYMMETRY_LUT_REG26_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e54++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_27, IRIDIX_LUT_REGISTER_27 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_27_ASYMMETRY_LUT_REG27_SEGMENT0 ,ASYMMETRY_LUT_REG27_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e58++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_28, IRIDIX_LUT_REGISTER_28 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_28_ASYMMETRY_LUT_REG28_SEGMENT0 ,ASYMMETRY_LUT_REG28_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e5c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_29, IRIDIX_LUT_REGISTER_29 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_29_ASYMMETRY_LUT_REG29_SEGMENT0 ,ASYMMETRY_LUT_REG29_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e60++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_30, IRIDIX_LUT_REGISTER_30 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_30_ASYMMETRY_LUT_REG30_SEGMENT0 ,ASYMMETRY_LUT_REG30_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e64++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_31, IRIDIX_LUT_REGISTER_31 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_31_ASYMMETRY_LUT_REG31_SEGMENT0 ,ASYMMETRY_LUT_REG31_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e68++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_32, IRIDIX_LUT_REGISTER_32 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_32_ASYMMETRY_LUT_REG32_SEGMENT0 ,ASYMMETRY_LUT_REG32_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e6c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_33, IRIDIX_LUT_REGISTER_33 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_33_ASYMMETRY_LUT_REG33_SEGMENT0 ,ASYMMETRY_LUT_REG33_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e70++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_34, IRIDIX_LUT_REGISTER_34 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_34_ASYMMETRY_LUT_REG34_SEGMENT0 ,ASYMMETRY_LUT_REG34_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_35, IRIDIX_LUT_REGISTER_35 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_35_ASYMMETRY_LUT_REG35_SEGMENT0 ,ASYMMETRY_LUT_REG35_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e78++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_36, IRIDIX_LUT_REGISTER_36 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_36_ASYMMETRY_LUT_REG36_SEGMENT0 ,ASYMMETRY_LUT_REG36_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e7c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_37, IRIDIX_LUT_REGISTER_37 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_37_ASYMMETRY_LUT_REG37_SEGMENT0 ,ASYMMETRY_LUT_REG37_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_38, IRIDIX_LUT_REGISTER_38 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_38_ASYMMETRY_LUT_REG38_SEGMENT0 ,ASYMMETRY_LUT_REG38_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_39, IRIDIX_LUT_REGISTER_39 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_39_ASYMMETRY_LUT_REG39_SEGMENT0 ,ASYMMETRY_LUT_REG39_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_40, IRIDIX_LUT_REGISTER_40 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_40_ASYMMETRY_LUT_REG40_SEGMENT0 ,ASYMMETRY_LUT_REG40_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_41, IRIDIX_LUT_REGISTER_41 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_41_ASYMMETRY_LUT_REG41_SEGMENT0 ,ASYMMETRY_LUT_REG41_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e90++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_42, IRIDIX_LUT_REGISTER_42 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_42_ASYMMETRY_LUT_REG42_SEGMENT0 ,ASYMMETRY_LUT_REG42_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_43, IRIDIX_LUT_REGISTER_43 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_43_ASYMMETRY_LUT_REG43_SEGMENT0 ,ASYMMETRY_LUT_REG43_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_44, IRIDIX_LUT_REGISTER_44 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_44_ASYMMETRY_LUT_REG44_SEGMENT0 ,ASYMMETRY_LUT_REG44_SEGMENT0 RESET:0x0"
          
          
group.long  0x1e9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_45, IRIDIX_LUT_REGISTER_45 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_45_ASYMMETRY_LUT_REG45_SEGMENT0 ,ASYMMETRY_LUT_REG45_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ea0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_46, IRIDIX_LUT_REGISTER_46 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_46_ASYMMETRY_LUT_REG46_SEGMENT0 ,ASYMMETRY_LUT_REG46_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ea4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_47, IRIDIX_LUT_REGISTER_47 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_47_ASYMMETRY_LUT_REG47_SEGMENT0 ,ASYMMETRY_LUT_REG47_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ea8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_48, IRIDIX_LUT_REGISTER_48 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_48_ASYMMETRY_LUT_REG48_SEGMENT0 ,ASYMMETRY_LUT_REG48_SEGMENT0 RESET:0x0"
          
          
group.long  0x1eac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_49, IRIDIX_LUT_REGISTER_49 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_49_ASYMMETRY_LUT_REG49_SEGMENT0 ,ASYMMETRY_LUT_REG49_SEGMENT0 RESET:0x0"
          
          
group.long  0x1eb0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_50, IRIDIX_LUT_REGISTER_50 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_50_ASYMMETRY_LUT_REG50_SEGMENT0 ,ASYMMETRY_LUT_REG50_SEGMENT0 RESET:0x0"
          
          
group.long  0x1eb4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_51, IRIDIX_LUT_REGISTER_51 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_51_ASYMMETRY_LUT_REG51_SEGMENT0 ,ASYMMETRY_LUT_REG51_SEGMENT0 RESET:0x0"
          
          
group.long  0x1eb8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_52, IRIDIX_LUT_REGISTER_52 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_52_ASYMMETRY_LUT_REG52_SEGMENT0 ,ASYMMETRY_LUT_REG52_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ebc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_53, IRIDIX_LUT_REGISTER_53 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_53_ASYMMETRY_LUT_REG53_SEGMENT0 ,ASYMMETRY_LUT_REG53_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ec0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_54, IRIDIX_LUT_REGISTER_54 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_54_ASYMMETRY_LUT_REG54_SEGMENT0 ,ASYMMETRY_LUT_REG54_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ec4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_55, IRIDIX_LUT_REGISTER_55 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_55_ASYMMETRY_LUT_REG55_SEGMENT0 ,ASYMMETRY_LUT_REG55_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ec8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_56, IRIDIX_LUT_REGISTER_56 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_56_ASYMMETRY_LUT_REG56_SEGMENT0 ,ASYMMETRY_LUT_REG56_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ecc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_57, IRIDIX_LUT_REGISTER_57 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_57_ASYMMETRY_LUT_REG57_SEGMENT0 ,ASYMMETRY_LUT_REG57_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ed0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_58, IRIDIX_LUT_REGISTER_58 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_58_ASYMMETRY_LUT_REG58_SEGMENT0 ,ASYMMETRY_LUT_REG58_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ed4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_59, IRIDIX_LUT_REGISTER_59 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_59_ASYMMETRY_LUT_REG59_SEGMENT0 ,ASYMMETRY_LUT_REG59_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ed8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_60, IRIDIX_LUT_REGISTER_60 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_60_ASYMMETRY_LUT_REG60_SEGMENT0 ,ASYMMETRY_LUT_REG60_SEGMENT0 RESET:0x0"
          
          
group.long  0x1edc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_61, IRIDIX_LUT_REGISTER_61 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_61_ASYMMETRY_LUT_REG61_SEGMENT0 ,ASYMMETRY_LUT_REG61_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ee0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_62, IRIDIX_LUT_REGISTER_62 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_62_ASYMMETRY_LUT_REG62_SEGMENT0 ,ASYMMETRY_LUT_REG62_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ee4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_63, IRIDIX_LUT_REGISTER_63 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_63_ASYMMETRY_LUT_REG63_SEGMENT0 ,ASYMMETRY_LUT_REG63_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ee8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_64, IRIDIX_LUT_REGISTER_64 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_64_ASYMMETRY_LUT_REG64_SEGMENT0 ,ASYMMETRY_LUT_REG64_SEGMENT0 RESET:0x0"
          
          
group.long  0x1eec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_65, IRIDIX_LUT_REGISTER_65 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_65_GLOBALTM_X_LUT_REG0_SEGMENT0 ,GLOBALTM_X_LUT_REG0_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ef0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_66, IRIDIX_LUT_REGISTER_66 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_66_GLOBALTM_X_LUT_REG1_SEGMENT0 ,GLOBALTM_X_LUT_REG1_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ef4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_67, IRIDIX_LUT_REGISTER_67 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_67_GLOBALTM_X_LUT_REG2_SEGMENT0 ,GLOBALTM_X_LUT_REG2_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ef8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_68, IRIDIX_LUT_REGISTER_68 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_68_GLOBALTM_X_LUT_REG3_SEGMENT0 ,GLOBALTM_X_LUT_REG3_SEGMENT0 RESET:0x0"
          
          
group.long  0x1efc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_69, IRIDIX_LUT_REGISTER_69 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_69_GLOBALTM_X_LUT_REG4_SEGMENT0 ,GLOBALTM_X_LUT_REG4_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f00++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_70, IRIDIX_LUT_REGISTER_70 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_70_GLOBALTM_X_LUT_REG5_SEGMENT0 ,GLOBALTM_X_LUT_REG5_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f04++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_71, IRIDIX_LUT_REGISTER_71 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_71_GLOBALTM_X_LUT_REG6_SEGMENT0 ,GLOBALTM_X_LUT_REG6_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f08++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_72, IRIDIX_LUT_REGISTER_72 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_72_GLOBALTM_X_LUT_REG7_SEGMENT0 ,GLOBALTM_X_LUT_REG7_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f0c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_73, IRIDIX_LUT_REGISTER_73 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_73_GLOBALTM_X_LUT_REG8_SEGMENT0 ,GLOBALTM_X_LUT_REG8_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f10++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_74, IRIDIX_LUT_REGISTER_74 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_74_GLOBALTM_X_LUT_REG9_SEGMENT0 ,GLOBALTM_X_LUT_REG9_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f14++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_75, IRIDIX_LUT_REGISTER_75 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_75_GLOBALTM_X_LUT_REG10_SEGMENT0 ,GLOBALTM_X_LUT_REG10_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f18++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_76, IRIDIX_LUT_REGISTER_76 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_76_GLOBALTM_X_LUT_REG11_SEGMENT0 ,GLOBALTM_X_LUT_REG11_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f1c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_77, IRIDIX_LUT_REGISTER_77 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_77_GLOBALTM_X_LUT_REG12_SEGMENT0 ,GLOBALTM_X_LUT_REG12_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f20++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_78, IRIDIX_LUT_REGISTER_78 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_78_GLOBALTM_X_LUT_REG13_SEGMENT0 ,GLOBALTM_X_LUT_REG13_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f24++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_79, IRIDIX_LUT_REGISTER_79 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_79_GLOBALTM_X_LUT_REG14_SEGMENT0 ,GLOBALTM_X_LUT_REG14_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f28++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_80, IRIDIX_LUT_REGISTER_80 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_80_GLOBALTM_X_LUT_REG15_SEGMENT0 ,GLOBALTM_X_LUT_REG15_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f2c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_81, IRIDIX_LUT_REGISTER_81 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_81_GLOBALTM_X_LUT_REG16_SEGMENT0 ,GLOBALTM_X_LUT_REG16_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f30++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_82, IRIDIX_LUT_REGISTER_82 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_82_GLOBALTM_X_LUT_REG17_SEGMENT0 ,GLOBALTM_X_LUT_REG17_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f34++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_83, IRIDIX_LUT_REGISTER_83 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_83_GLOBALTM_X_LUT_REG18_SEGMENT0 ,GLOBALTM_X_LUT_REG18_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f38++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_84, IRIDIX_LUT_REGISTER_84 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_84_GLOBALTM_X_LUT_REG19_SEGMENT0 ,GLOBALTM_X_LUT_REG19_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f3c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_85, IRIDIX_LUT_REGISTER_85 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_85_GLOBALTM_X_LUT_REG20_SEGMENT0 ,GLOBALTM_X_LUT_REG20_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f40++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_86, IRIDIX_LUT_REGISTER_86 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_86_GLOBALTM_X_LUT_REG21_SEGMENT0 ,GLOBALTM_X_LUT_REG21_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f44++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_87, IRIDIX_LUT_REGISTER_87 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_87_GLOBALTM_X_LUT_REG22_SEGMENT0 ,GLOBALTM_X_LUT_REG22_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f48++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_88, IRIDIX_LUT_REGISTER_88 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_88_GLOBALTM_X_LUT_REG23_SEGMENT0 ,GLOBALTM_X_LUT_REG23_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f4c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_89, IRIDIX_LUT_REGISTER_89 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_89_GLOBALTM_X_LUT_REG24_SEGMENT0 ,GLOBALTM_X_LUT_REG24_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f50++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_90, IRIDIX_LUT_REGISTER_90 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_90_GLOBALTM_X_LUT_REG25_SEGMENT0 ,GLOBALTM_X_LUT_REG25_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f54++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_91, IRIDIX_LUT_REGISTER_91 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_91_GLOBALTM_X_LUT_REG26_SEGMENT0 ,GLOBALTM_X_LUT_REG26_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f58++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_92, IRIDIX_LUT_REGISTER_92 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_92_GLOBALTM_X_LUT_REG27_SEGMENT0 ,GLOBALTM_X_LUT_REG27_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f5c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_93, IRIDIX_LUT_REGISTER_93 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_93_GLOBALTM_X_LUT_REG28_SEGMENT0 ,GLOBALTM_X_LUT_REG28_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f60++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_94, IRIDIX_LUT_REGISTER_94 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_94_GLOBALTM_X_LUT_REG29_SEGMENT0 ,GLOBALTM_X_LUT_REG29_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f64++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_95, IRIDIX_LUT_REGISTER_95 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_95_GLOBALTM_X_LUT_REG30_SEGMENT0 ,GLOBALTM_X_LUT_REG30_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f68++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_96, IRIDIX_LUT_REGISTER_96 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_96_GLOBALTM_X_LUT_REG31_SEGMENT0 ,GLOBALTM_X_LUT_REG31_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f6c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_97, IRIDIX_LUT_REGISTER_97 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_97_GLOBALTM_X_LUT_REG32_SEGMENT0 ,GLOBALTM_X_LUT_REG32_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f70++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_98, IRIDIX_LUT_REGISTER_98 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_98_GLOBALTM_Y_LUT_REG0_SEGMENT0 ,GLOBALTM_Y_LUT_REG0_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_99, IRIDIX_LUT_REGISTER_99 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_99_GLOBALTM_Y_LUT_REG1_SEGMENT0 ,GLOBALTM_Y_LUT_REG1_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f78++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_100, IRIDIX_LUT_REGISTER_100 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_100_GLOBALTM_Y_LUT_REG2_SEGMENT0 ,GLOBALTM_Y_LUT_REG2_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f7c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_101, IRIDIX_LUT_REGISTER_101 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_101_GLOBALTM_Y_LUT_REG3_SEGMENT0 ,GLOBALTM_Y_LUT_REG3_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_102, IRIDIX_LUT_REGISTER_102 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_102_GLOBALTM_Y_LUT_REG4_SEGMENT0 ,GLOBALTM_Y_LUT_REG4_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_103, IRIDIX_LUT_REGISTER_103 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_103_GLOBALTM_Y_LUT_REG5_SEGMENT0 ,GLOBALTM_Y_LUT_REG5_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_104, IRIDIX_LUT_REGISTER_104 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_104_GLOBALTM_Y_LUT_REG6_SEGMENT0 ,GLOBALTM_Y_LUT_REG6_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_105, IRIDIX_LUT_REGISTER_105 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_105_GLOBALTM_Y_LUT_REG7_SEGMENT0 ,GLOBALTM_Y_LUT_REG7_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f90++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_106, IRIDIX_LUT_REGISTER_106 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_106_GLOBALTM_Y_LUT_REG8_SEGMENT0 ,GLOBALTM_Y_LUT_REG8_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_107, IRIDIX_LUT_REGISTER_107 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_107_GLOBALTM_Y_LUT_REG9_SEGMENT0 ,GLOBALTM_Y_LUT_REG9_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_108, IRIDIX_LUT_REGISTER_108 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_108_GLOBALTM_Y_LUT_REG10_SEGMENT0 ,GLOBALTM_Y_LUT_REG10_SEGMENT0 RESET:0x0"
          
          
group.long  0x1f9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_109, IRIDIX_LUT_REGISTER_109 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_109_GLOBALTM_Y_LUT_REG11_SEGMENT0 ,GLOBALTM_Y_LUT_REG11_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fa0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_110, IRIDIX_LUT_REGISTER_110 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_110_GLOBALTM_Y_LUT_REG12_SEGMENT0 ,GLOBALTM_Y_LUT_REG12_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fa4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_111, IRIDIX_LUT_REGISTER_111 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_111_GLOBALTM_Y_LUT_REG13_SEGMENT0 ,GLOBALTM_Y_LUT_REG13_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fa8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_112, IRIDIX_LUT_REGISTER_112 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_112_GLOBALTM_Y_LUT_REG14_SEGMENT0 ,GLOBALTM_Y_LUT_REG14_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_113, IRIDIX_LUT_REGISTER_113 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_113_GLOBALTM_Y_LUT_REG15_SEGMENT0 ,GLOBALTM_Y_LUT_REG15_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fb0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_114, IRIDIX_LUT_REGISTER_114 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_114_GLOBALTM_Y_LUT_REG16_SEGMENT0 ,GLOBALTM_Y_LUT_REG16_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fb4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_115, IRIDIX_LUT_REGISTER_115 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_115_GLOBALTM_Y_LUT_REG17_SEGMENT0 ,GLOBALTM_Y_LUT_REG17_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fb8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_116, IRIDIX_LUT_REGISTER_116 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_116_GLOBALTM_Y_LUT_REG18_SEGMENT0 ,GLOBALTM_Y_LUT_REG18_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fbc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_117, IRIDIX_LUT_REGISTER_117 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_117_GLOBALTM_Y_LUT_REG19_SEGMENT0 ,GLOBALTM_Y_LUT_REG19_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fc0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_118, IRIDIX_LUT_REGISTER_118 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_118_GLOBALTM_Y_LUT_REG20_SEGMENT0 ,GLOBALTM_Y_LUT_REG20_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fc4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_119, IRIDIX_LUT_REGISTER_119 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_119_GLOBALTM_Y_LUT_REG21_SEGMENT0 ,GLOBALTM_Y_LUT_REG21_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fc8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_120, IRIDIX_LUT_REGISTER_120 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_120_GLOBALTM_Y_LUT_REG22_SEGMENT0 ,GLOBALTM_Y_LUT_REG22_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fcc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_121, IRIDIX_LUT_REGISTER_121 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_121_GLOBALTM_Y_LUT_REG23_SEGMENT0 ,GLOBALTM_Y_LUT_REG23_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fd0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_122, IRIDIX_LUT_REGISTER_122 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_122_GLOBALTM_Y_LUT_REG24_SEGMENT0 ,GLOBALTM_Y_LUT_REG24_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fd4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_123, IRIDIX_LUT_REGISTER_123 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_123_GLOBALTM_Y_LUT_REG25_SEGMENT0 ,GLOBALTM_Y_LUT_REG25_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fd8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_124, IRIDIX_LUT_REGISTER_124 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_124_GLOBALTM_Y_LUT_REG26_SEGMENT0 ,GLOBALTM_Y_LUT_REG26_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fdc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_125, IRIDIX_LUT_REGISTER_125 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_125_GLOBALTM_Y_LUT_REG27_SEGMENT0 ,GLOBALTM_Y_LUT_REG27_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fe0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_126, IRIDIX_LUT_REGISTER_126 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_126_GLOBALTM_Y_LUT_REG28_SEGMENT0 ,GLOBALTM_Y_LUT_REG28_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fe4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_127, IRIDIX_LUT_REGISTER_127 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_127_GLOBALTM_Y_LUT_REG29_SEGMENT0 ,GLOBALTM_Y_LUT_REG29_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fe8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_128, IRIDIX_LUT_REGISTER_128 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_128_GLOBALTM_Y_LUT_REG30_SEGMENT0 ,GLOBALTM_Y_LUT_REG30_SEGMENT0 RESET:0x0"
          
          
group.long  0x1fec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_129, IRIDIX_LUT_REGISTER_129 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_129_GLOBALTM_Y_LUT_REG31_SEGMENT0 ,GLOBALTM_Y_LUT_REG31_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ff0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_130, IRIDIX_LUT_REGISTER_130 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_IRIDIX_LUT_REGISTER_130_GLOBALTM_Y_LUT_REG32_SEGMENT0 ,GLOBALTM_Y_LUT_REG32_SEGMENT0 RESET:0x0"
          
          
group.long  0x1ff4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_0, DEMOSAIC_RGB_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_0_UU_SLOPE ,UU_SLOPE RESET:0x0"
          
          
group.long  0x2000++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_1, DEMOSAIC_RGB_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_1_UU_THRESH ,UU_THRESH RESET:0x0"
          
          
group.long  0x2018++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_2, DEMOSAIC_RGB_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_2_DMSC_CONFIG ,DMSC_CONFIG RESET:0x0"
          
          
group.long  0x2020++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_3, DEMOSAIC_RGB_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_3_FC_SLOPE ,FC_SLOPE RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_3_FC_ALIAS_SLOPE ,FC_ALIAS_SLOPE RESET:0x0"
          
          
group.long  0x2028++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_4, DEMOSAIC_RGB_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_4_SHARP_ALT_LD ,SHARP_ALT_LD RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_4_SHARP_ALT_LDU ,SHARP_ALT_LDU RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_4_SHARP_ALT_LU ,SHARP_ALT_LU RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_4_SAD_AMP ,SAD_AMP RESET:0x0"
          
group.long  0x202c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_5, DEMOSAIC_RGB_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_5_MIN_D_STRENGTH ,MIN_D_STRENGTH RESET:0x0"
          
          
group.long  0x2030++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_6, DEMOSAIC_RGB_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_6_MIN_UD_STRENGTH ,MIN_UD_STRENGTH RESET:0x0"
          
          
group.long  0x2038++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_7, DEMOSAIC_RGB_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_7_UU_SH_SLOPE ,UU_SH_SLOPE RESET:0x0"
          
          
group.long  0x203c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_8, DEMOSAIC_RGB_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_8_UU_SH_THRESH ,UU_SH_THRESH RESET:0x0"
          
          
group.long  0x2044++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_9, DEMOSAIC_RGB_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_9_MAX_D_STRENGTH ,MAX_D_STRENGTH RESET:0x0"
          
          
         hexmask.long 0x00 16.--28. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_9_MAX_UD_STRENGTH ,MAX_UD_STRENGTH RESET:0x0"
          
          
group.long  0x2048++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_10, DEMOSAIC_RGB_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_10_LUMA_THRESH_LOW_D ,LUMA_THRESH_LOW_D RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_10_LUMA_OFFSET_LOW_D ,LUMA_OFFSET_LOW_D RESET:0x0"
          
          
group.long  0x204c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_11, DEMOSAIC_RGB_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_11_LUMA_SLOPE_LOW_D ,LUMA_SLOPE_LOW_D RESET:0x0"
          
          
group.long  0x2050++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_12, DEMOSAIC_RGB_REGISTER_12 RESET:0x0"
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_12_LUMA_THRESH_HIGH_D ,LUMA_THRESH_HIGH_D RESET:0x0"
          
          
group.long  0x2054++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_13, DEMOSAIC_RGB_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_13_LUMA_SLOPE_HIGH_D ,LUMA_SLOPE_HIGH_D RESET:0x0"
          
          
group.long  0x2058++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_14, DEMOSAIC_RGB_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_14_LUMA_THRESH_LOW_UD ,LUMA_THRESH_LOW_UD RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_14_LUMA_OFFSET_LOW_UD ,LUMA_OFFSET_LOW_UD RESET:0x0"
          
          
group.long  0x205c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_15, DEMOSAIC_RGB_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_15_LUMA_SLOPE_LOW_UD ,LUMA_SLOPE_LOW_UD RESET:0x0"
          
          
group.long  0x2060++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_16, DEMOSAIC_RGB_REGISTER_16 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_16_LUMA_THRESH_HIGH_UD ,LUMA_THRESH_HIGH_UD RESET:0x0"
          
          
group.long  0x2064++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_17, DEMOSAIC_RGB_REGISTER_17 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DEMOSAIC_RGB_REGISTER_17_LUMA_SLOPE_HIGH_UD ,LUMA_SLOPE_HIGH_UD RESET:0x0"
          
          
group.long  0x2140++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_0, PF_CORRECTION_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_0_USE_COLOR_CORRECTED_RGB ,USE_COLOR_CORRECTED_RGB RESET:0x0"
          
          
group.long  0x2144++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_1, PF_CORRECTION_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_1_HUE_STRENGTH ,HUE_STRENGTH RESET:0x0"
          
          
group.long  0x2148++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_2, PF_CORRECTION_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_2_SAT_STRENGTH ,SAT_STRENGTH RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_2_LUMA_STRENGTH ,LUMA_STRENGTH RESET:0x0"
          
          
group.long  0x214c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_3, PF_CORRECTION_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_3_PURPLE_STRENGTH ,PURPLE_STRENGTH RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_3_SATURATION_STRENGTH ,SATURATION_STRENGTH RESET:0x0"
          
          
group.long  0x2150++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_4, PF_CORRECTION_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_4_OFF_CENTER_MULT ,OFF_CENTER_MULT RESET:0x0"
          
          
group.long  0x2154++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_5, PF_CORRECTION_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_5_CENTER_X ,CENTER_X RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_5_CENTER_Y ,CENTER_Y RESET:0x0"
          
group.long  0x2158++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_6, PF_CORRECTION_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_6_CCM_COEFF_RR ,CCM_COEFF_RR RESET:0x0"
          
          
group.long  0x215c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_7, PF_CORRECTION_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_7_CCM_COEFF_RG ,CCM_COEFF_RG RESET:0x0"
          
          
group.long  0x2160++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_8, PF_CORRECTION_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_8_CCM_COEFF_RB ,CCM_COEFF_RB RESET:0x0"
          
          
group.long  0x2164++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_9, PF_CORRECTION_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_9_CCM_COEFF_GR ,CCM_COEFF_GR RESET:0x0"
          
          
group.long  0x2168++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_10, PF_CORRECTION_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_10_CCM_COEFF_GG ,CCM_COEFF_GG RESET:0x0"
          
          
group.long  0x216c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_11, PF_CORRECTION_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_11_CCM_COEFF_GB ,CCM_COEFF_GB RESET:0x0"
          
          
group.long  0x2170++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_12, PF_CORRECTION_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_12_CCM_COEFF_BR ,CCM_COEFF_BR RESET:0x0"
          
          
group.long  0x2174++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_13, PF_CORRECTION_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_13_CCM_COEFF_BG ,CCM_COEFF_BG RESET:0x0"
          
          
group.long  0x2178++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_14, PF_CORRECTION_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_14_CCM_COEFF_BB ,CCM_COEFF_BB RESET:0x0"
          
          
group.long  0x217c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_15, PF_CORRECTION_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_15_SAD_SLOPE ,SAD_SLOPE RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_15_SAD_OFFSET ,SAD_OFFSET RESET:0x0"
          
          
group.long  0x2180++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_16, PF_CORRECTION_REGISTER_16 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_16_SAD_THRESH ,SAD_THRESH RESET:0x0"
          
          
group.long  0x2184++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_17, PF_CORRECTION_REGISTER_17 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_17_HUE_LOW_SLOPE ,HUE_LOW_SLOPE RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_17_HUE_LOW_OFFSET ,HUE_LOW_OFFSET RESET:0x0"
          
          
group.long  0x2188++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_18, PF_CORRECTION_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_18_HUE_LOW_THRESH ,HUE_LOW_THRESH RESET:0x0"
          
          
group.long  0x218c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_19, PF_CORRECTION_REGISTER_19 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_19_HUE_HIGH_SLOPE ,HUE_HIGH_SLOPE RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_19_HUE_HIGH_OFFSET ,HUE_HIGH_OFFSET RESET:0x0"
          
          
group.long  0x2190++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_20, PF_CORRECTION_REGISTER_20 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_20_HUE_HIGH_THRESH ,HUE_HIGH_THRESH RESET:0x0"
          
          
group.long  0x2194++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_21, PF_CORRECTION_REGISTER_21 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_21_SAT_LOW_SLOPE ,SAT_LOW_SLOPE RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_21_SAT_LOW_OFFSET ,SAT_LOW_OFFSET RESET:0x0"
          
          
group.long  0x2198++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_22, PF_CORRECTION_REGISTER_22 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_22_SAT_LOW_THRESH ,SAT_LOW_THRESH RESET:0x0"
          
          
group.long  0x219c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_23, PF_CORRECTION_REGISTER_23 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_23_SAT_HIGH_SLOPE ,SAT_HIGH_SLOPE RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_23_SAT_HIGH_OFFSET ,SAT_HIGH_OFFSET RESET:0x0"
          
          
group.long  0x21a0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_24, PF_CORRECTION_REGISTER_24 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_24_SAT_HIGH_THRESH ,SAT_HIGH_THRESH RESET:0x0"
          
          
group.long  0x21a4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_25, PF_CORRECTION_REGISTER_25 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_25_LUMA1_LOW_SLOPE ,LUMA1_LOW_SLOPE RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_25_LUMA1_LOW_OFFSET ,LUMA1_LOW_OFFSET RESET:0x0"
          
          
group.long  0x21a8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_26, PF_CORRECTION_REGISTER_26 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_26_LUMA1_LOW_THRESH ,LUMA1_LOW_THRESH RESET:0x0"
          
          
group.long  0x21ac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_27, PF_CORRECTION_REGISTER_27 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_27_LUMA1_HIGH_SLOPE ,LUMA1_HIGH_SLOPE RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_27_LUMA1_HIGH_OFFSET ,LUMA1_HIGH_OFFSET RESET:0x0"
          
          
group.long  0x21b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_28, PF_CORRECTION_REGISTER_28 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_28_LUMA1_HIGH_THRESH ,LUMA1_HIGH_THRESH RESET:0x0"
          
          
group.long  0x21b4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_29, PF_CORRECTION_REGISTER_29 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_29_LUMA2_LOW_SLOPE ,LUMA2_LOW_SLOPE RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_29_LUMA2_LOW_OFFSET ,LUMA2_LOW_OFFSET RESET:0x0"
          
          
group.long  0x21b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_30, PF_CORRECTION_REGISTER_30 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_30_LUMA2_LOW_THRESH ,LUMA2_LOW_THRESH RESET:0x0"
          
          
group.long  0x21bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_31, PF_CORRECTION_REGISTER_31 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_31_LUMA2_HIGH_SLOPE ,LUMA2_HIGH_SLOPE RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_31_LUMA2_HIGH_OFFSET ,LUMA2_HIGH_OFFSET RESET:0x0"
          
          
group.long  0x21c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_32, PF_CORRECTION_REGISTER_32 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_32_LUMA2_HIGH_THRESH ,LUMA2_HIGH_THRESH RESET:0x0"
          
          
group.long  0x21c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_33, PF_CORRECTION_REGISTER_33 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_33_HSL_SLOPE ,HSL_SLOPE RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_33_HSL_OFFSET ,HSL_OFFSET RESET:0x0"
          
          
group.long  0x21c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_34, PF_CORRECTION_REGISTER_34 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_34_HSL_THRESH ,HSL_THRESH RESET:0x0"
          
          
group.long  0x21cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_35, PF_CORRECTION_REGISTER_35 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_REGISTER_35_DEBUG_SEL ,DEBUG_SEL RESET:0x0"
          
          
group.long  0x21d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_0, PF_CORRECTION_SHADING_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_0_SHADING_LUT_REG0_SEGMENT0 ,SHADING_LUT_REG0_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_0_SHADING_LUT_REG0_SEGMENT1 ,SHADING_LUT_REG0_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_0_SHADING_LUT_REG0_SEGMENT2 ,SHADING_LUT_REG0_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_0_SHADING_LUT_REG0_SEGMENT3 ,SHADING_LUT_REG0_SEGMENT3 RESET:0x0"
          
group.long  0x21d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_1, PF_CORRECTION_SHADING_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_1_SHADING_LUT_REG1_SEGMENT0 ,SHADING_LUT_REG1_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_1_SHADING_LUT_REG1_SEGMENT1 ,SHADING_LUT_REG1_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_1_SHADING_LUT_REG1_SEGMENT2 ,SHADING_LUT_REG1_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_1_SHADING_LUT_REG1_SEGMENT3 ,SHADING_LUT_REG1_SEGMENT3 RESET:0x0"
          
group.long  0x21d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_2, PF_CORRECTION_SHADING_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_2_SHADING_LUT_REG2_SEGMENT0 ,SHADING_LUT_REG2_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_2_SHADING_LUT_REG2_SEGMENT1 ,SHADING_LUT_REG2_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_2_SHADING_LUT_REG2_SEGMENT2 ,SHADING_LUT_REG2_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_2_SHADING_LUT_REG2_SEGMENT3 ,SHADING_LUT_REG2_SEGMENT3 RESET:0x0"
          
group.long  0x21dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_3, PF_CORRECTION_SHADING_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_3_SHADING_LUT_REG3_SEGMENT0 ,SHADING_LUT_REG3_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_3_SHADING_LUT_REG3_SEGMENT1 ,SHADING_LUT_REG3_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_3_SHADING_LUT_REG3_SEGMENT2 ,SHADING_LUT_REG3_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_3_SHADING_LUT_REG3_SEGMENT3 ,SHADING_LUT_REG3_SEGMENT3 RESET:0x0"
          
group.long  0x21e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_4, PF_CORRECTION_SHADING_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_4_SHADING_LUT_REG4_SEGMENT0 ,SHADING_LUT_REG4_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_4_SHADING_LUT_REG4_SEGMENT1 ,SHADING_LUT_REG4_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_4_SHADING_LUT_REG4_SEGMENT2 ,SHADING_LUT_REG4_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_4_SHADING_LUT_REG4_SEGMENT3 ,SHADING_LUT_REG4_SEGMENT3 RESET:0x0"
          
group.long  0x21e4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_5, PF_CORRECTION_SHADING_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_5_SHADING_LUT_REG5_SEGMENT0 ,SHADING_LUT_REG5_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_5_SHADING_LUT_REG5_SEGMENT1 ,SHADING_LUT_REG5_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_5_SHADING_LUT_REG5_SEGMENT2 ,SHADING_LUT_REG5_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_5_SHADING_LUT_REG5_SEGMENT3 ,SHADING_LUT_REG5_SEGMENT3 RESET:0x0"
          
group.long  0x21e8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_6, PF_CORRECTION_SHADING_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_6_SHADING_LUT_REG6_SEGMENT0 ,SHADING_LUT_REG6_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_6_SHADING_LUT_REG6_SEGMENT1 ,SHADING_LUT_REG6_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_6_SHADING_LUT_REG6_SEGMENT2 ,SHADING_LUT_REG6_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_6_SHADING_LUT_REG6_SEGMENT3 ,SHADING_LUT_REG6_SEGMENT3 RESET:0x0"
          
group.long  0x21ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_7, PF_CORRECTION_SHADING_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_7_SHADING_LUT_REG7_SEGMENT0 ,SHADING_LUT_REG7_SEGMENT0 RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_7_SHADING_LUT_REG7_SEGMENT1 ,SHADING_LUT_REG7_SEGMENT1 RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_7_SHADING_LUT_REG7_SEGMENT2 ,SHADING_LUT_REG7_SEGMENT2 RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_PF_CORRECTION_SHADING_REGISTER_7_SHADING_LUT_REG7_SEGMENT3 ,SHADING_LUT_REG7_SEGMENT3 RESET:0x0"
          
group.long  0x21f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_0, CCM_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
          
group.long  0x21f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_1, CCM_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_1_COEFFT_R_R ,COEFFT_R-R RESET:0x0"
          
          
group.long  0x21fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_2, CCM_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_2_COEFFT_R_G ,COEFFT_R-G RESET:0x0"
          
          
group.long  0x2200++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_3, CCM_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_3_COEFFT_R_B ,COEFFT_R-B RESET:0x0"
          
          
group.long  0x2208++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_4, CCM_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_4_COEFFT_G_R ,COEFFT_G-R RESET:0x0"
          
          
group.long  0x220c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_5, CCM_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_5_COEFFT_G_G ,COEFFT_G-G RESET:0x0"
          
          
group.long  0x2210++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_6, CCM_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_6_COEFFT_G_B ,COEFFT_G-B RESET:0x0"
          
          
group.long  0x2218++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_7, CCM_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_7_COEFFT_B_R ,COEFFT_B-R RESET:0x0"
          
          
group.long  0x221c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_8, CCM_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_8_COEFFT_B_G ,COEFFT_B-G RESET:0x0"
          
          
group.long  0x2220++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_9, CCM_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_9_COEFFT_B_B ,COEFFT_B-B RESET:0x0"
          
          
group.long  0x2228++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_10, CCM_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_10_COEFFT_WB_R ,COEFFT_WB_R RESET:0x0"
          
          
group.long  0x222c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_11, CCM_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_11_COEFFT_WB_G ,COEFFT_WB_G RESET:0x0"
          
          
group.long  0x2230++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_12, CCM_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_12_COEFFT_WB_B ,COEFFT_WB_B RESET:0x0"
          
          
group.long  0x2238++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_13, CCM_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_13_COEFFT_FOG_OFFSET_R ,COEFFT_FOG_OFFSET_R RESET:0x0"
          
          
group.long  0x223c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_14, CCM_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_14_COEFFT_FOG_OFFSET_G ,COEFFT_FOG_OFFSET_G RESET:0x0"
          
          
group.long  0x2240++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_15, CCM_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CCM_REGISTER_15_COEFFT_FOG_OFFSET_B ,COEFFT_FOG_OFFSET_B RESET:0x0"
          
          
group.long  0x2248++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_0, CNR_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_0_SQUARE_ROOT_ENABLE ,SQUARE_ROOT_ENABLE RESET:0x0"
          
          
group.long  0x224c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_1, CNR_REGISTER_1 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_1_ENABLE ,ENABLE RESET:0x0"
          
          
group.long  0x2250++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_2, CNR_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_2_DEBUG_REG ,DEBUG_REG RESET:0x0"
          
          
group.long  0x2258++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_3, CNR_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_3_DELTA_FACTOR ,DELTA_FACTOR RESET:0x0"
          
          
group.long  0x225c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_4, CNR_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_4_UV_SEG1_MIN ,UV_SEG1_MIN RESET:0x0"
          
          
group.long  0x2260++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_5, CNR_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_5_UV_SEG1_OFFSET ,UV_SEG1_OFFSET RESET:0x0"
          
          
group.long  0x2264++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_6, CNR_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_6_UV_SEG1_SLOPE ,UV_SEG1_SLOPE RESET:0x0"
          
          
group.long  0x2268++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_7, CNR_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_7_UV_MEAN_OFFSET ,UV_MEAN_OFFSET RESET:0x0"
          
          
group.long  0x226c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_8, CNR_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_8_UV_MEAN_SLOPE ,UV_MEAN_SLOPE RESET:0x0"
          
          
group.long  0x2270++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_9, CNR_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_9_UV_VAR_OFFSET ,UV_VAR_OFFSET RESET:0x0"
          
          
group.long  0x2274++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_10, CNR_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_10_UV_VAR_SLOPE ,UV_VAR_SLOPE RESET:0x0"
          
          
group.long  0x2278++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_11, CNR_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_11_UV_DELTA_OFFSET ,UV_DELTA_OFFSET RESET:0x0"
          
          
group.long  0x227c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_12, CNR_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_CNR_REGISTER_12_UV_DELTA_SLOPE ,UV_DELTA_SLOPE RESET:0x0"
          
          
group.long  0x23ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TARGETADDR_REGISTER_0, TARGETADDR_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TARGETADDR_REGISTER_0_TARGET1_ADDR ,TARGET1_ADDR RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_TARGETADDR_REGISTER_0_TARGET2_ADDR ,TARGET2_ADDR RESET:0x0"
          
group.long  0x23f0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AEXP_REGISTER_0, METERING_AEXP_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AEXP_REGISTER_0_HIST_THRESH_0_1 ,HIST_THRESH_0_1 RESET:0x0"
          
          
group.long  0x23f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AEXP_REGISTER_1, METERING_AEXP_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AEXP_REGISTER_1_HIST_THRESH_1_2 ,HIST_THRESH_1_2 RESET:0x0"
          
          
group.long  0x23f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AEXP_REGISTER_2, METERING_AEXP_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AEXP_REGISTER_2_HIST_THRESH_3_4 ,HIST_THRESH_3_4 RESET:0x0"
          
          
group.long  0x23fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AEXP_REGISTER_3, METERING_AEXP_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AEXP_REGISTER_3_HIST_THRESH_4_5 ,HIST_THRESH_4_5 RESET:0x0"
          
          
group.long  0x2410++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AEXP_REGISTER_4, METERING_AEXP_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AEXP_REGISTER_4_NODES_USED_HORIZ ,NODES_USED_HORIZ RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AEXP_REGISTER_4_NODES_USED_VERT ,NODES_USED_VERT RESET:0x0"
          
          
group.long  0x2414++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_0, METERING_AWB_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_0_STATS_MODE ,STATS_MODE RESET:0x0"
          
          
group.long  0x2418++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_1, METERING_AWB_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_1_WHITE_LEVEL_AWB ,WHITE_LEVEL_AWB RESET:0x0"
          
          
group.long  0x241c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_2, METERING_AWB_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_2_BLACK_LEVEL_AWB ,BLACK_LEVEL_AWB RESET:0x0"
          
          
group.long  0x2420++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_3, METERING_AWB_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_3_CR_REF_MAX_AWB ,CR_REF_MAX_AWB RESET:0x0"
          
          
group.long  0x2424++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_4, METERING_AWB_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_4_CR_REF_MIN_AWB ,CR_REF_MIN_AWB RESET:0x0"
          
          
group.long  0x2428++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_5, METERING_AWB_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_5_CB_REF_MAX_AWB ,CB_REF_MAX_AWB RESET:0x0"
          
          
group.long  0x242c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_6, METERING_AWB_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_6_CB_REF_MIN_AWB ,CB_REF_MIN_AWB RESET:0x0"
          
          
group.long  0x243c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_7, METERING_AWB_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_7_NODES_USED_HORIZ ,NODES_USED_HORIZ RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_7_NODES_USED_VERT ,NODES_USED_VERT RESET:0x0"
          
          
group.long  0x2440++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_8, METERING_AWB_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_8_CR_REF_HIGH_AWB ,CR_REF_HIGH_AWB RESET:0x0"
          
          
group.long  0x2444++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_9, METERING_AWB_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_9_CR_REF_LOW_AWB ,CR_REF_LOW_AWB RESET:0x0"
          
          
group.long  0x2448++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_10, METERING_AWB_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_10_CB_REF_HIGH_AWB ,CB_REF_HIGH_AWB RESET:0x0"
          
          
group.long  0x244c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_11, METERING_AWB_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AWB_REGISTER_11_CB_REF_LOW_AWB ,CB_REF_LOW_AWB RESET:0x0"
          
          
group.long  0x2880++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_0, METERING_AF_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_0_ROI_HORIZ_START ,ROI_HORIZ_START RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_0_ROI_HORIZ_END ,ROI_HORIZ_END RESET:0x0"
          
group.long  0x2884++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_1, METERING_AF_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_1_ROI_VERT_START ,ROI_VERT_START RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_1_ROI_VERT_END ,ROI_VERT_END RESET:0x0"
          
group.long  0x2888++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_2, METERING_AF_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_2_NODES_USED_HORIZ ,NODES_USED_HORIZ RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_2_NODES_USED_VERT ,NODES_USED_VERT RESET:0x0"
          
          
group.long  0x288c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_3, METERING_AF_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_3_CHANNEL_MASK ,CHANNEL_MASK RESET:0x0"
          
          
group.long  0x2890++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_4, METERING_AF_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_4_BLACK_LEVEL ,BLACK_LEVEL RESET:0x0"
          
          
group.long  0x2894++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_5, METERING_AF_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_5_FIR_COEFFS_CENTER ,FIR_COEFFS_CENTER RESET:0x0"
          
          
group.long  0x2898++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_6, METERING_AF_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_6_FIR_COEFFS_SIDES ,FIR_COEFFS_SIDES RESET:0x0"
          
group.long  0x289c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_7, METERING_AF_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_7_FIR_COEFFS_SHIFT ,FIR_COEFFS_SHIFT RESET:0x0"
          
          
group.long  0x28a0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_8, METERING_AF_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_8_AR_COEFFS_HORIZ ,AR_COEFFS_HORIZ RESET:0x0"
          
          
group.long  0x28a4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_9, METERING_AF_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_AF_REGISTER_9_AR_COEFFS_VERT ,AR_COEFFS_VERT RESET:0x0"
          
          
group.long  0x28a8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_0, METERING_HIST_AEXP_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_0_SKIP_X ,SKIP_X RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_0_OFFSET_X ,OFFSET_X RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_0_SKIP_Y ,SKIP_Y RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_0_OFFSET_Y ,OFFSET_Y RESET:0x0"
          
          
group.long  0x28ac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_1, METERING_HIST_AEXP_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_1_SCALE_BOTTOM ,SCALE_BOTTOM RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_1_SCALE_TOP ,SCALE_TOP RESET:0x0"
          
          
rgroup.long 0x28b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_2, METERING_HIST_AEXP_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_2_TOTAL_PIXELS ,TOTAL_PIXELS RESET:0x0"
          
rgroup.long 0x28b4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_3, METERING_HIST_AEXP_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_3_COUNTED_PIXELS ,COUNTED_PIXELS RESET:0x0"
          
group.long  0x28b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_4, METERING_HIST_AEXP_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_4_PLANE_MODE ,PLANE_MODE RESET:0x0"
          
          
rgroup.long 0x28bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_5, METERING_HIST_AEXP_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_5_PLANE_TOTAL_0 ,PLANE_TOTAL_0 RESET:0x0"
          
rgroup.long 0x28c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_6, METERING_HIST_AEXP_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_6_PLANE_TOTAL_1 ,PLANE_TOTAL_1 RESET:0x0"
          
rgroup.long 0x28c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_7, METERING_HIST_AEXP_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_7_PLANE_TOTAL_2 ,PLANE_TOTAL_2 RESET:0x0"
          
rgroup.long 0x28c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_8, METERING_HIST_AEXP_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_8_PLANE_TOTAL_3 ,PLANE_TOTAL_3 RESET:0x0"
          
rgroup.long 0x28cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_9, METERING_HIST_AEXP_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_9_PLANE_COUNTED_0 ,PLANE_COUNTED_0 RESET:0x0"
          
rgroup.long 0x28d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_10, METERING_HIST_AEXP_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_10_PLANE_COUNTED_1 ,PLANE_COUNTED_1 RESET:0x0"
          
rgroup.long 0x28d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_11, METERING_HIST_AEXP_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_11_PLANE_COUNTED_2 ,PLANE_COUNTED_2 RESET:0x0"
          
rgroup.long 0x28d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_12, METERING_HIST_AEXP_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_12_PLANE_COUNTED_3 ,PLANE_COUNTED_3 RESET:0x0"
          
group.long  0x28dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_13, METERING_HIST_AEXP_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_13_NODES_USED_HORIZ ,NODES_USED_HORIZ RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_13_NODES_USED_VERT ,NODES_USED_VERT RESET:0x0"
          
          
group.long  0x28e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_14, METERING_HIST_AEXP_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT0 ,ZONES_WEIGHT_REG0_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT1 ,ZONES_WEIGHT_REG0_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT2 ,ZONES_WEIGHT_REG0_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT3 ,ZONES_WEIGHT_REG0_SEGMENT3 RESET:0x0"
          
          
group.long  0x28e4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_15, METERING_HIST_AEXP_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT0 ,ZONES_WEIGHT_REG1_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT1 ,ZONES_WEIGHT_REG1_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT2 ,ZONES_WEIGHT_REG1_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT3 ,ZONES_WEIGHT_REG1_SEGMENT3 RESET:0x0"
          
          
group.long  0x28e8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_16, METERING_HIST_AEXP_REGISTER_16 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT0 ,ZONES_WEIGHT_REG2_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT1 ,ZONES_WEIGHT_REG2_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT2 ,ZONES_WEIGHT_REG2_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT3 ,ZONES_WEIGHT_REG2_SEGMENT3 RESET:0x0"
          
          
group.long  0x28ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_17, METERING_HIST_AEXP_REGISTER_17 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT0 ,ZONES_WEIGHT_REG3_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT1 ,ZONES_WEIGHT_REG3_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT2 ,ZONES_WEIGHT_REG3_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT3 ,ZONES_WEIGHT_REG3_SEGMENT3 RESET:0x0"
          
          
group.long  0x28f0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_18, METERING_HIST_AEXP_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT0 ,ZONES_WEIGHT_REG4_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT1 ,ZONES_WEIGHT_REG4_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT2 ,ZONES_WEIGHT_REG4_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT3 ,ZONES_WEIGHT_REG4_SEGMENT3 RESET:0x0"
          
          
group.long  0x28f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_19, METERING_HIST_AEXP_REGISTER_19 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT0 ,ZONES_WEIGHT_REG5_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT1 ,ZONES_WEIGHT_REG5_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT2 ,ZONES_WEIGHT_REG5_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT3 ,ZONES_WEIGHT_REG5_SEGMENT3 RESET:0x0"
          
          
group.long  0x28f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_20, METERING_HIST_AEXP_REGISTER_20 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT0 ,ZONES_WEIGHT_REG6_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT1 ,ZONES_WEIGHT_REG6_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT2 ,ZONES_WEIGHT_REG6_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT3 ,ZONES_WEIGHT_REG6_SEGMENT3 RESET:0x0"
          
          
group.long  0x28fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_21, METERING_HIST_AEXP_REGISTER_21 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT0 ,ZONES_WEIGHT_REG7_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT1 ,ZONES_WEIGHT_REG7_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT2 ,ZONES_WEIGHT_REG7_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT3 ,ZONES_WEIGHT_REG7_SEGMENT3 RESET:0x0"
          
          
group.long  0x2900++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_22, METERING_HIST_AEXP_REGISTER_22 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT0 ,ZONES_WEIGHT_REG8_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT1 ,ZONES_WEIGHT_REG8_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT2 ,ZONES_WEIGHT_REG8_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT3 ,ZONES_WEIGHT_REG8_SEGMENT3 RESET:0x0"
          
          
group.long  0x2904++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_23, METERING_HIST_AEXP_REGISTER_23 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT0 ,ZONES_WEIGHT_REG9_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT1 ,ZONES_WEIGHT_REG9_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT2 ,ZONES_WEIGHT_REG9_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT3 ,ZONES_WEIGHT_REG9_SEGMENT3 RESET:0x0"
          
          
group.long  0x2908++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_24, METERING_HIST_AEXP_REGISTER_24 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT0 ,ZONES_WEIGHT_REG10_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT1 ,ZONES_WEIGHT_REG10_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT2 ,ZONES_WEIGHT_REG10_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT3 ,ZONES_WEIGHT_REG10_SEGMENT3 RESET:0x0"
          
          
group.long  0x290c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_25, METERING_HIST_AEXP_REGISTER_25 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT0 ,ZONES_WEIGHT_REG11_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT1 ,ZONES_WEIGHT_REG11_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT2 ,ZONES_WEIGHT_REG11_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT3 ,ZONES_WEIGHT_REG11_SEGMENT3 RESET:0x0"
          
          
group.long  0x2910++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_26, METERING_HIST_AEXP_REGISTER_26 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT0 ,ZONES_WEIGHT_REG12_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT1 ,ZONES_WEIGHT_REG12_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT2 ,ZONES_WEIGHT_REG12_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT3 ,ZONES_WEIGHT_REG12_SEGMENT3 RESET:0x0"
          
          
group.long  0x2914++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_27, METERING_HIST_AEXP_REGISTER_27 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT0 ,ZONES_WEIGHT_REG13_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT1 ,ZONES_WEIGHT_REG13_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT2 ,ZONES_WEIGHT_REG13_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT3 ,ZONES_WEIGHT_REG13_SEGMENT3 RESET:0x0"
          
          
group.long  0x2918++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_28, METERING_HIST_AEXP_REGISTER_28 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT0 ,ZONES_WEIGHT_REG14_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT1 ,ZONES_WEIGHT_REG14_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT2 ,ZONES_WEIGHT_REG14_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT3 ,ZONES_WEIGHT_REG14_SEGMENT3 RESET:0x0"
          
          
group.long  0x291c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_29, METERING_HIST_AEXP_REGISTER_29 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT0 ,ZONES_WEIGHT_REG15_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT1 ,ZONES_WEIGHT_REG15_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT2 ,ZONES_WEIGHT_REG15_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT3 ,ZONES_WEIGHT_REG15_SEGMENT3 RESET:0x0"
          
          
group.long  0x2920++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_30, METERING_HIST_AEXP_REGISTER_30 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT0 ,ZONES_WEIGHT_REG16_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT1 ,ZONES_WEIGHT_REG16_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT2 ,ZONES_WEIGHT_REG16_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT3 ,ZONES_WEIGHT_REG16_SEGMENT3 RESET:0x0"
          
          
group.long  0x2924++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_31, METERING_HIST_AEXP_REGISTER_31 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT0 ,ZONES_WEIGHT_REG17_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT1 ,ZONES_WEIGHT_REG17_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT2 ,ZONES_WEIGHT_REG17_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT3 ,ZONES_WEIGHT_REG17_SEGMENT3 RESET:0x0"
          
          
group.long  0x2928++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_32, METERING_HIST_AEXP_REGISTER_32 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT0 ,ZONES_WEIGHT_REG18_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT1 ,ZONES_WEIGHT_REG18_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT2 ,ZONES_WEIGHT_REG18_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT3 ,ZONES_WEIGHT_REG18_SEGMENT3 RESET:0x0"
          
          
group.long  0x292c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_33, METERING_HIST_AEXP_REGISTER_33 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT0 ,ZONES_WEIGHT_REG19_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT1 ,ZONES_WEIGHT_REG19_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT2 ,ZONES_WEIGHT_REG19_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT3 ,ZONES_WEIGHT_REG19_SEGMENT3 RESET:0x0"
          
          
group.long  0x2930++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_34, METERING_HIST_AEXP_REGISTER_34 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT0 ,ZONES_WEIGHT_REG20_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT1 ,ZONES_WEIGHT_REG20_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT2 ,ZONES_WEIGHT_REG20_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT3 ,ZONES_WEIGHT_REG20_SEGMENT3 RESET:0x0"
          
          
group.long  0x2934++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_35, METERING_HIST_AEXP_REGISTER_35 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT0 ,ZONES_WEIGHT_REG21_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT1 ,ZONES_WEIGHT_REG21_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT2 ,ZONES_WEIGHT_REG21_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT3 ,ZONES_WEIGHT_REG21_SEGMENT3 RESET:0x0"
          
          
group.long  0x2938++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_36, METERING_HIST_AEXP_REGISTER_36 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT0 ,ZONES_WEIGHT_REG22_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT1 ,ZONES_WEIGHT_REG22_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT2 ,ZONES_WEIGHT_REG22_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT3 ,ZONES_WEIGHT_REG22_SEGMENT3 RESET:0x0"
          
          
group.long  0x293c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_37, METERING_HIST_AEXP_REGISTER_37 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT0 ,ZONES_WEIGHT_REG23_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT1 ,ZONES_WEIGHT_REG23_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT2 ,ZONES_WEIGHT_REG23_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT3 ,ZONES_WEIGHT_REG23_SEGMENT3 RESET:0x0"
          
          
group.long  0x2940++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_38, METERING_HIST_AEXP_REGISTER_38 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT0 ,ZONES_WEIGHT_REG24_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT1 ,ZONES_WEIGHT_REG24_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT2 ,ZONES_WEIGHT_REG24_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT3 ,ZONES_WEIGHT_REG24_SEGMENT3 RESET:0x0"
          
          
group.long  0x2944++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_39, METERING_HIST_AEXP_REGISTER_39 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT0 ,ZONES_WEIGHT_REG25_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT1 ,ZONES_WEIGHT_REG25_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT2 ,ZONES_WEIGHT_REG25_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT3 ,ZONES_WEIGHT_REG25_SEGMENT3 RESET:0x0"
          
          
group.long  0x2948++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_40, METERING_HIST_AEXP_REGISTER_40 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT0 ,ZONES_WEIGHT_REG26_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT1 ,ZONES_WEIGHT_REG26_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT2 ,ZONES_WEIGHT_REG26_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT3 ,ZONES_WEIGHT_REG26_SEGMENT3 RESET:0x0"
          
          
group.long  0x294c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_41, METERING_HIST_AEXP_REGISTER_41 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT0 ,ZONES_WEIGHT_REG27_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT1 ,ZONES_WEIGHT_REG27_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT2 ,ZONES_WEIGHT_REG27_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT3 ,ZONES_WEIGHT_REG27_SEGMENT3 RESET:0x0"
          
          
group.long  0x2950++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_42, METERING_HIST_AEXP_REGISTER_42 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT0 ,ZONES_WEIGHT_REG28_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT1 ,ZONES_WEIGHT_REG28_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT2 ,ZONES_WEIGHT_REG28_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT3 ,ZONES_WEIGHT_REG28_SEGMENT3 RESET:0x0"
          
          
group.long  0x2954++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_43, METERING_HIST_AEXP_REGISTER_43 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT0 ,ZONES_WEIGHT_REG29_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT1 ,ZONES_WEIGHT_REG29_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT2 ,ZONES_WEIGHT_REG29_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT3 ,ZONES_WEIGHT_REG29_SEGMENT3 RESET:0x0"
          
          
group.long  0x2958++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_44, METERING_HIST_AEXP_REGISTER_44 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT0 ,ZONES_WEIGHT_REG30_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT1 ,ZONES_WEIGHT_REG30_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT2 ,ZONES_WEIGHT_REG30_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT3 ,ZONES_WEIGHT_REG30_SEGMENT3 RESET:0x0"
          
          
group.long  0x295c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_45, METERING_HIST_AEXP_REGISTER_45 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT0 ,ZONES_WEIGHT_REG31_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT1 ,ZONES_WEIGHT_REG31_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT2 ,ZONES_WEIGHT_REG31_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT3 ,ZONES_WEIGHT_REG31_SEGMENT3 RESET:0x0"
          
          
group.long  0x2960++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_46, METERING_HIST_AEXP_REGISTER_46 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT0 ,ZONES_WEIGHT_REG32_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT1 ,ZONES_WEIGHT_REG32_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT2 ,ZONES_WEIGHT_REG32_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT3 ,ZONES_WEIGHT_REG32_SEGMENT3 RESET:0x0"
          
          
group.long  0x2964++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_47, METERING_HIST_AEXP_REGISTER_47 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT0 ,ZONES_WEIGHT_REG33_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT1 ,ZONES_WEIGHT_REG33_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT2 ,ZONES_WEIGHT_REG33_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT3 ,ZONES_WEIGHT_REG33_SEGMENT3 RESET:0x0"
          
          
group.long  0x2968++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_48, METERING_HIST_AEXP_REGISTER_48 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT0 ,ZONES_WEIGHT_REG34_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT1 ,ZONES_WEIGHT_REG34_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT2 ,ZONES_WEIGHT_REG34_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT3 ,ZONES_WEIGHT_REG34_SEGMENT3 RESET:0x0"
          
          
group.long  0x296c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_49, METERING_HIST_AEXP_REGISTER_49 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT0 ,ZONES_WEIGHT_REG35_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT1 ,ZONES_WEIGHT_REG35_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT2 ,ZONES_WEIGHT_REG35_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT3 ,ZONES_WEIGHT_REG35_SEGMENT3 RESET:0x0"
          
          
group.long  0x2970++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_50, METERING_HIST_AEXP_REGISTER_50 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT0 ,ZONES_WEIGHT_REG36_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT1 ,ZONES_WEIGHT_REG36_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT2 ,ZONES_WEIGHT_REG36_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT3 ,ZONES_WEIGHT_REG36_SEGMENT3 RESET:0x0"
          
          
group.long  0x2974++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_51, METERING_HIST_AEXP_REGISTER_51 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT0 ,ZONES_WEIGHT_REG37_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT1 ,ZONES_WEIGHT_REG37_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT2 ,ZONES_WEIGHT_REG37_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT3 ,ZONES_WEIGHT_REG37_SEGMENT3 RESET:0x0"
          
          
group.long  0x2978++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_52, METERING_HIST_AEXP_REGISTER_52 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT0 ,ZONES_WEIGHT_REG38_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT1 ,ZONES_WEIGHT_REG38_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT2 ,ZONES_WEIGHT_REG38_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT3 ,ZONES_WEIGHT_REG38_SEGMENT3 RESET:0x0"
          
          
group.long  0x297c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_53, METERING_HIST_AEXP_REGISTER_53 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT0 ,ZONES_WEIGHT_REG39_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT1 ,ZONES_WEIGHT_REG39_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT2 ,ZONES_WEIGHT_REG39_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT3 ,ZONES_WEIGHT_REG39_SEGMENT3 RESET:0x0"
          
          
group.long  0x2980++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_54, METERING_HIST_AEXP_REGISTER_54 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT0 ,ZONES_WEIGHT_REG40_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT1 ,ZONES_WEIGHT_REG40_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT2 ,ZONES_WEIGHT_REG40_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT3 ,ZONES_WEIGHT_REG40_SEGMENT3 RESET:0x0"
          
          
group.long  0x2984++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_55, METERING_HIST_AEXP_REGISTER_55 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT0 ,ZONES_WEIGHT_REG41_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT1 ,ZONES_WEIGHT_REG41_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT2 ,ZONES_WEIGHT_REG41_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT3 ,ZONES_WEIGHT_REG41_SEGMENT3 RESET:0x0"
          
          
group.long  0x2988++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_56, METERING_HIST_AEXP_REGISTER_56 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT0 ,ZONES_WEIGHT_REG42_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT1 ,ZONES_WEIGHT_REG42_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT2 ,ZONES_WEIGHT_REG42_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT3 ,ZONES_WEIGHT_REG42_SEGMENT3 RESET:0x0"
          
          
group.long  0x298c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_57, METERING_HIST_AEXP_REGISTER_57 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT0 ,ZONES_WEIGHT_REG43_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT1 ,ZONES_WEIGHT_REG43_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT2 ,ZONES_WEIGHT_REG43_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT3 ,ZONES_WEIGHT_REG43_SEGMENT3 RESET:0x0"
          
          
group.long  0x2990++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_58, METERING_HIST_AEXP_REGISTER_58 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT0 ,ZONES_WEIGHT_REG44_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT1 ,ZONES_WEIGHT_REG44_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT2 ,ZONES_WEIGHT_REG44_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT3 ,ZONES_WEIGHT_REG44_SEGMENT3 RESET:0x0"
          
          
group.long  0x2994++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_59, METERING_HIST_AEXP_REGISTER_59 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT0 ,ZONES_WEIGHT_REG45_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT1 ,ZONES_WEIGHT_REG45_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT2 ,ZONES_WEIGHT_REG45_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT3 ,ZONES_WEIGHT_REG45_SEGMENT3 RESET:0x0"
          
          
group.long  0x2998++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_60, METERING_HIST_AEXP_REGISTER_60 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT0 ,ZONES_WEIGHT_REG46_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT1 ,ZONES_WEIGHT_REG46_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT2 ,ZONES_WEIGHT_REG46_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT3 ,ZONES_WEIGHT_REG46_SEGMENT3 RESET:0x0"
          
          
group.long  0x299c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_61, METERING_HIST_AEXP_REGISTER_61 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT0 ,ZONES_WEIGHT_REG47_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT1 ,ZONES_WEIGHT_REG47_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT2 ,ZONES_WEIGHT_REG47_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT3 ,ZONES_WEIGHT_REG47_SEGMENT3 RESET:0x0"
          
          
group.long  0x29a0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_62, METERING_HIST_AEXP_REGISTER_62 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT0 ,ZONES_WEIGHT_REG48_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT1 ,ZONES_WEIGHT_REG48_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT2 ,ZONES_WEIGHT_REG48_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT3 ,ZONES_WEIGHT_REG48_SEGMENT3 RESET:0x0"
          
          
group.long  0x29a4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_63, METERING_HIST_AEXP_REGISTER_63 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT0 ,ZONES_WEIGHT_REG49_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT1 ,ZONES_WEIGHT_REG49_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT2 ,ZONES_WEIGHT_REG49_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT3 ,ZONES_WEIGHT_REG49_SEGMENT3 RESET:0x0"
          
          
group.long  0x29a8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_64, METERING_HIST_AEXP_REGISTER_64 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT0 ,ZONES_WEIGHT_REG50_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT1 ,ZONES_WEIGHT_REG50_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT2 ,ZONES_WEIGHT_REG50_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT3 ,ZONES_WEIGHT_REG50_SEGMENT3 RESET:0x0"
          
          
group.long  0x29ac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_65, METERING_HIST_AEXP_REGISTER_65 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT0 ,ZONES_WEIGHT_REG51_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT1 ,ZONES_WEIGHT_REG51_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT2 ,ZONES_WEIGHT_REG51_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT3 ,ZONES_WEIGHT_REG51_SEGMENT3 RESET:0x0"
          
          
group.long  0x29b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_66, METERING_HIST_AEXP_REGISTER_66 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT0 ,ZONES_WEIGHT_REG52_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT1 ,ZONES_WEIGHT_REG52_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT2 ,ZONES_WEIGHT_REG52_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT3 ,ZONES_WEIGHT_REG52_SEGMENT3 RESET:0x0"
          
          
group.long  0x29b4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_67, METERING_HIST_AEXP_REGISTER_67 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT0 ,ZONES_WEIGHT_REG53_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT1 ,ZONES_WEIGHT_REG53_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT2 ,ZONES_WEIGHT_REG53_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT3 ,ZONES_WEIGHT_REG53_SEGMENT3 RESET:0x0"
          
          
group.long  0x29b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_68, METERING_HIST_AEXP_REGISTER_68 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT0 ,ZONES_WEIGHT_REG54_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT1 ,ZONES_WEIGHT_REG54_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT2 ,ZONES_WEIGHT_REG54_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT3 ,ZONES_WEIGHT_REG54_SEGMENT3 RESET:0x0"
          
          
group.long  0x29bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_69, METERING_HIST_AEXP_REGISTER_69 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT0 ,ZONES_WEIGHT_REG55_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT1 ,ZONES_WEIGHT_REG55_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT2 ,ZONES_WEIGHT_REG55_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_HIST_AEXP_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT3 ,ZONES_WEIGHT_REG55_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d24++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_0, METERING_IHIST_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_0_SKIP_X ,SKIP_X RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_0_OFFSET_X ,OFFSET_X RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_0_SKIP_Y ,SKIP_Y RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_0_OFFSET_Y ,OFFSET_Y RESET:0x0"
          
          
group.long  0x2d28++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_1, METERING_IHIST_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_1_SCALE_BOTTOM ,SCALE_BOTTOM RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_1_SCALE_TOP ,SCALE_TOP RESET:0x0"
          
          
rgroup.long 0x2d2c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_2, METERING_IHIST_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_2_TOTAL_PIXELS ,TOTAL_PIXELS RESET:0x0"
          
rgroup.long 0x2d30++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_3, METERING_IHIST_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_3_COUNTED_PIXELS ,COUNTED_PIXELS RESET:0x0"
          
group.long  0x2d34++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_4, METERING_IHIST_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_4_PLANE_MODE ,PLANE_MODE RESET:0x0"
          
          
rgroup.long 0x2d38++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_5, METERING_IHIST_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_5_PLANE_TOTAL_0 ,PLANE_TOTAL_0 RESET:0x0"
          
rgroup.long 0x2d3c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_6, METERING_IHIST_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_6_PLANE_TOTAL_1 ,PLANE_TOTAL_1 RESET:0x0"
          
rgroup.long 0x2d40++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_7, METERING_IHIST_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_7_PLANE_TOTAL_2 ,PLANE_TOTAL_2 RESET:0x0"
          
rgroup.long 0x2d44++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_8, METERING_IHIST_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_8_PLANE_TOTAL_3 ,PLANE_TOTAL_3 RESET:0x0"
          
rgroup.long 0x2d48++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_9, METERING_IHIST_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_9_PLANE_COUNTED_0 ,PLANE_COUNTED_0 RESET:0x0"
          
rgroup.long 0x2d4c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_10, METERING_IHIST_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_10_PLANE_COUNTED_1 ,PLANE_COUNTED_1 RESET:0x0"
          
rgroup.long 0x2d50++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_11, METERING_IHIST_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_11_PLANE_COUNTED_2 ,PLANE_COUNTED_2 RESET:0x0"
          
rgroup.long 0x2d54++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_12, METERING_IHIST_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_12_PLANE_COUNTED_3 ,PLANE_COUNTED_3 RESET:0x0"
          
group.long  0x2d58++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_13, METERING_IHIST_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_13_NODES_USED_HORIZ ,NODES_USED_HORIZ RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_13_NODES_USED_VERT ,NODES_USED_VERT RESET:0x0"
          
          
group.long  0x2d5c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_14, METERING_IHIST_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT0 ,ZONES_WEIGHT_REG0_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT1 ,ZONES_WEIGHT_REG0_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT2 ,ZONES_WEIGHT_REG0_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_14_ZONES_WEIGHT_REG0_SEGMENT3 ,ZONES_WEIGHT_REG0_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d60++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_15, METERING_IHIST_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT0 ,ZONES_WEIGHT_REG1_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT1 ,ZONES_WEIGHT_REG1_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT2 ,ZONES_WEIGHT_REG1_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_15_ZONES_WEIGHT_REG1_SEGMENT3 ,ZONES_WEIGHT_REG1_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d64++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_16, METERING_IHIST_REGISTER_16 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT0 ,ZONES_WEIGHT_REG2_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT1 ,ZONES_WEIGHT_REG2_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT2 ,ZONES_WEIGHT_REG2_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_16_ZONES_WEIGHT_REG2_SEGMENT3 ,ZONES_WEIGHT_REG2_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d68++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_17, METERING_IHIST_REGISTER_17 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT0 ,ZONES_WEIGHT_REG3_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT1 ,ZONES_WEIGHT_REG3_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT2 ,ZONES_WEIGHT_REG3_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_17_ZONES_WEIGHT_REG3_SEGMENT3 ,ZONES_WEIGHT_REG3_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d6c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_18, METERING_IHIST_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT0 ,ZONES_WEIGHT_REG4_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT1 ,ZONES_WEIGHT_REG4_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT2 ,ZONES_WEIGHT_REG4_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_18_ZONES_WEIGHT_REG4_SEGMENT3 ,ZONES_WEIGHT_REG4_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d70++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_19, METERING_IHIST_REGISTER_19 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT0 ,ZONES_WEIGHT_REG5_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT1 ,ZONES_WEIGHT_REG5_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT2 ,ZONES_WEIGHT_REG5_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_19_ZONES_WEIGHT_REG5_SEGMENT3 ,ZONES_WEIGHT_REG5_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d74++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_20, METERING_IHIST_REGISTER_20 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT0 ,ZONES_WEIGHT_REG6_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT1 ,ZONES_WEIGHT_REG6_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT2 ,ZONES_WEIGHT_REG6_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_20_ZONES_WEIGHT_REG6_SEGMENT3 ,ZONES_WEIGHT_REG6_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d78++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_21, METERING_IHIST_REGISTER_21 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT0 ,ZONES_WEIGHT_REG7_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT1 ,ZONES_WEIGHT_REG7_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT2 ,ZONES_WEIGHT_REG7_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_21_ZONES_WEIGHT_REG7_SEGMENT3 ,ZONES_WEIGHT_REG7_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d7c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_22, METERING_IHIST_REGISTER_22 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT0 ,ZONES_WEIGHT_REG8_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT1 ,ZONES_WEIGHT_REG8_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT2 ,ZONES_WEIGHT_REG8_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_22_ZONES_WEIGHT_REG8_SEGMENT3 ,ZONES_WEIGHT_REG8_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d80++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_23, METERING_IHIST_REGISTER_23 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT0 ,ZONES_WEIGHT_REG9_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT1 ,ZONES_WEIGHT_REG9_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT2 ,ZONES_WEIGHT_REG9_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_23_ZONES_WEIGHT_REG9_SEGMENT3 ,ZONES_WEIGHT_REG9_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d84++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_24, METERING_IHIST_REGISTER_24 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT0 ,ZONES_WEIGHT_REG10_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT1 ,ZONES_WEIGHT_REG10_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT2 ,ZONES_WEIGHT_REG10_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_24_ZONES_WEIGHT_REG10_SEGMENT3 ,ZONES_WEIGHT_REG10_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d88++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_25, METERING_IHIST_REGISTER_25 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT0 ,ZONES_WEIGHT_REG11_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT1 ,ZONES_WEIGHT_REG11_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT2 ,ZONES_WEIGHT_REG11_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_25_ZONES_WEIGHT_REG11_SEGMENT3 ,ZONES_WEIGHT_REG11_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d8c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_26, METERING_IHIST_REGISTER_26 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT0 ,ZONES_WEIGHT_REG12_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT1 ,ZONES_WEIGHT_REG12_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT2 ,ZONES_WEIGHT_REG12_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_26_ZONES_WEIGHT_REG12_SEGMENT3 ,ZONES_WEIGHT_REG12_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d90++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_27, METERING_IHIST_REGISTER_27 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT0 ,ZONES_WEIGHT_REG13_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT1 ,ZONES_WEIGHT_REG13_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT2 ,ZONES_WEIGHT_REG13_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_27_ZONES_WEIGHT_REG13_SEGMENT3 ,ZONES_WEIGHT_REG13_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d94++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_28, METERING_IHIST_REGISTER_28 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT0 ,ZONES_WEIGHT_REG14_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT1 ,ZONES_WEIGHT_REG14_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT2 ,ZONES_WEIGHT_REG14_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_28_ZONES_WEIGHT_REG14_SEGMENT3 ,ZONES_WEIGHT_REG14_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d98++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_29, METERING_IHIST_REGISTER_29 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT0 ,ZONES_WEIGHT_REG15_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT1 ,ZONES_WEIGHT_REG15_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT2 ,ZONES_WEIGHT_REG15_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_29_ZONES_WEIGHT_REG15_SEGMENT3 ,ZONES_WEIGHT_REG15_SEGMENT3 RESET:0x0"
          
          
group.long  0x2d9c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_30, METERING_IHIST_REGISTER_30 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT0 ,ZONES_WEIGHT_REG16_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT1 ,ZONES_WEIGHT_REG16_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT2 ,ZONES_WEIGHT_REG16_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_30_ZONES_WEIGHT_REG16_SEGMENT3 ,ZONES_WEIGHT_REG16_SEGMENT3 RESET:0x0"
          
          
group.long  0x2da0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_31, METERING_IHIST_REGISTER_31 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT0 ,ZONES_WEIGHT_REG17_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT1 ,ZONES_WEIGHT_REG17_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT2 ,ZONES_WEIGHT_REG17_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_31_ZONES_WEIGHT_REG17_SEGMENT3 ,ZONES_WEIGHT_REG17_SEGMENT3 RESET:0x0"
          
          
group.long  0x2da4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_32, METERING_IHIST_REGISTER_32 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT0 ,ZONES_WEIGHT_REG18_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT1 ,ZONES_WEIGHT_REG18_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT2 ,ZONES_WEIGHT_REG18_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_32_ZONES_WEIGHT_REG18_SEGMENT3 ,ZONES_WEIGHT_REG18_SEGMENT3 RESET:0x0"
          
          
group.long  0x2da8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_33, METERING_IHIST_REGISTER_33 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT0 ,ZONES_WEIGHT_REG19_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT1 ,ZONES_WEIGHT_REG19_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT2 ,ZONES_WEIGHT_REG19_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_33_ZONES_WEIGHT_REG19_SEGMENT3 ,ZONES_WEIGHT_REG19_SEGMENT3 RESET:0x0"
          
          
group.long  0x2dac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_34, METERING_IHIST_REGISTER_34 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT0 ,ZONES_WEIGHT_REG20_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT1 ,ZONES_WEIGHT_REG20_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT2 ,ZONES_WEIGHT_REG20_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_34_ZONES_WEIGHT_REG20_SEGMENT3 ,ZONES_WEIGHT_REG20_SEGMENT3 RESET:0x0"
          
          
group.long  0x2db0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_35, METERING_IHIST_REGISTER_35 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT0 ,ZONES_WEIGHT_REG21_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT1 ,ZONES_WEIGHT_REG21_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT2 ,ZONES_WEIGHT_REG21_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_35_ZONES_WEIGHT_REG21_SEGMENT3 ,ZONES_WEIGHT_REG21_SEGMENT3 RESET:0x0"
          
          
group.long  0x2db4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_36, METERING_IHIST_REGISTER_36 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT0 ,ZONES_WEIGHT_REG22_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT1 ,ZONES_WEIGHT_REG22_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT2 ,ZONES_WEIGHT_REG22_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_36_ZONES_WEIGHT_REG22_SEGMENT3 ,ZONES_WEIGHT_REG22_SEGMENT3 RESET:0x0"
          
          
group.long  0x2db8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_37, METERING_IHIST_REGISTER_37 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT0 ,ZONES_WEIGHT_REG23_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT1 ,ZONES_WEIGHT_REG23_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT2 ,ZONES_WEIGHT_REG23_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_37_ZONES_WEIGHT_REG23_SEGMENT3 ,ZONES_WEIGHT_REG23_SEGMENT3 RESET:0x0"
          
          
group.long  0x2dbc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_38, METERING_IHIST_REGISTER_38 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT0 ,ZONES_WEIGHT_REG24_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT1 ,ZONES_WEIGHT_REG24_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT2 ,ZONES_WEIGHT_REG24_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_38_ZONES_WEIGHT_REG24_SEGMENT3 ,ZONES_WEIGHT_REG24_SEGMENT3 RESET:0x0"
          
          
group.long  0x2dc0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_39, METERING_IHIST_REGISTER_39 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT0 ,ZONES_WEIGHT_REG25_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT1 ,ZONES_WEIGHT_REG25_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT2 ,ZONES_WEIGHT_REG25_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_39_ZONES_WEIGHT_REG25_SEGMENT3 ,ZONES_WEIGHT_REG25_SEGMENT3 RESET:0x0"
          
          
group.long  0x2dc4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_40, METERING_IHIST_REGISTER_40 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT0 ,ZONES_WEIGHT_REG26_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT1 ,ZONES_WEIGHT_REG26_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT2 ,ZONES_WEIGHT_REG26_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_40_ZONES_WEIGHT_REG26_SEGMENT3 ,ZONES_WEIGHT_REG26_SEGMENT3 RESET:0x0"
          
          
group.long  0x2dc8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_41, METERING_IHIST_REGISTER_41 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT0 ,ZONES_WEIGHT_REG27_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT1 ,ZONES_WEIGHT_REG27_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT2 ,ZONES_WEIGHT_REG27_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_41_ZONES_WEIGHT_REG27_SEGMENT3 ,ZONES_WEIGHT_REG27_SEGMENT3 RESET:0x0"
          
          
group.long  0x2dcc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_42, METERING_IHIST_REGISTER_42 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT0 ,ZONES_WEIGHT_REG28_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT1 ,ZONES_WEIGHT_REG28_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT2 ,ZONES_WEIGHT_REG28_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_42_ZONES_WEIGHT_REG28_SEGMENT3 ,ZONES_WEIGHT_REG28_SEGMENT3 RESET:0x0"
          
          
group.long  0x2dd0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_43, METERING_IHIST_REGISTER_43 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT0 ,ZONES_WEIGHT_REG29_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT1 ,ZONES_WEIGHT_REG29_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT2 ,ZONES_WEIGHT_REG29_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_43_ZONES_WEIGHT_REG29_SEGMENT3 ,ZONES_WEIGHT_REG29_SEGMENT3 RESET:0x0"
          
          
group.long  0x2dd4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_44, METERING_IHIST_REGISTER_44 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT0 ,ZONES_WEIGHT_REG30_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT1 ,ZONES_WEIGHT_REG30_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT2 ,ZONES_WEIGHT_REG30_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_44_ZONES_WEIGHT_REG30_SEGMENT3 ,ZONES_WEIGHT_REG30_SEGMENT3 RESET:0x0"
          
          
group.long  0x2dd8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_45, METERING_IHIST_REGISTER_45 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT0 ,ZONES_WEIGHT_REG31_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT1 ,ZONES_WEIGHT_REG31_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT2 ,ZONES_WEIGHT_REG31_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_45_ZONES_WEIGHT_REG31_SEGMENT3 ,ZONES_WEIGHT_REG31_SEGMENT3 RESET:0x0"
          
          
group.long  0x2ddc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_46, METERING_IHIST_REGISTER_46 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT0 ,ZONES_WEIGHT_REG32_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT1 ,ZONES_WEIGHT_REG32_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT2 ,ZONES_WEIGHT_REG32_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_46_ZONES_WEIGHT_REG32_SEGMENT3 ,ZONES_WEIGHT_REG32_SEGMENT3 RESET:0x0"
          
          
group.long  0x2de0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_47, METERING_IHIST_REGISTER_47 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT0 ,ZONES_WEIGHT_REG33_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT1 ,ZONES_WEIGHT_REG33_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT2 ,ZONES_WEIGHT_REG33_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_47_ZONES_WEIGHT_REG33_SEGMENT3 ,ZONES_WEIGHT_REG33_SEGMENT3 RESET:0x0"
          
          
group.long  0x2de4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_48, METERING_IHIST_REGISTER_48 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT0 ,ZONES_WEIGHT_REG34_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT1 ,ZONES_WEIGHT_REG34_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT2 ,ZONES_WEIGHT_REG34_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_48_ZONES_WEIGHT_REG34_SEGMENT3 ,ZONES_WEIGHT_REG34_SEGMENT3 RESET:0x0"
          
          
group.long  0x2de8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_49, METERING_IHIST_REGISTER_49 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT0 ,ZONES_WEIGHT_REG35_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT1 ,ZONES_WEIGHT_REG35_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT2 ,ZONES_WEIGHT_REG35_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_49_ZONES_WEIGHT_REG35_SEGMENT3 ,ZONES_WEIGHT_REG35_SEGMENT3 RESET:0x0"
          
          
group.long  0x2dec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_50, METERING_IHIST_REGISTER_50 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT0 ,ZONES_WEIGHT_REG36_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT1 ,ZONES_WEIGHT_REG36_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT2 ,ZONES_WEIGHT_REG36_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_50_ZONES_WEIGHT_REG36_SEGMENT3 ,ZONES_WEIGHT_REG36_SEGMENT3 RESET:0x0"
          
          
group.long  0x2df0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_51, METERING_IHIST_REGISTER_51 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT0 ,ZONES_WEIGHT_REG37_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT1 ,ZONES_WEIGHT_REG37_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT2 ,ZONES_WEIGHT_REG37_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_51_ZONES_WEIGHT_REG37_SEGMENT3 ,ZONES_WEIGHT_REG37_SEGMENT3 RESET:0x0"
          
          
group.long  0x2df4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_52, METERING_IHIST_REGISTER_52 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT0 ,ZONES_WEIGHT_REG38_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT1 ,ZONES_WEIGHT_REG38_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT2 ,ZONES_WEIGHT_REG38_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_52_ZONES_WEIGHT_REG38_SEGMENT3 ,ZONES_WEIGHT_REG38_SEGMENT3 RESET:0x0"
          
          
group.long  0x2df8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_53, METERING_IHIST_REGISTER_53 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT0 ,ZONES_WEIGHT_REG39_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT1 ,ZONES_WEIGHT_REG39_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT2 ,ZONES_WEIGHT_REG39_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_53_ZONES_WEIGHT_REG39_SEGMENT3 ,ZONES_WEIGHT_REG39_SEGMENT3 RESET:0x0"
          
          
group.long  0x2dfc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_54, METERING_IHIST_REGISTER_54 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT0 ,ZONES_WEIGHT_REG40_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT1 ,ZONES_WEIGHT_REG40_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT2 ,ZONES_WEIGHT_REG40_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_54_ZONES_WEIGHT_REG40_SEGMENT3 ,ZONES_WEIGHT_REG40_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e00++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_55, METERING_IHIST_REGISTER_55 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT0 ,ZONES_WEIGHT_REG41_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT1 ,ZONES_WEIGHT_REG41_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT2 ,ZONES_WEIGHT_REG41_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_55_ZONES_WEIGHT_REG41_SEGMENT3 ,ZONES_WEIGHT_REG41_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e04++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_56, METERING_IHIST_REGISTER_56 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT0 ,ZONES_WEIGHT_REG42_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT1 ,ZONES_WEIGHT_REG42_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT2 ,ZONES_WEIGHT_REG42_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_56_ZONES_WEIGHT_REG42_SEGMENT3 ,ZONES_WEIGHT_REG42_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e08++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_57, METERING_IHIST_REGISTER_57 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT0 ,ZONES_WEIGHT_REG43_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT1 ,ZONES_WEIGHT_REG43_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT2 ,ZONES_WEIGHT_REG43_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_57_ZONES_WEIGHT_REG43_SEGMENT3 ,ZONES_WEIGHT_REG43_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e0c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_58, METERING_IHIST_REGISTER_58 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT0 ,ZONES_WEIGHT_REG44_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT1 ,ZONES_WEIGHT_REG44_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT2 ,ZONES_WEIGHT_REG44_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_58_ZONES_WEIGHT_REG44_SEGMENT3 ,ZONES_WEIGHT_REG44_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e10++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_59, METERING_IHIST_REGISTER_59 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT0 ,ZONES_WEIGHT_REG45_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT1 ,ZONES_WEIGHT_REG45_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT2 ,ZONES_WEIGHT_REG45_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_59_ZONES_WEIGHT_REG45_SEGMENT3 ,ZONES_WEIGHT_REG45_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e14++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_60, METERING_IHIST_REGISTER_60 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT0 ,ZONES_WEIGHT_REG46_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT1 ,ZONES_WEIGHT_REG46_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT2 ,ZONES_WEIGHT_REG46_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_60_ZONES_WEIGHT_REG46_SEGMENT3 ,ZONES_WEIGHT_REG46_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e18++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_61, METERING_IHIST_REGISTER_61 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT0 ,ZONES_WEIGHT_REG47_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT1 ,ZONES_WEIGHT_REG47_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT2 ,ZONES_WEIGHT_REG47_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_61_ZONES_WEIGHT_REG47_SEGMENT3 ,ZONES_WEIGHT_REG47_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e1c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_62, METERING_IHIST_REGISTER_62 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT0 ,ZONES_WEIGHT_REG48_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT1 ,ZONES_WEIGHT_REG48_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT2 ,ZONES_WEIGHT_REG48_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_62_ZONES_WEIGHT_REG48_SEGMENT3 ,ZONES_WEIGHT_REG48_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e20++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_63, METERING_IHIST_REGISTER_63 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT0 ,ZONES_WEIGHT_REG49_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT1 ,ZONES_WEIGHT_REG49_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT2 ,ZONES_WEIGHT_REG49_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_63_ZONES_WEIGHT_REG49_SEGMENT3 ,ZONES_WEIGHT_REG49_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e24++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_64, METERING_IHIST_REGISTER_64 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT0 ,ZONES_WEIGHT_REG50_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT1 ,ZONES_WEIGHT_REG50_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT2 ,ZONES_WEIGHT_REG50_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_64_ZONES_WEIGHT_REG50_SEGMENT3 ,ZONES_WEIGHT_REG50_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e28++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_65, METERING_IHIST_REGISTER_65 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT0 ,ZONES_WEIGHT_REG51_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT1 ,ZONES_WEIGHT_REG51_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT2 ,ZONES_WEIGHT_REG51_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_65_ZONES_WEIGHT_REG51_SEGMENT3 ,ZONES_WEIGHT_REG51_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e2c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_66, METERING_IHIST_REGISTER_66 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT0 ,ZONES_WEIGHT_REG52_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT1 ,ZONES_WEIGHT_REG52_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT2 ,ZONES_WEIGHT_REG52_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_66_ZONES_WEIGHT_REG52_SEGMENT3 ,ZONES_WEIGHT_REG52_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e30++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_67, METERING_IHIST_REGISTER_67 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT0 ,ZONES_WEIGHT_REG53_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT1 ,ZONES_WEIGHT_REG53_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT2 ,ZONES_WEIGHT_REG53_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_67_ZONES_WEIGHT_REG53_SEGMENT3 ,ZONES_WEIGHT_REG53_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e34++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_68, METERING_IHIST_REGISTER_68 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT0 ,ZONES_WEIGHT_REG54_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT1 ,ZONES_WEIGHT_REG54_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT2 ,ZONES_WEIGHT_REG54_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_68_ZONES_WEIGHT_REG54_SEGMENT3 ,ZONES_WEIGHT_REG54_SEGMENT3 RESET:0x0"
          
          
group.long  0x2e38++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_69, METERING_IHIST_REGISTER_69 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT0 ,ZONES_WEIGHT_REG55_SEGMENT0 RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT1 ,ZONES_WEIGHT_REG55_SEGMENT1 RESET:0x0"
          
          
         hexmask.long 0x00 16.--19. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT2 ,ZONES_WEIGHT_REG55_SEGMENT2 RESET:0x0"
          
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_METERING_IHIST_REGISTER_69_ZONES_WEIGHT_REG55_SEGMENT3 ,ZONES_WEIGHT_REG55_SEGMENT3 RESET:0x0"
          
          
group.long  0x31a0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CROP_REGISTER_0, FR_CROP_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CROP_REGISTER_0_ENABLE_CROP ,ENABLE_CROP RESET:0x0"
          
          
group.long  0x31a4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CROP_REGISTER_1, FR_CROP_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CROP_REGISTER_1_START_X ,START_X RESET:0x0"
          
          
group.long  0x31a8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CROP_REGISTER_2, FR_CROP_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CROP_REGISTER_2_START_Y ,START_Y RESET:0x0"
          
          
group.long  0x31ac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CROP_REGISTER_3, FR_CROP_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CROP_REGISTER_3_SIZE_X ,SIZE_X RESET:0x0"
          
          
group.long  0x31b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CROP_REGISTER_4, FR_CROP_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CROP_REGISTER_4_SIZE_Y ,SIZE_Y RESET:0x0"
          
          
group.long  0x31b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_0, FR_SCALER_REGISTER_0 RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_0_TIMEOUT_ENABLE ,TIMEOUT_ENABLE RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_0_TIMEOUT_VALUE ,TIMEOUT_VALUE RESET:0x0"
          
group.long  0x31bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_1, FR_SCALER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_1_WIDTH ,WIDTH RESET:0x0"
          
          
group.long  0x31c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_2, FR_SCALER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_2_HEIGHT ,HEIGHT RESET:0x0"
          
          
group.long  0x31c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_3, FR_SCALER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_3_OWIDTH ,OWIDTH RESET:0x0"
          
          
group.long  0x31c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_4, FR_SCALER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_4_OHEIGHT ,OHEIGHT RESET:0x0"
          
          
group.long  0x31cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_5, FR_SCALER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_5_HFILT_TINC ,HFILT_TINC RESET:0x0"
          
          
group.long  0x31d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_6, FR_SCALER_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_6_HFILT_COEFSET ,HFILT_COEFSET RESET:0x0"
          
          
group.long  0x31d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_7, FR_SCALER_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_7_VFILT_TINC ,VFILT_TINC RESET:0x0"
          
          
group.long  0x31d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_8, FR_SCALER_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SCALER_REGISTER_8_VFILT_COEFSET ,VFILT_COEFSET RESET:0x0"
          
          
group.long  0x31dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_GAMMA_RGB_REGISTER_0, FR_GAMMA_RGB_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_GAMMA_RGB_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
          
group.long  0x31e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_GAMMA_RGB_REGISTER_1, FR_GAMMA_RGB_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_GAMMA_RGB_REGISTER_1_GAIN_R ,GAIN_R RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_GAMMA_RGB_REGISTER_1_GAIN_G ,GAIN_G RESET:0x0"
          
          
group.long  0x31e4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_GAMMA_RGB_REGISTER_2, FR_GAMMA_RGB_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_GAMMA_RGB_REGISTER_2_GAIN_B ,GAIN_B RESET:0x0"
          
          
group.long  0x31e8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_GAMMA_RGB_REGISTER_3, FR_GAMMA_RGB_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_GAMMA_RGB_REGISTER_3_OFFSET_R ,OFFSET_R RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_GAMMA_RGB_REGISTER_3_OFFSET_G ,OFFSET_G RESET:0x0"
          
          
group.long  0x31ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_GAMMA_RGB_REGISTER_4, FR_GAMMA_RGB_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_GAMMA_RGB_REGISTER_4_OFFSET_B ,OFFSET_B RESET:0x0"
          
          
group.long  0x31f0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_0, FR_SHARPEN_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
          
group.long  0x31f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_1, FR_SHARPEN_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_1_STRENGTH ,STRENGTH RESET:0x0"
          
          
group.long  0x31f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_2, FR_SHARPEN_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_2_CONTROL_R ,CONTROL_R RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_2_CONTROL_B ,CONTROL_B RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_2_ALPHA_UNDERSHOOT ,ALPHA_UNDERSHOOT RESET:0x0"
          
          
group.long  0x31fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_3, FR_SHARPEN_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_3_LUMA_THRESH_LOW ,LUMA_THRESH_LOW RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_3_LUMA_OFFSET_LOW ,LUMA_OFFSET_LOW RESET:0x0"
          
          
group.long  0x3200++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_4, FR_SHARPEN_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_4_LUMA_SLOPE_LOW ,LUMA_SLOPE_LOW RESET:0x0"
          
         hexmask.long 0x00 16.--25. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_4_LUMA_THRESH_HIGH ,LUMA_THRESH_HIGH RESET:0x0"
          
          
group.long  0x3204++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_5, FR_SHARPEN_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_5_LUMA_OFFSET_HIGH ,LUMA_OFFSET_HIGH RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_5_LUMA_SLOPE_HIGH ,LUMA_SLOPE_HIGH RESET:0x0"
          
group.long  0x3208++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_6, FR_SHARPEN_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_6_CLIP_STR_MAX ,CLIP_STR_MAX RESET:0x0"
          
          
         hexmask.long 0x00 16.--29. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_6_CLIP_STR_MIN ,CLIP_STR_MIN RESET:0x0"
          
          
group.long  0x320c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_7, FR_SHARPEN_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_SHARPEN_REGISTER_7_DEBUG ,DEBUG RESET:0x0"
          
          
group.long  0x3210++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_0, FR_CS_CONV_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_0_ENABLE_MATRIX ,ENABLE_MATRIX RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_0_ENABLE_FILTER ,ENABLE_FILTER RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_0_ENABLE_HORIZONTAL_DOWNSAMPLE ,ENABLE_HORIZONTAL_DOWNSAMPLE RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_0_ENABLE_VERTICAL_DOWNSAMPLE ,ENABLE_VERTICAL_DOWNSAMPLE RESET:0x0"
          
          
group.long  0x3214++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_1, FR_CS_CONV_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_1_COEFFT_11 ,COEFFT_11 RESET:0x0"
          
          
group.long  0x3218++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_2, FR_CS_CONV_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_2_COEFFT_12 ,COEFFT_12 RESET:0x0"
          
          
group.long  0x321c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_3, FR_CS_CONV_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_3_COEFFT_13 ,COEFFT_13 RESET:0x0"
          
          
group.long  0x3220++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_4, FR_CS_CONV_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_4_COEFFT_21 ,COEFFT_21 RESET:0x0"
          
          
group.long  0x3224++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_5, FR_CS_CONV_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_5_COEFFT_22 ,COEFFT_22 RESET:0x0"
          
          
group.long  0x3228++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_6, FR_CS_CONV_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_6_COEFFT_23 ,COEFFT_23 RESET:0x0"
          
          
group.long  0x322c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_7, FR_CS_CONV_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_7_COEFFT_31 ,COEFFT_31 RESET:0x0"
          
          
group.long  0x3230++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_8, FR_CS_CONV_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_8_COEFFT_32 ,COEFFT_32 RESET:0x0"
          
          
group.long  0x3234++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_9, FR_CS_CONV_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_9_COEFFT_33 ,COEFFT_33 RESET:0x0"
          
          
group.long  0x3238++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_10, FR_CS_CONV_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_10_COEFFT_O1 ,COEFFT_O1 RESET:0x0"
          
          
group.long  0x323c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_11, FR_CS_CONV_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_11_COEFFT_O2 ,COEFFT_O2 RESET:0x0"
          
          
group.long  0x3240++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_12, FR_CS_CONV_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_12_COEFFT_O3 ,COEFFT_O3 RESET:0x0"
          
          
group.long  0x3244++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_13, FR_CS_CONV_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_13_CLIP_MIN_Y ,CLIP_MIN_Y RESET:0x0"
          
          
group.long  0x3248++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_14, FR_CS_CONV_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_14_CLIP_MAX_Y ,CLIP_MAX_Y RESET:0x0"
          
          
group.long  0x324c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_15, FR_CS_CONV_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_15_CLIP_MIN_UV ,CLIP_MIN_UV RESET:0x0"
          
          
group.long  0x3250++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_16, FR_CS_CONV_REGISTER_16 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_16_CLIP_MAX_UV ,CLIP_MAX_UV RESET:0x0"
          
          
group.long  0x3254++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_17, FR_CS_CONV_REGISTER_17 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_17_DATA_MASK_RY ,DATA_MASK_RY RESET:0x0"
          
          
group.long  0x3258++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_18, FR_CS_CONV_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_18_DATA_MASK_GU ,DATA_MASK_GU RESET:0x0"
          
          
group.long  0x325c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_19, FR_CS_CONV_REGISTER_19 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_REGISTER_19_DATA_MASK_BV ,DATA_MASK_BV RESET:0x0"
          
          
group.long  0x3260++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_DITHER_REGISTER_0, FR_CS_CONV_DITHER_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_DITHER_REGISTER_0_ENABLE_DITHER ,ENABLE_DITHER RESET:0x0"
          
         hexmask.long 0x00 1.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_DITHER_REGISTER_0_DITHER_AMOUNT ,DITHER_AMOUNT RESET:0x0"
          
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_CS_CONV_DITHER_REGISTER_0_SHIFT_MODE ,SHIFT_MODE RESET:0x0"
          
          
group.long  0x3264++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_0, FR_DMA_WRITER_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_0_FORMAT ,FORMAT RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_0_SINGLE_FRAME ,SINGLE_FRAME RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_0_FRAME_WRITE_ON ,FRAME_WRITE_ON RESET:0x0"
          
          
         bitfld.long 0x00 11. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_0_AXI_XACT_COMP ,AXI_XACT_COMP RESET:0x0"
          
          
group.long  0x3268++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_1, FR_DMA_WRITER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_1_ACTIVE_WIDTH ,ACTIVE_WIDTH RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_1_ACTIVE_HEIGHT ,ACTIVE_HEIGHT RESET:0x0"
          
group.long  0x326c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_2, FR_DMA_WRITER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_2_BANK0_BASE ,BANK0_BASE RESET:0x0"
          
group.long  0x3270++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_3, FR_DMA_WRITER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_3_BANK1_BASE ,BANK1_BASE RESET:0x0"
          
group.long  0x3274++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_4, FR_DMA_WRITER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_4_BANK2_BASE ,BANK2_BASE RESET:0x0"
          
group.long  0x3278++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_5, FR_DMA_WRITER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_5_BANK3_BASE ,BANK3_BASE RESET:0x0"
          
group.long  0x327c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_6, FR_DMA_WRITER_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_6_BANK4_BASE ,BANK4_BASE RESET:0x0"
          
group.long  0x3280++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_7, FR_DMA_WRITER_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_7_MAX_BANK ,MAX_BANK RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_7_BANK0_RESTART ,BANK0_RESTART RESET:0x0"
          
          
group.long  0x3284++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_8, FR_DMA_WRITER_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_8_LINE_OFFSET ,LINE_OFFSET RESET:0x0"
          
group.long  0x3288++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_9, FR_DMA_WRITER_REGISTER_9 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_9_WBANK_ACTIVE ,WBANK_ACTIVE RESET:0x0"
          
         hexmask.long 0x00 1.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_9_WBANK_CURR ,WBANK_CURR RESET:0x0"
          
          
rgroup.long 0x3294++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_10, FR_DMA_WRITER_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_10_FRAME_ICOUNT ,FRAME_ICOUNT RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_10_FRAME_WCOUNT ,FRAME_WCOUNT RESET:0x0"
          
group.long  0x329c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_11, FR_DMA_WRITER_REGISTER_11 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_11_AXI_FAIL_BRESP ,AXI_FAIL_BRESP RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_11_AXI_FAIL_AWMAXWAIT ,AXI_FAIL_AWMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_11_AXI_FAIL_WMAXWAIT ,AXI_FAIL_WMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_11_AXI_FAIL_WXACT_OSTAND ,AXI_FAIL_WXACT_OSTAND RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_WIDTH ,VI_FAIL_ACTIVE_WIDTH RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_HEIGHT ,VI_FAIL_ACTIVE_HEIGHT RESET:0x0"
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_11_VI_FAIL_INTERLINE_BLANKS ,VI_FAIL_INTERLINE_BLANKS RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_11_VI_FAIL_INTERFRAME_BLANKS ,VI_FAIL_INTERFRAME_BLANKS RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_11_VIDEO_ALARM ,VIDEO_ALARM RESET:0x0"
          
          
rgroup.long 0x32a0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_12, FR_DMA_WRITER_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_12_BLK_STATUS ,BLK_STATUS RESET:0x0"
          
group.long  0x32a4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_13, FR_DMA_WRITER_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_13_LINES_WRAPPED ,LINES_WRAPPED RESET:0x0"
          
          
group.long  0x32a8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_14, FR_DMA_WRITER_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_14_LINETICK_FIRST ,LINETICK_FIRST RESET:0x0"
          
          
group.long  0x32ac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_15, FR_DMA_WRITER_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_15_LINETICK_REPEAT ,LINETICK_REPEAT RESET:0x0"
          
          
group.long  0x32b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_16, FR_DMA_WRITER_REGISTER_16 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_16_LINETICK_EOL ,LINETICK_EOL RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_16_LINETICK_DELAY ,LINETICK_DELAY RESET:0x0"
          
group.long  0x32b4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_17, FR_DMA_WRITER_REGISTER_17 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_17_PAGEWARM_ON ,PAGEWARM_ON RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_17_AXI_ID_MULTI ,AXI_ID_MULTI RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_17_AXI_BURSTSPLIT ,AXI_BURSTSPLIT RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_17_AXI_CACHE_VALUE ,AXI_CACHE_VALUE RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_17_AXI_MAXOSTAND ,AXI_MAXOSTAND RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_17_AXI_MAX_AWLEN ,AXI_MAX_AWLEN RESET:0x0"
          
          
group.long  0x32b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_18, FR_DMA_WRITER_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_DMA_WRITER_REGISTER_18_AXI_ID_VALUE ,AXI_ID_VALUE RESET:0x0"
          
          
group.long  0x32bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_0, FR_UV_DMA_WRITER_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_0_FORMAT ,FORMAT RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_0_SINGLE_FRAME ,SINGLE_FRAME RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_0_FRAME_WRITE_ON ,FRAME_WRITE_ON RESET:0x0"
          
          
         bitfld.long 0x00 11. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_0_AXI_XACT_COMP ,AXI_XACT_COMP RESET:0x0"
          
          
group.long  0x32c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_1, FR_UV_DMA_WRITER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_1_ACTIVE_WIDTH ,ACTIVE_WIDTH RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_1_ACTIVE_HEIGHT ,ACTIVE_HEIGHT RESET:0x0"
          
group.long  0x32c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_2, FR_UV_DMA_WRITER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_2_BANK0_BASE ,BANK0_BASE RESET:0x0"
          
group.long  0x32c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_3, FR_UV_DMA_WRITER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_3_BANK1_BASE ,BANK1_BASE RESET:0x0"
          
group.long  0x32cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_4, FR_UV_DMA_WRITER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_4_BANK2_BASE ,BANK2_BASE RESET:0x0"
          
group.long  0x32d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_5, FR_UV_DMA_WRITER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_5_BANK3_BASE ,BANK3_BASE RESET:0x0"
          
group.long  0x32d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_6, FR_UV_DMA_WRITER_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_6_BANK4_BASE ,BANK4_BASE RESET:0x0"
          
group.long  0x32d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_7, FR_UV_DMA_WRITER_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_7_MAX_BANK ,MAX_BANK RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_7_BANK0_RESTART ,BANK0_RESTART RESET:0x0"
          
          
group.long  0x32dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_8, FR_UV_DMA_WRITER_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_8_LINE_OFFSET ,LINE_OFFSET RESET:0x0"
          
group.long  0x32e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_9, FR_UV_DMA_WRITER_REGISTER_9 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_9_WBANK_ACTIVE ,WBANK_ACTIVE RESET:0x0"
          
         hexmask.long 0x00 1.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_9_WBANK_CURR ,WBANK_CURR RESET:0x0"
          
          
rgroup.long 0x32ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_10, FR_UV_DMA_WRITER_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_10_FRAME_ICOUNT ,FRAME_ICOUNT RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_10_FRAME_WCOUNT ,FRAME_WCOUNT RESET:0x0"
          
group.long  0x32f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_11, FR_UV_DMA_WRITER_REGISTER_11 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_BRESP ,AXI_FAIL_BRESP RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_AWMAXWAIT ,AXI_FAIL_AWMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_WMAXWAIT ,AXI_FAIL_WMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_WXACT_OSTAND ,AXI_FAIL_WXACT_OSTAND RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_WIDTH ,VI_FAIL_ACTIVE_WIDTH RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_HEIGHT ,VI_FAIL_ACTIVE_HEIGHT RESET:0x0"
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_11_VI_FAIL_INTERLINE_BLANKS ,VI_FAIL_INTERLINE_BLANKS RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_11_VI_FAIL_INTERFRAME_BLANKS ,VI_FAIL_INTERFRAME_BLANKS RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_11_VIDEO_ALARM ,VIDEO_ALARM RESET:0x0"
          
          
rgroup.long 0x32f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_12, FR_UV_DMA_WRITER_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_12_BLK_STATUS ,BLK_STATUS RESET:0x0"
          
group.long  0x32fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_13, FR_UV_DMA_WRITER_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_13_LINES_WRAPPED ,LINES_WRAPPED RESET:0x0"
          
          
group.long  0x3300++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_14, FR_UV_DMA_WRITER_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_14_LINETICK_FIRST ,LINETICK_FIRST RESET:0x0"
          
          
group.long  0x3304++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_15, FR_UV_DMA_WRITER_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_15_LINETICK_REPEAT ,LINETICK_REPEAT RESET:0x0"
          
          
group.long  0x3308++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_16, FR_UV_DMA_WRITER_REGISTER_16 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_16_LINETICK_EOL ,LINETICK_EOL RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_16_LINETICK_DELAY ,LINETICK_DELAY RESET:0x0"
          
group.long  0x330c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_17, FR_UV_DMA_WRITER_REGISTER_17 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_17_PAGEWARM_ON ,PAGEWARM_ON RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_17_AXI_ID_MULTI ,AXI_ID_MULTI RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_17_AXI_BURSTSPLIT ,AXI_BURSTSPLIT RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_17_AXI_CACHE_VALUE ,AXI_CACHE_VALUE RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_17_AXI_MAXOSTAND ,AXI_MAXOSTAND RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_17_AXI_MAX_AWLEN ,AXI_MAX_AWLEN RESET:0x0"
          
          
group.long  0x3310++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_18, FR_UV_DMA_WRITER_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_FR_UV_DMA_WRITER_REGISTER_18_AXI_ID_VALUE ,AXI_ID_VALUE RESET:0x0"
          
          
group.long  0x3314++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CROP_REGISTER_0, DS_CROP_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CROP_REGISTER_0_ENABLE_CROP ,ENABLE_CROP RESET:0x0"
          
          
group.long  0x3318++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CROP_REGISTER_1, DS_CROP_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CROP_REGISTER_1_START_X ,START_X RESET:0x0"
          
          
group.long  0x331c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CROP_REGISTER_2, DS_CROP_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CROP_REGISTER_2_START_Y ,START_Y RESET:0x0"
          
          
group.long  0x3320++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CROP_REGISTER_3, DS_CROP_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CROP_REGISTER_3_SIZE_X ,SIZE_X RESET:0x0"
          
          
group.long  0x3324++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CROP_REGISTER_4, DS_CROP_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CROP_REGISTER_4_SIZE_Y ,SIZE_Y RESET:0x0"
          
          
group.long  0x332c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_0, DS_SCALER_REGISTER_0 RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_0_TIMEOUT_ENABLE ,TIMEOUT_ENABLE RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_0_TIMEOUT_VALUE ,TIMEOUT_VALUE RESET:0x0"
          
group.long  0x3330++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_1, DS_SCALER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_1_WIDTH ,WIDTH RESET:0x0"
          
          
group.long  0x3334++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_2, DS_SCALER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_2_HEIGHT ,HEIGHT RESET:0x0"
          
          
group.long  0x3338++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_3, DS_SCALER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_3_OWIDTH ,OWIDTH RESET:0x0"
          
          
group.long  0x333c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_4, DS_SCALER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_4_OHEIGHT ,OHEIGHT RESET:0x0"
          
          
group.long  0x3340++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_5, DS_SCALER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_5_HFILT_TINC ,HFILT_TINC RESET:0x0"
          
          
group.long  0x3344++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_6, DS_SCALER_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_6_HFILT_COEFSET ,HFILT_COEFSET RESET:0x0"
          
          
group.long  0x3348++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_7, DS_SCALER_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_7_VFILT_TINC ,VFILT_TINC RESET:0x0"
          
          
group.long  0x334c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_8, DS_SCALER_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SCALER_REGISTER_8_VFILT_COEFSET ,VFILT_COEFSET RESET:0x0"
          
          
group.long  0x3350++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_GAMMA_RGB_REGISTER_0, DS_GAMMA_RGB_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_GAMMA_RGB_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
          
group.long  0x3354++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_GAMMA_RGB_REGISTER_1, DS_GAMMA_RGB_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_GAMMA_RGB_REGISTER_1_GAIN_R ,GAIN_R RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_GAMMA_RGB_REGISTER_1_GAIN_G ,GAIN_G RESET:0x0"
          
          
group.long  0x3358++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_GAMMA_RGB_REGISTER_2, DS_GAMMA_RGB_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_GAMMA_RGB_REGISTER_2_GAIN_B ,GAIN_B RESET:0x0"
          
          
group.long  0x335c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_GAMMA_RGB_REGISTER_3, DS_GAMMA_RGB_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_GAMMA_RGB_REGISTER_3_OFFSET_R ,OFFSET_R RESET:0x0"
          
          
         hexmask.long 0x00 16.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_GAMMA_RGB_REGISTER_3_OFFSET_G ,OFFSET_G RESET:0x0"
          
          
group.long  0x3360++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_GAMMA_RGB_REGISTER_4, DS_GAMMA_RGB_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_GAMMA_RGB_REGISTER_4_OFFSET_B ,OFFSET_B RESET:0x0"
          
          
group.long  0x3364++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_0, DS_SHARPEN_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_0_ENABLE ,ENABLE RESET:0x0"
          
          
group.long  0x3368++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_1, DS_SHARPEN_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_1_STRENGTH ,STRENGTH RESET:0x0"
          
          
group.long  0x336c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_2, DS_SHARPEN_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_2_CONTROL_R ,CONTROL_R RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_2_CONTROL_B ,CONTROL_B RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_2_ALPHA_UNDERSHOOT ,ALPHA_UNDERSHOOT RESET:0x0"
          
          
group.long  0x3370++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_3, DS_SHARPEN_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_3_LUMA_THRESH_LOW ,LUMA_THRESH_LOW RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_3_LUMA_OFFSET_LOW ,LUMA_OFFSET_LOW RESET:0x0"
          
          
group.long  0x3374++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_4, DS_SHARPEN_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_4_LUMA_SLOPE_LOW ,LUMA_SLOPE_LOW RESET:0x0"
          
         hexmask.long 0x00 16.--25. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_4_LUMA_THRESH_HIGH ,LUMA_THRESH_HIGH RESET:0x0"
          
          
group.long  0x3378++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_5, DS_SHARPEN_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_5_LUMA_OFFSET_HIGH ,LUMA_OFFSET_HIGH RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_5_LUMA_SLOPE_HIGH ,LUMA_SLOPE_HIGH RESET:0x0"
          
group.long  0x337c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_6, DS_SHARPEN_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_6_CLIP_STR_MAX ,CLIP_STR_MAX RESET:0x0"
          
          
         hexmask.long 0x00 16.--29. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_6_CLIP_STR_MIN ,CLIP_STR_MIN RESET:0x0"
          
          
group.long  0x3380++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_7, DS_SHARPEN_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_SHARPEN_REGISTER_7_DEBUG ,DEBUG RESET:0x0"
          
          
group.long  0x3384++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_0, DS_CS_CONV_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_0_ENABLE_MATRIX ,ENABLE_MATRIX RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_0_ENABLE_FILTER ,ENABLE_FILTER RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_0_ENABLE_HORIZONTAL_DOWNSAMPLE ,ENABLE_HORIZONTAL_DOWNSAMPLE RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_0_ENABLE_VERTICAL_DOWNSAMPLE ,ENABLE_VERTICAL_DOWNSAMPLE RESET:0x0"
          
          
group.long  0x3388++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_1, DS_CS_CONV_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_1_COEFFT_11 ,COEFFT_11 RESET:0x0"
          
          
group.long  0x338c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_2, DS_CS_CONV_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_2_COEFFT_12 ,COEFFT_12 RESET:0x0"
          
          
group.long  0x3390++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_3, DS_CS_CONV_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_3_COEFFT_13 ,COEFFT_13 RESET:0x0"
          
          
group.long  0x3394++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_4, DS_CS_CONV_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_4_COEFFT_21 ,COEFFT_21 RESET:0x0"
          
          
group.long  0x3398++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_5, DS_CS_CONV_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_5_COEFFT_22 ,COEFFT_22 RESET:0x0"
          
          
group.long  0x339c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_6, DS_CS_CONV_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_6_COEFFT_23 ,COEFFT_23 RESET:0x0"
          
          
group.long  0x33a0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_7, DS_CS_CONV_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_7_COEFFT_31 ,COEFFT_31 RESET:0x0"
          
          
group.long  0x33a4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_8, DS_CS_CONV_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_8_COEFFT_32 ,COEFFT_32 RESET:0x0"
          
          
group.long  0x33a8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_9, DS_CS_CONV_REGISTER_9 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_9_COEFFT_33 ,COEFFT_33 RESET:0x0"
          
          
group.long  0x33ac++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_10, DS_CS_CONV_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_10_COEFFT_O1 ,COEFFT_O1 RESET:0x0"
          
          
group.long  0x33b0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_11, DS_CS_CONV_REGISTER_11 RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_11_COEFFT_O2 ,COEFFT_O2 RESET:0x0"
          
          
group.long  0x33b4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_12, DS_CS_CONV_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_12_COEFFT_O3 ,COEFFT_O3 RESET:0x0"
          
          
group.long  0x33b8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_13, DS_CS_CONV_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_13_CLIP_MIN_Y ,CLIP_MIN_Y RESET:0x0"
          
          
group.long  0x33bc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_14, DS_CS_CONV_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_14_CLIP_MAX_Y ,CLIP_MAX_Y RESET:0x0"
          
          
group.long  0x33c0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_15, DS_CS_CONV_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_15_CLIP_MIN_UV ,CLIP_MIN_UV RESET:0x0"
          
          
group.long  0x33c4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_16, DS_CS_CONV_REGISTER_16 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_16_CLIP_MAX_UV ,CLIP_MAX_UV RESET:0x0"
          
          
group.long  0x33c8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_17, DS_CS_CONV_REGISTER_17 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_17_DATA_MASK_RY ,DATA_MASK_RY RESET:0x0"
          
          
group.long  0x33cc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_18, DS_CS_CONV_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_18_DATA_MASK_GU ,DATA_MASK_GU RESET:0x0"
          
          
group.long  0x33d0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_19, DS_CS_CONV_REGISTER_19 RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_REGISTER_19_DATA_MASK_BV ,DATA_MASK_BV RESET:0x0"
          
          
group.long  0x33d4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_DITHER_REGISTER_0, DS_CS_CONV_DITHER_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_DITHER_REGISTER_0_ENABLE_DITHER ,ENABLE_DITHER RESET:0x0"
          
         hexmask.long 0x00 1.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_DITHER_REGISTER_0_DITHER_AMOUNT ,DITHER_AMOUNT RESET:0x0"
          
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_CS_CONV_DITHER_REGISTER_0_SHIFT_MODE ,SHIFT_MODE RESET:0x0"
          
          
group.long  0x33d8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_0, DS_DMA_WRITER_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_0_FORMAT ,FORMAT RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_0_SINGLE_FRAME ,SINGLE_FRAME RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_0_FRAME_WRITE_ON ,FRAME_WRITE_ON RESET:0x0"
          
          
         bitfld.long 0x00 11. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_0_AXI_XACT_COMP ,AXI_XACT_COMP RESET:0x0"
          
          
group.long  0x33dc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_1, DS_DMA_WRITER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_1_ACTIVE_WIDTH ,ACTIVE_WIDTH RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_1_ACTIVE_HEIGHT ,ACTIVE_HEIGHT RESET:0x0"
          
group.long  0x33e0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_2, DS_DMA_WRITER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_2_BANK0_BASE ,BANK0_BASE RESET:0x0"
          
group.long  0x33e4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_3, DS_DMA_WRITER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_3_BANK1_BASE ,BANK1_BASE RESET:0x0"
          
group.long  0x33e8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_4, DS_DMA_WRITER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_4_BANK2_BASE ,BANK2_BASE RESET:0x0"
          
group.long  0x33ec++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_5, DS_DMA_WRITER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_5_BANK3_BASE ,BANK3_BASE RESET:0x0"
          
group.long  0x33f0++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_6, DS_DMA_WRITER_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_6_BANK4_BASE ,BANK4_BASE RESET:0x0"
          
group.long  0x33f4++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_7, DS_DMA_WRITER_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_7_MAX_BANK ,MAX_BANK RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_7_BANK0_RESTART ,BANK0_RESTART RESET:0x0"
          
          
group.long  0x33f8++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_8, DS_DMA_WRITER_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_8_LINE_OFFSET ,LINE_OFFSET RESET:0x0"
          
group.long  0x33fc++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_9, DS_DMA_WRITER_REGISTER_9 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_9_WBANK_ACTIVE ,WBANK_ACTIVE RESET:0x0"
          
         hexmask.long 0x00 1.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_9_WBANK_CURR ,WBANK_CURR RESET:0x0"
          
          
rgroup.long 0x3408++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_10, DS_DMA_WRITER_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_10_FRAME_ICOUNT ,FRAME_ICOUNT RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_10_FRAME_WCOUNT ,FRAME_WCOUNT RESET:0x0"
          
group.long  0x3410++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_11, DS_DMA_WRITER_REGISTER_11 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_11_AXI_FAIL_BRESP ,AXI_FAIL_BRESP RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_11_AXI_FAIL_AWMAXWAIT ,AXI_FAIL_AWMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_11_AXI_FAIL_WMAXWAIT ,AXI_FAIL_WMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_11_AXI_FAIL_WXACT_OSTAND ,AXI_FAIL_WXACT_OSTAND RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_WIDTH ,VI_FAIL_ACTIVE_WIDTH RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_HEIGHT ,VI_FAIL_ACTIVE_HEIGHT RESET:0x0"
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_11_VI_FAIL_INTERLINE_BLANKS ,VI_FAIL_INTERLINE_BLANKS RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_11_VI_FAIL_INTERFRAME_BLANKS ,VI_FAIL_INTERFRAME_BLANKS RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_11_VIDEO_ALARM ,VIDEO_ALARM RESET:0x0"
          
          
rgroup.long 0x3414++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_12, DS_DMA_WRITER_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_12_BLK_STATUS ,BLK_STATUS RESET:0x0"
          
group.long  0x3418++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_13, DS_DMA_WRITER_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_13_LINES_WRAPPED ,LINES_WRAPPED RESET:0x0"
          
          
group.long  0x341c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_14, DS_DMA_WRITER_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_14_LINETICK_FIRST ,LINETICK_FIRST RESET:0x0"
          
          
group.long  0x3420++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_15, DS_DMA_WRITER_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_15_LINETICK_REPEAT ,LINETICK_REPEAT RESET:0x0"
          
          
group.long  0x3424++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_16, DS_DMA_WRITER_REGISTER_16 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_16_LINETICK_EOL ,LINETICK_EOL RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_16_LINETICK_DELAY ,LINETICK_DELAY RESET:0x0"
          
group.long  0x3428++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_17, DS_DMA_WRITER_REGISTER_17 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_17_PAGEWARM_ON ,PAGEWARM_ON RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_17_AXI_ID_MULTI ,AXI_ID_MULTI RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_17_AXI_BURSTSPLIT ,AXI_BURSTSPLIT RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_17_AXI_CACHE_VALUE ,AXI_CACHE_VALUE RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_17_AXI_MAXOSTAND ,AXI_MAXOSTAND RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_17_AXI_MAX_AWLEN ,AXI_MAX_AWLEN RESET:0x0"
          
          
group.long  0x342c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_18, DS_DMA_WRITER_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_DMA_WRITER_REGISTER_18_AXI_ID_VALUE ,AXI_ID_VALUE RESET:0x0"
          
          
group.long  0x3430++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_0, DS_UV_DMA_WRITER_REGISTER_0 RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_0_FORMAT ,FORMAT RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_0_SINGLE_FRAME ,SINGLE_FRAME RESET:0x0"
          
         bitfld.long 0x00 9. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_0_FRAME_WRITE_ON ,FRAME_WRITE_ON RESET:0x0"
          
          
         bitfld.long 0x00 11. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_0_AXI_XACT_COMP ,AXI_XACT_COMP RESET:0x0"
          
          
group.long  0x3434++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_1, DS_UV_DMA_WRITER_REGISTER_1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_1_ACTIVE_WIDTH ,ACTIVE_WIDTH RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_1_ACTIVE_HEIGHT ,ACTIVE_HEIGHT RESET:0x0"
          
group.long  0x3438++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_2, DS_UV_DMA_WRITER_REGISTER_2 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_2_BANK0_BASE ,BANK0_BASE RESET:0x0"
          
group.long  0x343c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_3, DS_UV_DMA_WRITER_REGISTER_3 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_3_BANK1_BASE ,BANK1_BASE RESET:0x0"
          
group.long  0x3440++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_4, DS_UV_DMA_WRITER_REGISTER_4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_4_BANK2_BASE ,BANK2_BASE RESET:0x0"
          
group.long  0x3444++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_5, DS_UV_DMA_WRITER_REGISTER_5 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_5_BANK3_BASE ,BANK3_BASE RESET:0x0"
          
group.long  0x3448++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_6, DS_UV_DMA_WRITER_REGISTER_6 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_6_BANK4_BASE ,BANK4_BASE RESET:0x0"
          
group.long  0x344c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_7, DS_UV_DMA_WRITER_REGISTER_7 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_7_MAX_BANK ,MAX_BANK RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_7_BANK0_RESTART ,BANK0_RESTART RESET:0x0"
          
          
group.long  0x3450++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_8, DS_UV_DMA_WRITER_REGISTER_8 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_8_LINE_OFFSET ,LINE_OFFSET RESET:0x0"
          
group.long  0x3454++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_9, DS_UV_DMA_WRITER_REGISTER_9 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_9_WBANK_ACTIVE ,WBANK_ACTIVE RESET:0x0"
          
         hexmask.long 0x00 1.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_9_WBANK_CURR ,WBANK_CURR RESET:0x0"
          
          
rgroup.long 0x3460++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_10, DS_UV_DMA_WRITER_REGISTER_10 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_10_FRAME_ICOUNT ,FRAME_ICOUNT RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_10_FRAME_WCOUNT ,FRAME_WCOUNT RESET:0x0"
          
group.long  0x3468++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_11, DS_UV_DMA_WRITER_REGISTER_11 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_BRESP ,AXI_FAIL_BRESP RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_AWMAXWAIT ,AXI_FAIL_AWMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 2. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_WMAXWAIT ,AXI_FAIL_WMAXWAIT RESET:0x0"
          
         bitfld.long 0x00 3. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_11_AXI_FAIL_WXACT_OSTAND ,AXI_FAIL_WXACT_OSTAND RESET:0x0"
          
         bitfld.long 0x00 4. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_WIDTH ,VI_FAIL_ACTIVE_WIDTH RESET:0x0"
          
         bitfld.long 0x00 5. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_11_VI_FAIL_ACTIVE_HEIGHT ,VI_FAIL_ACTIVE_HEIGHT RESET:0x0"
          
         bitfld.long 0x00 6. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_11_VI_FAIL_INTERLINE_BLANKS ,VI_FAIL_INTERLINE_BLANKS RESET:0x0"
          
         bitfld.long 0x00 7. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_11_VI_FAIL_INTERFRAME_BLANKS ,VI_FAIL_INTERFRAME_BLANKS RESET:0x0"
          
         bitfld.long 0x00 8. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_11_VIDEO_ALARM ,VIDEO_ALARM RESET:0x0"
          
          
rgroup.long 0x346c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_12, DS_UV_DMA_WRITER_REGISTER_12 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_12_BLK_STATUS ,BLK_STATUS RESET:0x0"
          
group.long  0x3470++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_13, DS_UV_DMA_WRITER_REGISTER_13 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_13_LINES_WRAPPED ,LINES_WRAPPED RESET:0x0"
          
          
group.long  0x3474++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_14, DS_UV_DMA_WRITER_REGISTER_14 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_14_LINETICK_FIRST ,LINETICK_FIRST RESET:0x0"
          
          
group.long  0x3478++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_15, DS_UV_DMA_WRITER_REGISTER_15 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_15_LINETICK_REPEAT ,LINETICK_REPEAT RESET:0x0"
          
          
group.long  0x347c++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_16, DS_UV_DMA_WRITER_REGISTER_16 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_16_LINETICK_EOL ,LINETICK_EOL RESET:0x0"
          
          
         hexmask.long 0x00 16.--31. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_16_LINETICK_DELAY ,LINETICK_DELAY RESET:0x0"
          
group.long  0x3480++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_17, DS_UV_DMA_WRITER_REGISTER_17 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_17_PAGEWARM_ON ,PAGEWARM_ON RESET:0x0"
          
         bitfld.long 0x00 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_17_AXI_ID_MULTI ,AXI_ID_MULTI RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_17_AXI_BURSTSPLIT ,AXI_BURSTSPLIT RESET:0x0"
          
          
         hexmask.long 0x00 8.--11. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_17_AXI_CACHE_VALUE ,AXI_CACHE_VALUE RESET:0x0"
          
          
         hexmask.long 0x00 16.--23. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_17_AXI_MAXOSTAND ,AXI_MAXOSTAND RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_17_AXI_MAX_AWLEN ,AXI_MAX_AWLEN RESET:0x0"
          
          
group.long  0x3484++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_18, DS_UV_DMA_WRITER_REGISTER_18 RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_DS_UV_DMA_WRITER_REGISTER_18_AXI_ID_VALUE ,AXI_ID_VALUE RESET:0x0"
          
          
group.long  0x3488++0x3
    line.long 0x00 "MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MULTI_CTX_REGISTER_0, MULTI_CTX_REGISTER_0 RESET:0x0"
         bitfld.long 0x00 0. " MALIC55_IP_CONFIG_TOP_ISP_CONFIG_PONG_MULTI_CTX_REGISTER_0_CONFIG_DONE ,CONFIG_DONE RESET:0x0"
          
          
tree.end

tree "ETHERNET_TSN_SW"
base e:0x40200000
width 80.
group.long  0x4++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LU_MAIN_CTRL, LU_MAIN control register (CENTRAL/LOOKUP/LU_MAIN) RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_LU_MAIN_CTRL_BYP_EN ,MAC Lookup bypass. When enabled, all frames are forwarded with the information of the BYPASS register. RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_TSN_SW_LU_MAIN_CTRL_STC_EN ,Send unknown SRC-MAC Frames to CPU-Port. (0 for disable, 1 for enable) RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LU_MAIN_HITMEM, LU_MAIN hit memory register (CENTRAL/LOOKUP/LU_MAIN) RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_LU_MAIN_HITMEM_CLR ,Clears the hit memory. The asserted bit is cleared automatically after the clear is forwarded to the hit memory. The clearing will take some additional time. RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_TSN_SW_LU_MAIN_HITMEM_DM_EN ,Select Hitmem MAC type: (0) Source MAC Address (1) Destination MAC address. RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LU_MAIN_BYPASS, LU_MAIN bypass register (CENTRAL/LOOKUP/LU_MAIN) RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETHERNET_TSN_SW_LU_MAIN_BYPASS_DEST ,Target destination port of frame. Mark port via bit-selection. Multiple ports can be selected. LSB is CPU Port (Port0). Bypass is only for testing without CAM and does not support DESTE field. RESET:0x0"
          
rgroup.long 0x100++0x3
    line.long 0x00 "ETHERNET_TSN_SW_CAM_APB2AXIS_STS, CAM APB2AXIS Status Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_CAM_APB2AXIS_STS_RDY ,Ready = '1' signalizes that new data can be written to DATA registers RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_TSN_SW_CAM_APB2AXIS_STS_BUSY ,Busy signalizes that the controller is writing data and/or data is pending. The controller can be ready to take more data also when it is busy. RESET:0x0"
          
rgroup.long 0x110++0x3
    line.long 0x00 "ETHERNET_TSN_SW_CAM_APB2AXIS_REQ_CNT, CAM APB2AXIS Request Count Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_CAM_APB2AXIS_REQ_CNT_WRCNT ,Number of streams in queue. CNT is always <= PARAM.DEPTH. RESET:0x0"
          
rgroup.long 0x114++0x3
    line.long 0x00 "ETHERNET_TSN_SW_CAM_APB2AXIS_FILLSTS, CAM APB2AXIS FILL STATUS Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_CAM_APB2AXIS_FILLSTS_EMPTY ,FD FIFO failure. Internal controller lost synchronization. RESET:0x0"
          
         bitfld.long 0x00 4. " ETHERNET_TSN_SW_CAM_APB2AXIS_FILLSTS_FULL ,Frame was dropped because the internal descriptor FIFO is full. Full by too many frames. RESET:0x0"
          
group.long  0x118++0x3
    line.long 0x00 "ETHERNET_TSN_SW_CAM_APB2AXIS_RESET, CAM APB2AXIS RESET Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_CAM_APB2AXIS_RESET_RESET ,Resets controller and clears all pending stream data. Bit is automatically reset to 0. RESET:0x0"
          
rgroup.long 0x11c++0x3
    line.long 0x00 "ETHERNET_TSN_SW_CAM_APB2AXIS_PARAM, CAM APB2AXIS Parameter Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_CAM_APB2AXIS_PARAM_WORDLEN_BYTE ,Number of configured 32-bit-words for this controller. RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETHERNET_TSN_SW_CAM_APB2AXIS_PARAM_DEPTH ,Number of configured buffer depth. If number is bigger than one then an internal FIFO is included. RESET:0x0"
          
group.long  0x120++0x3
    line.long 0x00 "ETHERNET_TSN_SW_CAM_APB2AXIS_REQ_DATA_0, CAM APB2AXIS Request Data 0 Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_CAM_APB2AXIS_REQ_DATA_0_CH ,CAM APB2AXIS channel selection. Always 0 for writing to DEST_MAC table. RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " ETHERNET_TSN_SW_CAM_APB2AXIS_REQ_DATA_0_TYPE ,Select between set, clear or clear all: 00 – unused 01 – Set one DEST_MAC entry 10 – Clear one DEST_MAC entry 11 – Clear multiple entries (advanced user only) RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ETHERNET_TSN_SW_CAM_APB2AXIS_REQ_DATA_0_ENTRY_NUM ,Entry number in ALMEM. The ALMEM[ENTRY_NUM] holding the routing information for the DESTMAC and VID. Value greater than the maximum entry number is not allowed. RESET:0x0"
          
group.long  0x124++0x3
    line.long 0x00 "ETHERNET_TSN_SW_CAM_APB2AXIS_REQ_DATA_1, CAM APB2AXIS Request Data 1 Register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHERNET_TSN_SW_CAM_APB2AXIS_REQ_DATA_1_DESTMAC ,Holding the first four bytes of the destination MAC for the DEST_MAC table. RESET:0x0"
          
group.long  0x128++0x3
    line.long 0x00 "ETHERNET_TSN_SW_CAM_APB2AXIS_REQ_DATA_2, CAM APB2AXIS Request Data 2 Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETHERNET_TSN_SW_CAM_APB2AXIS_REQ_DATA_2_DEST_MAC_47_32 ,Holding the last two bytes of the destination MAC. RESET:0x0"
          
         hexmask.long 0x00 16.--27. 1. " ETHERNET_TSN_SW_CAM_APB2AXIS_REQ_DATA_2_VID ,VLAN-ID value (12 bit) for the VLAN_ID table. Use the default VLAN-ID (VID=1), if setup an entry for non-VLAN traffic. RESET:0x0"
          
rgroup.long 0x200++0x3
    line.long 0x00 "ETHERNET_TSN_SW_ALMEM_APB2AXIS_STS, ALMEM APB2AXIS Status Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_STS_RDY ,Ready = '1' signalizes that new data can be written to DATA registers. RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_STS_BUSY ,Busy signalizes that the controller is writing data and/or data is pending. The controller can be ready to take more data also when it is busy. RESET:0x0"
          
rgroup.long 0x210++0x3
    line.long 0x00 "ETHERNET_TSN_SW_ALMEM_APB2AXIS_REQ_CNT, ALMEM APB2AXIS Request Count Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_REQ_CNT_WRCNT ,Number of streams in queue. CNT is always <= PARAM.DEPTH. RESET:0x0"
          
rgroup.long 0x214++0x3
    line.long 0x00 "ETHERNET_TSN_SW_ALMEM_APB2AXIS_FILLSTS, ALMEM APB2AXIS FILL STATUS Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_FILLSTS_EMPTY ,FD FIFO failure. Internal controller lost synchronization. RESET:0x0"
          
         bitfld.long 0x00 4. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_FILLSTS_FULL ,Frame was dropped because the internal descriptor FIFO is full. Full by too many frames. RESET:0x0"
          
group.long  0x218++0x3
    line.long 0x00 "ETHERNET_TSN_SW_ALMEM_APB2AXIS_RESET, ALMEM APB2AXIS RESET Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_RESET_RESET ,Resets controller and clears all pending stream data. Bit is automatically reset to 0. RESET:0x0"
          
rgroup.long 0x21c++0x3
    line.long 0x00 "ETHERNET_TSN_SW_ALMEM_APB2AXIS_PARAM, ALMEM APB2AXIS Parameter Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_PARAM_WORDLEN_BYTE ,Number of configured 32-bit-words for this controller. RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_PARAM_DEPTH ,Number of configured buffer depth. If number is bigger than one then an internal FIFO is included. RESET:0x0"
          
group.long  0x220++0x3
    line.long 0x00 "ETHERNET_TSN_SW_ALMEM_APB2AXIS_REQ_DATA_0, ALMEM APB2AXIS Request Data 0 Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_REQ_DATA_0_DEST ,Select the destination ports of forwarded frame. It is coded in onehot/select way, where 0 is always route to null. For 5 ports DEST[4:0] is sufficient. 00000 – to null (frame to clear) 00001 – to port 0 (CPU Port) 00010 – to port 1 00110 – to port 1&2 10000 – to port 4 RESET:0x0"
          
         hexmask.long 0x00 16.--18. 1. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_REQ_DATA_0_QUEUE ,Select the Priority Queue for TSN TX, only used if QSEL=11 RESET:0x0"
          
         bitfld.long 0x00 19. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_REQ_DATA_0_DROP ,1 if frame should be dropped. RESET:0x0"
          
         hexmask.long 0x00 20.--21. 1. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_REQ_DATA_0_QSEL ,Define the traffic queue selection: 00 – use PCP field of VLAN, untagged frames use PCP of PVID 01 – use PCP field with global remapping list 10 – reserved. (like ‘11’) 11 – use value QUEUE of Action List RESET:0x0"
          
         hexmask.long 0x00 22.--24. 1. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_REQ_DATA_0_UTAG ,TSN-EP user sideband information. RESET:0x0"
          
group.long  0x224++0x3
    line.long 0x00 "ETHERNET_TSN_SW_ALMEM_APB2AXIS_REQ_DATA_1, ALMEM APB2AXIS Request Data 1 Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_REQ_DATA_1_ENTRY_NUM ,Define the entry number for reading or writing. RESET:0x0"
          
         hexmask.long 0x00 16.--24. 1. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_REQ_DATA_1_DESTE ,Extended Destination Register for forwarding ports from 16 to 24. RESET:0x0"
          
         bitfld.long 0x00 30. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_REQ_DATA_1_RESP ,If set then the command request will always return a response. A read response is also sent if register is not set. A write response can be useful to wait for the end of the last command in a write burst. RESET:0x0"
          
         bitfld.long 0x00 31. " ETHERNET_TSN_SW_ALMEM_APB2AXIS_REQ_DATA_1_WR_RD ,1 if writing to the ALMEM entry, 0 if reading from ALMEM entry. RESET:0x0"
          
rgroup.long 0x280++0x3
    line.long 0x00 "ETHERNET_TSN_SW_ALMEM_AXIS2APB_STS, ALMEM AXIS2APB Status Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_STS_RDY ,Ready = '1' signalizes that new data can be read from DATA registers. RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_STS_BUSY ,Busy signalizes that the controller is reading data and/or data is pending. The controller can be ready to take more data also when it is busy. RESET:0x0"
          
rgroup.long 0x290++0x3
    line.long 0x00 "ETHERNET_TSN_SW_ALMEM_AXIS2APB_REQ_CNT, ALMEM AXIS2APB Request Count Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_REQ_CNT_RDCNT ,Number of streams in queue. CNT is always <= PARAM.DEPTH. RESET:0x0"
          
rgroup.long 0x294++0x3
    line.long 0x00 "ETHERNET_TSN_SW_ALMEM_AXIS2APB_FILLSTS, ALMEM AXIS2APB FILL STATUS Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_FILLSTS_EMPTY ,FD FIFO failure. Internal controller lost synchronization. RESET:0x0"
          
         bitfld.long 0x00 4. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_FILLSTS_FULL ,Frame was dropped because the internal descriptor FIFO is full. Full by too many frames. RESET:0x0"
          
group.long  0x298++0x3
    line.long 0x00 "ETHERNET_TSN_SW_ALMEM_AXIS2APB_RESET, ALMEM AXIS2APB RESET Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_RESET_RESET ,Resets controller and clears all pending stream data. Bit is automatically reset to 0. RESET:0x0"
          
rgroup.long 0x29c++0x3
    line.long 0x00 "ETHERNET_TSN_SW_ALMEM_AXIS2APB_PARAM, ALMEM AXIS2APB Parameter Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_PARAM_WORDLEN_BYTE ,Number of configured 32-bit-words for this controller. RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_PARAM_DEPTH ,Number of configured buffer depth. If number is bigger than one then an internal FIFO is included. RESET:0x0"
          
rgroup.long 0x2a0++0x3
    line.long 0x00 "ETHERNET_TSN_SW_ALMEM_AXIS2APB_REQ_DATA_0, ALMEM AXIS2APB Request Data 0 Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_REQ_DATA_0_DEST ,Select the destination ports of forwarded frame. It is coded in onehot/select way, where 0 is always route to null. For 5 ports DEST[4:0] is sufficient. 00000 – to null (frame to clear) 00001 – to port 0 (CPU Port) 00010 – to port 1 00110 – to port 1&2 10000 – to port 4 RESET:0x0"
          
         hexmask.long 0x00 16.--18. 1. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_REQ_DATA_0_QUEUE ,Select the Priority Queue for TSN TX, only used if QSEL=11 RESET:0x0"
          
         bitfld.long 0x00 19. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_REQ_DATA_0_DROP ,1 if frame should be dropped. RESET:0x0"
          
         hexmask.long 0x00 20.--21. 1. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_REQ_DATA_0_QSEL ,Define the traffic queue selection: 00 – use PCP field of VLAN, untagged frames use PCP of PVID 01 – use PCP field with global remapping list 10 – reserved. (like ‘11’) 11 – use value QUEUE of Action List RESET:0x0"
          
         hexmask.long 0x00 22.--24. 1. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_REQ_DATA_0_UTAG ,TSN-EP user sideband information. RESET:0x0"
          
rgroup.long 0x2a4++0x3
    line.long 0x00 "ETHERNET_TSN_SW_ALMEM_AXIS2APB_REQ_DATA_1, ALMEM AXIS2APB Request Data 1 Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_REQ_DATA_1_ENTRY_NUM ,Define the entry number for reading or writing. RESET:0x0"
          
         hexmask.long 0x00 16.--24. 1. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_REQ_DATA_1_DESTE ,Extended Destination Register for forwarding ports from 16 to 24. RESET:0x0"
          
         bitfld.long 0x00 30. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_REQ_DATA_1_RESP ,If set then the command request will always return a response. A read response is also sent if register is not set. A write response can be useful to wait for the end of the last command in a write burst. RESET:0x0"
          
         bitfld.long 0x00 31. " ETHERNET_TSN_SW_ALMEM_AXIS2APB_REQ_DATA_1_WR_RD ,1 if writing to the ALMEM entry, 0 if reading from ALMEM entry. RESET:0x0"
          
rgroup.long 0x1000++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_APB2AXIS_STS, LOOKUP APB2AXIS Status Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_LOOKUP_APB2AXIS_STS_RDY ,Ready = '1' signalizes that new data can be written to DATA registers. RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_TSN_SW_LOOKUP_APB2AXIS_STS_BUSY ,Busy signalizes that the controller is writing data and/or data is pending. The controller can be ready to take more data also when it is busy. RESET:0x0"
          
rgroup.long 0x1010++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_APB2AXIS_REQ_CNT, LOOKUP APB2AXIS Request Count Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_LOOKUP_APB2AXIS_REQ_CNT_WRCNT ,Number of streams in queue. CNT is always <= PARAM.DEPTH. RESET:0x0"
          
rgroup.long 0x1014++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_APB2AXIS_FILLSTS, LOOKUP APB2AXIS FILL STATUS Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_LOOKUP_APB2AXIS_FILLSTS_EMPTY ,FD FIFO failure. Internal controller lost synchronization. RESET:0x0"
          
         bitfld.long 0x00 4. " ETHERNET_TSN_SW_LOOKUP_APB2AXIS_FILLSTS_FULL ,Frame was dropped because the internal descriptor FIFO is full. Full by too many frames. RESET:0x0"
          
group.long  0x1018++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_APB2AXIS_RESET, LOOKUP APB2AXIS RESET Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_LOOKUP_APB2AXIS_RESET_RESET ,Resets controller and clears all pending stream data. Bit is automatically reset to 0. RESET:0x0"
          
rgroup.long 0x101c++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_APB2AXIS_PARAM, LOOKUP APB2AXIS Parameter Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_LOOKUP_APB2AXIS_PARAM_WORDLEN_BYTE ,Number of configured 32-bit-words for this controller. RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETHERNET_TSN_SW_LOOKUP_APB2AXIS_PARAM_DEPTH ,Number of configured buffer depth. If number is bigger than one then an internal FIFO is included. RESET:0x0"
          
group.long  0x1020++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_APB2AXIS_REQ_DATA_0, LOOKUP APB2AXIS REQ Data 0 Register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHERNET_TSN_SW_LOOKUP_APB2AXIS_REQ_DATA_0_DESTMAC_31_0 ,Holding the first four bytes of requested MAC address. RESET:0x0"
          
group.long  0x1024++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_APB2AXIS_REQ_DATA_1, LOOKUP APB2AXIS REQ Data 1 Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETHERNET_TSN_SW_LOOKUP_APB2AXIS_REQ_DATA_1_DEST_MAC_47_32 ,Holding the last two bytes of the requested MAC address. RESET:0x0"
          
group.long  0x102c++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_APB2AXIS_REQ_DATA_3, LOOKUP APB2AXIS REQ Data 3 Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETHERNET_TSN_SW_LOOKUP_APB2AXIS_REQ_DATA_3_VLAN_TCI ,Set the requested traffic VLAN_TCI, if IS_VLAN=1. RESET:0x0"
          
         bitfld.long 0x00 16. " ETHERNET_TSN_SW_LOOKUP_APB2AXIS_REQ_DATA_3_IS_VLAN ,Tell the LOOKUP module the requested traffic is VLAN tagged. RESET:0x0"
          
rgroup.long 0x1080++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_AXIS2APB_STS, LOOKUP AXIS2APB Status Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_STS_RDY ,Ready = '1' signalizes that new data can be read from DATA registers. RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_STS_BUSY ,Busy signalizes that the controller is reading data and/or data is pending. The controller can be ready to take more data also when it is busy. RESET:0x0"
          
rgroup.long 0x1090++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_AXIS2APB_REQ_CNT, LOOKUP AXIS2APB Request Count Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_REQ_CNT_RDCNT ,Number of streams in queue. CNT is always <= PARAM.DEPTH. RESET:0x0"
          
rgroup.long 0x1094++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_AXIS2APB_FILLSTS, LOOKUP AXIS2APB FILL STATUS Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_FILLSTS_EMPTY ,FD FIFO failure. Internal controller lost synchronization. RESET:0x0"
          
         bitfld.long 0x00 4. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_FILLSTS_FULL ,Frame was dropped because the internal descriptor FIFO is full. Full by too many frames. RESET:0x0"
          
group.long  0x1098++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_AXIS2APB_RESET, LOOKUP AXIS2APB RESET Register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_RESET_RESET ,Resets controller and clears all pending stream data. Bit is automatically reset to 0. RESET:0x0"
          
rgroup.long 0x109c++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_AXIS2APB_PARAM, LOOKUP AXIS2APB Parameter Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_PARAM_WORDLEN_BYTE ,Number of configured 32-bit-words for this controller. RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_PARAM_DEPTH ,Number of configured buffer depth. If number is bigger than one then an internal FIFO is included. RESET:0x0"
          
group.long  0x10a0++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_AXIS2APB_RESP_DATA_0, LOOKUP AXIS2APB RESPONSE Data 0 Register LOOKUP Response Data only valid, if the HIT bit in RESP_DATA_0 is set. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_RESP_DATA_0_DEST ,Forwarding ports from 0 to 15, Bit 0 is CPU port. RESET:0x0"
          
         hexmask.long 0x00 16.--18. 1. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_RESP_DATA_0_QUEUE ,TX traffic queue selection. RESET:0x0"
          
         bitfld.long 0x00 19. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_RESP_DATA_0_DROP ,Indicate that the frame should be dropped. RESET:0x0"
          
         bitfld.long 0x00 20. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_RESP_DATA_0_HIT_VLAN ,Is 1, if VID hit entry in VLAN_PORT table. RESET:0x0"
          
         hexmask.long 0x00 21.--23. 1. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_RESP_DATA_0_UTAG ,TSN user sideband information from ALMEM. RESET:0x0"
          
         bitfld.long 0x00 24. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_RESP_DATA_0_HIT ,Is 1, if DESTMAC and VID hit an entry. RESET:0x0"
          
         bitfld.long 0x00 25. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_RESP_DATA_0_DROP_VLAN ,Used for statistics. Shows that drop occurs by VLAN-ID RESET:0x0"
          
group.long  0x10a4++0x3
    line.long 0x00 "ETHERNET_TSN_SW_LOOKUP_AXIS2APB_RESP_DATA_1, LOOKUP AXIS2APB RESPONSE Data 1 Register LOOKUP Response Data only valid, if the HIT bit in RESP_DATA_0 is set. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_RESP_DATA_1_ENTRY_NUM ,Entry number of ALMEM. RESET:0x0"
          
         hexmask.long 0x00 16.--24. 1. " ETHERNET_TSN_SW_LOOKUP_AXIS2APB_RESP_DATA_1_DESTE ,Extended Destination Register for forwarding ports from 16 to 24. RESET:0x0"
          
group.long  0x200c++0x3
    line.long 0x00 "ETHERNET_TSN_SW_CENTRAL_CSR_CP_PARAM, CSR CB parameter register (CENTRAL/CSR) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_CENTRAL_CSR_CP_PARAM_FRER_D ,Number of 802.1CB Stream Identification entries. 2^SID_D entries. RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETHERNET_TSN_SW_CENTRAL_CSR_CP_PARAM_SID_D ,Number of 802.1CB Recovery Function entries. 2^FRER_D entries. RESET:0x0"
          
group.long  0x2104++0x3
    line.long 0x00 "ETHERNET_TSN_SW_CENTRAL_QCI_HWCONFIG, HWCONFIG (CENTRAL/QCI) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_CENTRAL_QCI_HWCONFIG_FTD ,FDP parameter RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETHERNET_TSN_SW_CENTRAL_QCI_HWCONFIG_GTD ,GTD parameter RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " ETHERNET_TSN_SW_CENTRAL_QCI_HWCONFIG_FMD ,FMD parameter RESET:0x0"
          
group.long  0x20004++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_1_MACADDR_L, Lower bits of MAC address (port1) RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHERNET_TSN_SW_TSN_PORT_1_MACADDR_L_MACADDR ,MAC Address RESET:0x0"
          
group.long  0x20008++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_1_MACADDR_H, Upper bits of MAC address (port1) RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETHERNET_TSN_SW_TSN_PORT_1_MACADDR_H_MACADDR ,MAC Address RESET:0x0"
          
group.long  0x2000c++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_1_MAC_CTRL, MAC control register (port1) RESET:0x1800"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_TSN_PORT_1_MAC_CTRL_RESSTAT ,Software reset of statistic counters RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_TSN_SW_TSN_PORT_1_MAC_CTRL_RX_EN ,RX path enable RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_TSN_SW_TSN_PORT_1_MAC_CTRL_TX_EN ,TX path enable RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_TSN_SW_TSN_PORT_1_MAC_CTRL_JUMBO ,Jumbo frame support RESET:0x0"
          
         bitfld.long 0x00 4. " ETHERNET_TSN_SW_TSN_PORT_1_MAC_CTRL_GMIIMODE ,MII transmit mode RESET:0x0"
          
         hexmask.long 0x00 5.--6. 1. " ETHERNET_TSN_SW_TSN_PORT_1_MAC_CTRL_PHYSEL ,PHY selection RESET:0x0"
          
         hexmask.long 0x00 8.--10. 1. " ETHERNET_TSN_SW_TSN_PORT_1_MAC_CTRL_CLKSEL ,Clock selection RESET:0x0"
          
         bitfld.long 0x00 11. " ETHERNET_TSN_SW_TSN_PORT_1_MAC_CTRL_MCE ,Clock selection RESET:0x1"
          
         bitfld.long 0x00 12. " ETHERNET_TSN_SW_TSN_PORT_1_MAC_CTRL_RCE ,Ref clock enable RESET:0x1"
          
         bitfld.long 0x00 13. " ETHERNET_TSN_SW_TSN_PORT_1_MAC_CTRL_CSA ,Clock switching active RESET:0x0"
          
group.long  0x20020++0x3
    line.long 0x00 "ETHERNET_TSN_SW_MDIO_CFG, MDIO Configuration register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_MDIO_CFG_MDC_CLKDIV ,Clock Divider to configure MDC clock frequency. Refer to 10.1 Clock Divider for more details. RESET:0x0"
          
         bitfld.long 0x00 8. " ETHERNET_TSN_SW_MDIO_CFG_ENABLE ,Enable the MDIO controller. If the controller is enabled then MDC will be toggled.  ENABLE can only be read as 1 if a valid MDC_CLKDIV value is set. RESET:0x0"
          
         bitfld.long 0x00 15. " ETHERNET_TSN_SW_MDIO_CFG_NPRE ,No Preamble With NPRE=1 the preamble generation is suppressed and frames are initiated with Start of Frame pattern directly. Suitable in case that all connected PHYs accept management frames without a preamble pattern. Recommended to be used if only one PHY is connected. RESET:0x0"
          
group.long  0x20024++0x3
    line.long 0x00 "ETHERNET_TSN_SW_MDIO_CTRL, MDIO Control register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_MDIO_CTRL_READY ,READY=1 indicates a finished transfer and also shows that the controller is ready for a new transfer. READY=1 is only possible if ENABLE=1. If READY=1 is signaled after a read transfer, then RD_DATA is valid until a new transfer is started. RESET:0x0"
          
         bitfld.long 0x00 8. " ETHERNET_TSN_SW_MDIO_CTRL_INIT ,INIT=1 results in a MDIO write/read transfer if READY=1. If READY=0 while a transfer is already pending or if ENABLE=0 then settings INIT=1 has no effect and the current transaction is withdrawn. RESET:0x0"
          
         hexmask.long 0x00 16.--20. 1. " ETHERNET_TSN_SW_MDIO_CTRL_REGAD ,MODE=0 Management Frame Register Address. MODE=1 Management Frame Device (MMD) Address RESET:0x0"
          
         bitfld.long 0x00 21. " ETHERNET_TSN_SW_MDIO_CTRL_MODE ,Switch the MDIO frame format between clause 22 and clause 45 devices. 0 – clause 22 (typical for 10/100/1000 PHYs) 1 – clause 45 RESET:0x0"
          
         hexmask.long 0x00 24.--28. 1. " ETHERNET_TSN_SW_MDIO_CTRL_PHYAD ,Management Frame PHY Address. RESET:0x0"
          
         hexmask.long 0x00 30.--31. 1. " ETHERNET_TSN_SW_MDIO_CTRL_OP ,Opcode to determine transfer type If the frame format is based on Clause 22 MDIO (MODE=0) 01 – Write Access 10 – Read Access If the frame format is based on Clause 45 MDIO (MODE=1) 00 – Address Write Access on the address register 01 – Write Access at the address register location (MMD register bank) 11 – Read Access at the address register location (MMD register bank) 10 – Read Access at the address register location (MMD register bank) and increment address register after read. RESET:0x0"
          
rgroup.long 0x20028++0x3
    line.long 0x00 "ETHERNET_TSN_SW_MDIO_RD_DATA, MDIO Read Data register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_MDIO_RD_DATA_READ_DATA_1 ,Read Data is available if READY=1 after a transfer has been started. RD_DATA represents the content of the management data field of the read transfer. RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETHERNET_TSN_SW_MDIO_RD_DATA_READ_DATA_2 ,Read Data is available if READY=1 after a transfer has been started. RD_DATA represents the content of the management data field of the read transfer. RESET:0x0"
          
group.long  0x2002c++0x3
    line.long 0x00 "ETHERNET_TSN_SW_MDIO_WR_DATA, MDIO Write Data register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHERNET_TSN_SW_MDIO_WR_DATA_WRITE_DATA_1 ,Data is used for the management data field after a write transfer has been started. RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " ETHERNET_TSN_SW_MDIO_WR_DATA_WRITE_DATA_2 ,Data is used for the management data field after a write transfer has been started. RESET:0x0"
          
group.long  0x20030++0x3
    line.long 0x00 "ETHERNET_TSN_SW_IRQ_CTRL, Interrupt Request Control register RESET:0x0"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_IRQ_CTRL_MDIE ,MDIO Interrupt Enable 0 – Disabled 1 – Enabled RESET:0x0"
          
group.long  0x20800++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_1_RTC_CTRL_REG, RTC Control Register RESET:0x0"
         bitfld.long 0x00 1. " ETHERNET_TSN_SW_TSN_PORT_1_RTC_CTRL_REG_ALIE ,Alarm interrupt enable: alarm interrupt enabled when 1 RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_TSN_SW_TSN_PORT_1_RTC_CTRL_REG_TAEN ,Timer A enable: timer enabled when 1 RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_TSN_SW_TSN_PORT_1_RTC_CTRL_REG_TAIE ,Timer A interrupt enable: interrupt enabled when 1 RESET:0x0"
          
group.long  0x2081c++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_1_RTC_TIMER_INCREMENT, RTC Current timer increment RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETHERNET_TSN_SW_TSN_PORT_1_RTC_TIMER_INCREMENT_FNS ,Local time increment – fractional ns, unsigned, in (1 / 2^24) n RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " ETHERNET_TSN_SW_TSN_PORT_1_RTC_TIMER_INCREMENT_NS ,Local time increment – nanoseconds (integer) RESET:0x0"
          
group.long  0x22004++0x3
    line.long 0x00 "ETHERNET_TSN_SW_UNKNOWN_TODO_1, REG NOT FOUND TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHERNET_TSN_SW_UNKNOWN_TODO_1_TEMP ,TODO RESET:0x0"
          
group.long  0x34020++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_1_INGRESS_RX_FDFIFO_E_STRFWD, TSN_PORT_1 RX_FDFIFO STRFWD Register RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETHERNET_TSN_SW_TSN_PORT_1_INGRESS_RX_FDFIFO_E_STRFWD_PORT ,If selected port is set then the frame is transmitted in Store & Forward mode. This is necessary when the ingress rate of this port is slower than the egress rate of the transmitting port. In S&F, the ingress module is able to drop frames with bad CRC. bit 0 - CPU-Port, bit 1 - Port 1, … RESET:0x0"
          
group.long  0x34120++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_1_INGRESS_RX_FDFIFO_P_STRFWD, TSN_PORT_1 RX_FDFIFO STRFWD Register RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETHERNET_TSN_SW_TSN_PORT_1_INGRESS_RX_FDFIFO_P_STRFWD_PORT ,If selected port is set then the frame is transmitted in Store & Forward mode. This is necessary when the ingress rate of this port is slower than the egress rate of the transmitting port. In S&F, the ingress module is able to drop frames with bad CRC. bit 0 - CPU-Port, bit 1 - Port 1, … RESET:0x0"
          
group.long  0x40004++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_2_MACADDR_L, Lower bits of MAC address (port 2) RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHERNET_TSN_SW_TSN_PORT_2_MACADDR_L_MACADDR ,MAC Address RESET:0x0"
          
group.long  0x40008++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_2_MACADDR_H, Upper bits of MAC address (port 2) RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETHERNET_TSN_SW_TSN_PORT_2_MACADDR_H_MACADDR ,MAC Address RESET:0x0"
          
group.long  0x4000c++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_2_MAC_CTRL, MAC control register (port2) RESET:0x1800"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_TSN_PORT_2_MAC_CTRL_RESSTAT ,Software reset of statistic counters RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_TSN_SW_TSN_PORT_2_MAC_CTRL_RX_EN ,RX path enable RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_TSN_SW_TSN_PORT_2_MAC_CTRL_TX_EN ,TX path enable RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_TSN_SW_TSN_PORT_2_MAC_CTRL_JUMBO ,Jumbo frame support RESET:0x0"
          
         bitfld.long 0x00 4. " ETHERNET_TSN_SW_TSN_PORT_2_MAC_CTRL_GMIIMODE ,MII transmit mode RESET:0x0"
          
         hexmask.long 0x00 5.--6. 1. " ETHERNET_TSN_SW_TSN_PORT_2_MAC_CTRL_PHYSEL ,PHY selection RESET:0x0"
          
         hexmask.long 0x00 8.--10. 1. " ETHERNET_TSN_SW_TSN_PORT_2_MAC_CTRL_CLKSEL ,Clock selection RESET:0x0"
          
         bitfld.long 0x00 11. " ETHERNET_TSN_SW_TSN_PORT_2_MAC_CTRL_MCE ,Clock selection RESET:0x1"
          
         bitfld.long 0x00 12. " ETHERNET_TSN_SW_TSN_PORT_2_MAC_CTRL_RCE ,Ref clock enable RESET:0x1"
          
         bitfld.long 0x00 13. " ETHERNET_TSN_SW_TSN_PORT_2_MAC_CTRL_CSA ,Clock switching active RESET:0x0"
          
group.long  0x40800++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_2_RTC_CTRL_REG, RTC Control Register RESET:0x0"
         bitfld.long 0x00 1. " ETHERNET_TSN_SW_TSN_PORT_2_RTC_CTRL_REG_ALIE ,Alarm interrupt enable: alarm interrupt enabled when 1 RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_TSN_SW_TSN_PORT_2_RTC_CTRL_REG_TAEN ,Timer A enable: timer enabled when 1 RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_TSN_SW_TSN_PORT_2_RTC_CTRL_REG_TAIE ,Timer A interrupt enable: interrupt enabled when 1 RESET:0x0"
          
group.long  0x4081c++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_2_RTC_TIMER_INCREMENT, RTC Current timer increment RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETHERNET_TSN_SW_TSN_PORT_2_RTC_TIMER_INCREMENT_FNS ,Local time increment – fractional ns, unsigned, in (1 / 2^24) n RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " ETHERNET_TSN_SW_TSN_PORT_2_RTC_TIMER_INCREMENT_NS ,Local time increment – nanoseconds (integer) RESET:0x0"
          
group.long  0x42004++0x3
    line.long 0x00 "ETHERNET_TSN_SW_UNKNOWN_TODO_2, REG NOT FOUND TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHERNET_TSN_SW_UNKNOWN_TODO_2_TEMP ,TODO RESET:0x0"
          
group.long  0x54020++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_2_INGRESS_RX_FDFIFO_E_STRFWD, TSN_PORT_2 RX_FDFIFO STRFWD Register RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETHERNET_TSN_SW_TSN_PORT_2_INGRESS_RX_FDFIFO_E_STRFWD_PORT ,If selected port is set then the frame is transmitted in Store & Forward mode. This is necessary when the ingress rate of this port is slower than the egress rate of the transmitting port. In S&F, the ingress module is able to drop frames with bad CRC. bit 0 - CPU-Port, bit 1 - Port 1, … RESET:0x0"
          
group.long  0x54120++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_2_INGRESS_RX_FDFIFO_P_STRFWD, TSN_PORT_2 RX_FDFIFO STRFWD Register RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETHERNET_TSN_SW_TSN_PORT_2_INGRESS_RX_FDFIFO_P_STRFWD_PORT ,If selected port is set then the frame is transmitted in Store & Forward mode. This is necessary when the ingress rate of this port is slower than the egress rate of the transmitting port. In S&F, the ingress module is able to drop frames with bad CRC. bit 0 - CPU-Port, bit 1 - Port 1, … RESET:0x0"
          
group.long  0x60004++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_3_MACADDR_L, Lower bits of MAC address (port 3) RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHERNET_TSN_SW_TSN_PORT_3_MACADDR_L_MACADDR ,MAC Address RESET:0x0"
          
group.long  0x60008++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_3_MACADDR_H, Upper bits of MAC address (port 3) RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " ETHERNET_TSN_SW_TSN_PORT_3_MACADDR_H_MACADDR ,MAC Address RESET:0x0"
          
group.long  0x6000c++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_3_MAC_CTRL, MAC control register (port3) RESET:0x1800"
         bitfld.long 0x00 0. " ETHERNET_TSN_SW_TSN_PORT_3_MAC_CTRL_RESSTAT ,Software reset of statistic counters RESET:0x0"
          
         bitfld.long 0x00 1. " ETHERNET_TSN_SW_TSN_PORT_3_MAC_CTRL_RX_EN ,RX path enable RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_TSN_SW_TSN_PORT_3_MAC_CTRL_TX_EN ,TX path enable RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_TSN_SW_TSN_PORT_3_MAC_CTRL_JUMBO ,Jumbo frame support RESET:0x0"
          
         bitfld.long 0x00 4. " ETHERNET_TSN_SW_TSN_PORT_3_MAC_CTRL_GMIIMODE ,MII transmit mode RESET:0x0"
          
         hexmask.long 0x00 5.--6. 1. " ETHERNET_TSN_SW_TSN_PORT_3_MAC_CTRL_PHYSEL ,PHY selection RESET:0x0"
          
         hexmask.long 0x00 8.--10. 1. " ETHERNET_TSN_SW_TSN_PORT_3_MAC_CTRL_CLKSEL ,Clock selection RESET:0x0"
          
         bitfld.long 0x00 11. " ETHERNET_TSN_SW_TSN_PORT_3_MAC_CTRL_MCE ,Clock selection RESET:0x1"
          
         bitfld.long 0x00 12. " ETHERNET_TSN_SW_TSN_PORT_3_MAC_CTRL_RCE ,Ref clock enable RESET:0x1"
          
         bitfld.long 0x00 13. " ETHERNET_TSN_SW_TSN_PORT_3_MAC_CTRL_CSA ,Clock switching active RESET:0x0"
          
group.long  0x60800++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_3_RTC_CTRL_REG, RTC Control Register RESET:0x0"
         bitfld.long 0x00 1. " ETHERNET_TSN_SW_TSN_PORT_3_RTC_CTRL_REG_ALIE ,Alarm interrupt enable: alarm interrupt enabled when 1 RESET:0x0"
          
         bitfld.long 0x00 2. " ETHERNET_TSN_SW_TSN_PORT_3_RTC_CTRL_REG_TAEN ,Timer A enable: timer enabled when 1 RESET:0x0"
          
         bitfld.long 0x00 3. " ETHERNET_TSN_SW_TSN_PORT_3_RTC_CTRL_REG_TAIE ,Timer A interrupt enable: interrupt enabled when 1 RESET:0x0"
          
group.long  0x6081c++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_3_RTC_TIMER_INCREMENT, RTC Current timer increment RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETHERNET_TSN_SW_TSN_PORT_3_RTC_TIMER_INCREMENT_FNS ,Local time increment – fractional ns, unsigned, in (1 / 2^24) n RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " ETHERNET_TSN_SW_TSN_PORT_3_RTC_TIMER_INCREMENT_NS ,Local time increment – nanoseconds (integer) RESET:0x0"
          
group.long  0x62004++0x3
    line.long 0x00 "ETHERNET_TSN_SW_UNKNOWN_TODO_3, REG NOT FOUND TODO RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHERNET_TSN_SW_UNKNOWN_TODO_3_TEMP ,TODO RESET:0x0"
          
group.long  0x74020++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_3_INGRESS_RX_FDFIFO_E_STRFWD, TSN_PORT_3 RX_FDFIFO STRFWD Register RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETHERNET_TSN_SW_TSN_PORT_3_INGRESS_RX_FDFIFO_E_STRFWD_PORT ,If selected port is set then the frame is transmitted in Store & Forward mode. This is necessary when the ingress rate of this port is slower than the egress rate of the transmitting port. In S&F, the ingress module is able to drop frames with bad CRC. bit 0 - CPU-Port, bit 1 - Port 1, … RESET:0x0"
          
group.long  0x74120++0x3
    line.long 0x00 "ETHERNET_TSN_SW_TSN_PORT_3_INGRESS_RX_FDFIFO_P_STRFWD, TSN_PORT_3 RX_FDFIFO STRFWD Register RESET:0x0"
         hexmask.long 0x00 0.--23. 1. " ETHERNET_TSN_SW_TSN_PORT_3_INGRESS_RX_FDFIFO_P_STRFWD_PORT ,If selected port is set then the frame is transmitted in Store & Forward mode. This is necessary when the ingress rate of this port is slower than the egress rate of the transmitting port. In S&F, the ingress module is able to drop frames with bad CRC. bit 0 - CPU-Port, bit 1 - Port 1, … RESET:0x0"
          
tree.end

tree "EMMC_QSPI_REG"
base e:0x40300000
width 80.
tree.end

tree "EMMC_QSPI_REG__TOP"
base e:0x40300000
width 80.
group.long  0x0++0x3
    line.long 0x00 "EMMC_QSPI_REG_TOP_CTRL, EMMC-QSPI mode controls + Miscellaneous controls of EMMC controller RESET:0x3e"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_TOP_CTRL_QSPI_MODE_EN ,QSPI mode enable; enables QSPI host to control EMMC test interface AND enables pad ctrl from test interface. Connected to both phy_intf_sel and test_pad_mode signals on EMMC controller. 0: EMMC mode, 1: QSPI mode RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_TOP_CTRL_CARD_CLK_STABLE ,Indicates to controller that the supplied card clock is stable RESET:0x1"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_TOP_CTRL_INT_BCLK_STABLE ,Indicates to controller that the supplied base clock is stable RESET:0x1"
          
         bitfld.long 0x00 3. " EMMC_QSPI_REG_TOP_CTRL_INT_ACLK_STABLE ,Indicates to controller that the supplied AXI clock is stable RESET:0x1"
          
         bitfld.long 0x00 4. " EMMC_QSPI_REG_TOP_CTRL_INT_TMCLK_STABLE ,Indicates to controller that the supplied timer clock is stable RESET:0x1"
          
         bitfld.long 0x00 5. " EMMC_QSPI_REG_TOP_CTRL_HOST_REG_VOL_STABLE ,Indicates to controller that the host regulator voltage is stable RESET:0x1"
          
         bitfld.long 0x00 6. " EMMC_QSPI_REG_TOP_CTRL_CARD_DETECT_N ,SD card detect. Must tie LOW in eMMC mode RESET:0x0"
          
         bitfld.long 0x00 7. " EMMC_QSPI_REG_TOP_CTRL_CARD_WRITE_PROT ,SD card write protect. Must tie LOW in eMMC mode RESET:0x0"
          
         bitfld.long 0x00 8. " EMMC_QSPI_REG_TOP_CTRL_RESET_EMMC_TX_N ,SW trigger for reset_emmc_tx_n RESET:0x0"
          
         bitfld.long 0x00 9. " EMMC_QSPI_REG_TOP_CTRL_RESET_EMMC_TIMER_N ,SW trigger for reset_emmc_timer_n RESET:0x0"
          
         bitfld.long 0x00 10. " EMMC_QSPI_REG_TOP_CTRL_RESET_EMMC_N ,SW trigger for reset_emmc_n RESET:0x0"
          
tree.end

tree "EMMC_QSPI_REG__QSPI"
base e:0x40300100
width 80.
tree.end

tree "EMMC_QSPI_REG__QSPI__MST_WRAP"
base e:0x40300100
width 80.
group.long  0x0++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WRAP_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_WRAP_CTRL_EN ,Enable SPI Master RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_WRAP_CTRL_CPHA ,CPHA RESET:0x0"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_QSPI_MST_WRAP_CTRL_CPOL ,CPOL RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_QSPI_REG_QSPI_MST_WRAP_CTRL_STOP ,End of Transfer. Must be set when last byte to be transmitted is added to the TX FIFO RESET:0x0"
          
         bitfld.long 0x00 4.--6. " EMMC_QSPI_REG_QSPI_MST_WRAP_CTRL_MODE ,SPI communication mode: bits [1:0] control TX (MUX_SEL), bit [2] controls RX (DEMUX_SEL) - 000: DMA (default) - 001: APB_WDMA - 010: WDMA_ONLY - 100: APB_RDMA - 101: APB RESET:0x0" "DMA-0,APB_WDMA-1,WDMA_ONLY-2,APB_RDMA-4,APB-5"
          
rgroup.long 0x4++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WRAP_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_WRAP_STATUS_RX_NOT_EMPTY ,Status: RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_WRAP_STATUS_RX_FULL ,Status: RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_QSPI_MST_WRAP_STATUS_TX_EMPTY ,Status: TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_QSPI_REG_QSPI_MST_WRAP_STATUS_TX_NOT_FULL ,Status: TX FIFO not full RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_ENABLE, None RESET:0x0"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_ENABLE_RX_OVFL ,Enable IRQ for RX FIFO overflow RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_ENABLE_RX_FULL ,Enable IRQ for RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_ENABLE_RX_NOT_EMPTY ,Enable IRQ for RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_ENABLE_TX_EMPTY ,Enable IRQ for TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 4. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_ENABLE_TX_NOT_FULL ,Enable IRQ for TX FIFO not full RESET:0x0"
          
         bitfld.long 0x00 5. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_ENABLE_TX_DONE ,Enable IRQ for last byte TX/RX done RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_RX_OVFL ,IRQ Status for RX FIFO overflow RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_RX_FULL ,IRQ Status for RX FIFO full RESET:0x0"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_RX_NOT_EMPTY ,Enable IRQ for RX FIFO not empty RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_TX_EMPTY ,IRQ Status for TX FIFO empty RESET:0x0"
          
         bitfld.long 0x00 4. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_TX_NOT_FULL ,IRQ Status for TX FIFO not full RESET:0x0"
          
         bitfld.long 0x00 5. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_TX_DONE ,IRQ Status for last byte TX/RX done RESET:0x0"
          
wgroup.long 0x10++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev). RESET:0x0"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_SET_RX_OVFL ,Set rx_ovfl irq RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_SET_RX_FULL ,Set rx_full irq RESET:0x0"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_SET_RX_NOT_EMPTY ,Set rx_not_empty irq RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_SET_TX_EMPTY ,Set tx_empty irq RESET:0x0"
          
         bitfld.long 0x00 4. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_SET_TX_NOT_FULL ,Set tx_not_full irq RESET:0x0"
          
         bitfld.long 0x00 5. " EMMC_QSPI_REG_QSPI_MST_WRAP_IRQ_STATUS_SET_TX_DONE ,Set tx_done irq RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WRAP_SCLK_FREQ, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EMMC_QSPI_REG_QSPI_MST_WRAP_SCLK_FREQ_TICKS ,Set clock ticks for half of SCLK_PERIOD. SCLK_FREQ = SPI_MST_CLK_FREQ/(2*(ticks+1)) RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WRAP_TX, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EMMC_QSPI_REG_QSPI_MST_WRAP_TX_DATA ,Data to be added on TX FIFO RESET:0x0"
          
         bitfld.long 0x00 8. " EMMC_QSPI_REG_QSPI_MST_WRAP_TX_EN ,Controls the tx_enable signal at the qspi_master level. 1: Output enables are activated, data lines that are used function as MOSI. 0: Output enables are released, data lines that are used function as MISO. Only relevant for DSPI and QSPI modes. In SPI mode, tie to 1. RESET:0x0"
          
         bitfld.long 0x00 9. " EMMC_QSPI_REG_QSPI_MST_WRAP_TX_DATA_WTRIG ,Set wtrig signal to indicate data is valid. RESET:0x0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WRAP_RX, None RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EMMC_QSPI_REG_QSPI_MST_WRAP_RX_DATA ,Data to be read from the RX FIFO. Data is not consumed on read. Use RX_FIFO register to consume/clear RX FIFO RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WRAP_RX_FIFO, None RESET:0x0"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_WRAP_RX_FIFO_POP ,Consume one item on RX FIFO (singlepulse) RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_WRAP_RX_FIFO_RX_FLUSH ,Flush RX FIFO (constant enable) RESET:0x0"
          
tree.end

tree "EMMC_QSPI_REG__QSPI__MST"
base e:0x40300140
width 80.
group.long  0x0++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_CFG_ITF, Configuration for (Q)SPI master interface RESET:0x40"
         bitfld.long 0x00 0.--1. " EMMC_QSPI_REG_QSPI_MST_CFG_ITF_SPI_MODE ,SPI interface mode - 00: 1 bit SPI (single SPI) (default) - 01: 2 bit SPI (dual SPI) - 10: 4 bit SPI (quad SPI) - 11: reserved RESET:0x0" "SNGL_SPI-0,DUAL_SPI-1,QUAD_SPI-2"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_QSPI_MST_CFG_ITF_CPHA ,SPI clock phase - 0: change data on falling egde, sample data on rising  edge (default) - 1: change data on rising  egde, sample data on falling edge RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_QSPI_REG_QSPI_MST_CFG_ITF_CPOL ,SPI clock polarity - 0: clock in idle state is low (default) - 1: clock in idle state is high RESET:0x0"
          
         bitfld.long 0x00 4.--5. " EMMC_QSPI_REG_QSPI_MST_CFG_ITF_MOSI_SEL ,select QSPI data port for SPI MOSI (output) in single SPI mode - 0: MOSI[0] (default) - 1: MOSI[1] - 2: MOSI[2] - 3: MOSI[3] RESET:0x0" "MOSI_0-0,MOSI_1-1,MOSI_2-2,MOSI_3-3"
          
         bitfld.long 0x00 6.--7. " EMMC_QSPI_REG_QSPI_MST_CFG_ITF_MISO_SEL ,select QSPI data port for SPI MISO (input) in single SPI mode - 0: MISO[0] - 1: MISO[1] (default) - 2: MISO[2] - 3: MISO[3] RESET:0x1" "MISO_0-0,MISO_1-1,MISO_2-2,MISO_3-3"
          
group.long  0x4++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_CFG_SCLK, Configuration for SPI clock RESET:0x10001"
         hexmask.long 0x00 0.--7. 1. " EMMC_QSPI_REG_QSPI_MST_CFG_SCLK_CDIV ,SPI clock divider SPI clock[freq] = sys_clk / (2*(cdiv+1))     duty cycle is 50% RESET:0x1"
          
         hexmask.long 0x00 16.--24. 1. " EMMC_QSPI_REG_QSPI_MST_CFG_SCLK_SMPL_POINT ,sample point - [8]   : SPI clock high/low - [7:0] : clk_div_phase example: sample at rising edge: [8]   = 0 [7:0] = cdiv RESET:0x1"
          
group.long  0x8++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_CFG_SS_TIMING, configure SPI slave select timing RESET:0x100"
         hexmask.long 0x00 0.--3. 1. " EMMC_QSPI_REG_QSPI_MST_CFG_SS_TIMING_SETUP ,setup time, time from falling edge of 'slave select' to first active SPI clock edge, number of SPI clock periods, values 0-15 (default = 0) RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " EMMC_QSPI_REG_QSPI_MST_CFG_SS_TIMING_HOLD ,hold time, time from last active SPI clock edge to rising edge of 'slave select', number of SPI clock periods, values 0-15 (default = 0) RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " EMMC_QSPI_REG_QSPI_MST_CFG_SS_TIMING_INACTIVE ,minimum inactive time (inter transaction gap), SPI slave select is high for minimum this period between transactions, number of SPI clock periods, values 0-15 (default = 1) RESET:0x1"
          
group.long  0xc++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_CTRL, (Q)SPI master control RESET:0x0"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_CTRL_RESTART ,Restart (Q)SPI master interface (single pulse / self clearing) reset state and flush buffers RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_EXT_SS_CTRL, (Q)SPI slave select control RESET:0x2"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_EXT_SS_CTRL_ENABLE ,enable external slave select RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_EXT_SS_CTRL_VALUE ,value of external slave select 0: low 1: high (default) RESET:0x1"
          
rgroup.long 0x14++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_STATUS, (Q)SPI state RESET:0x0"
         bitfld.long 0x00 0.--2. " EMMC_QSPI_REG_QSPI_MST_STATUS_STATE ,FSM state of (Q)SPI master RESET:0x0" "IDLE-0,SS_SETUP-1,SS_HOLD-2,SS_INACTIVE-3,SHIFTING-4,SHIFT_LAST_WORD-5,WAIT-6,FINISH_TRANSFER-7"
          
tree.end

tree "EMMC_QSPI_REG__QSPI__MST_WDMA"
base e:0x40300180
width 80.
group.long  0x0++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_WDMA_CTRL_ENABLE ,Global enable for the WDMA RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_WDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next write will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_QSPI_MST_WDMA_CTRL_ADDR_DECREMENT ,When = 1, address is decremented in the AXI master RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_QSPI_REG_QSPI_MST_WDMA_CTRL_CONT_MODE ,Enables continuous mode if set to 1, transmission is finalized, if HW signals last access RESET:0x0"
          
         bitfld.long 0x00 4. " EMMC_QSPI_REG_QSPI_MST_WDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 5.--12. 1. " EMMC_QSPI_REG_QSPI_MST_WDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " EMMC_QSPI_REG_QSPI_MST_WDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " EMMC_QSPI_REG_QSPI_MST_WDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " EMMC_QSPI_REG_QSPI_MST_WDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " EMMC_QSPI_REG_QSPI_MST_WDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_QSPI_REG_QSPI_MST_WDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WDMA_SIZE1, SIZE1 interrupt triggers in case buffer is filled with size1 byte / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_QSPI_REG_QSPI_MST_WDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WDMA_CURR_ADDR, the current address of the DMA write pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_QSPI_REG_QSPI_MST_WDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS, interrupt status bits / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS_OVFL ,Overflow: data from AXI-4S is coming too fast to be written to the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS_ENABLE_OVFL ,Enable interrupt ovfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to force an interrupt event (used for Software debugging or integration testing) RESET:0x0"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize for one cycle RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 for one cycle RESET:0x0"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr for one cycle RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_QSPI_REG_QSPI_MST_WDMA_IRQ_STATUS_SET_OVFL ,Set interrupt ovfl for one cycle RESET:0x0"
          
tree.end

tree "EMMC_QSPI_REG__QSPI__MST_RDMA"
base e:0x403001c0
width 80.
group.long  0x0++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_RDMA_CTRL, Contains software control fields RESET:0x2"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_RDMA_CTRL_ENABLE ,Global enable for the RDMA RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_RDMA_CTRL_CYCLIC ,Enable cyclic operation. If enabled and the DMA address has reached (startaddr + maxsize), the next read will wrap to startaddr RESET:0x1"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_QSPI_MST_RDMA_CTRL_DOUBLE_BUF ,Enables double buffering mode, once maxsize is reached, it starts again from startaddr_db RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " EMMC_QSPI_REG_QSPI_MST_RDMA_CTRL_BURST_LEN ,AXI burst length RESET:0x0"
          
         bitfld.long 0x00 11. " EMMC_QSPI_REG_QSPI_MST_RDMA_CTRL_TERMINATE ,Manual termination of stream, concludes transaction and sends tlast. Self-clearing RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_RDMA_STARTADDR, the start address of the DMA buffer. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " EMMC_QSPI_REG_QSPI_MST_RDMA_STARTADDR_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " EMMC_QSPI_REG_QSPI_MST_RDMA_STARTADDR_VALUE ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_RDMA_STARTADDR_DB, the second start address of the DMA in double buffering mode. The last two bits are zero for word alignment RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " EMMC_QSPI_REG_QSPI_MST_RDMA_STARTADDR_DB_WORD_ALIGNMENT ,None RESET:0x0"
          
         hexmask.long 0x00 2.--31. 1. " EMMC_QSPI_REG_QSPI_MST_RDMA_STARTADDR_DB_VALUE ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_RDMA_MAXSIZE, the size in bytes of the buffer allocated for DMA operations RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_QSPI_REG_QSPI_MST_RDMA_MAXSIZE_VALUE ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_RDMA_SIZE1, SIZE1 interrupt triggers in case size1 byte have been read from the buffer / can be used for double buffering RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_QSPI_REG_QSPI_MST_RDMA_SIZE1_VALUE ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_RDMA_CURR_ADDR, the current address of the DMA read pointer RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " EMMC_QSPI_REG_QSPI_MST_RDMA_CURR_ADDR_VALUE ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS, interrupt status bits reflect the occurrence of an event / whether these bits generate an interrupt is contolled via irq_status_enable RESET:0x0"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS_MAXSIZE ,Buffer is filled to MAXSIZE RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS_SIZE1 ,Buffer is filled to size1 RESET:0x0"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS_BERR ,Bus error: system bus returns an error response. Use curr_addr as a hint where the bus error occurred RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS_UNFL ,Underflow: data towards AXI-4S is consumed faster than the DMA is able to read data from the bus system in time. NOTE: This can also be detected from the interface axi wrappers (e.g. spi_axi4s_wrap) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS_ENABLE, Enables the selected events to generate interrupts on the interrupt line RESET:0x0"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS_ENABLE_MAXSIZE ,Enable interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS_ENABLE_SIZE1 ,Enable interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS_ENABLE_BERR ,Enable interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS_ENABLE_UNFL ,Enable interrupt unfl RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev) RESET:0x0"
         bitfld.long 0x00 0. " EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS_SET_MAXSIZE ,Set interrupt maxsize RESET:0x0"
          
         bitfld.long 0x00 1. " EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS_SET_SIZE1 ,Set interrupt size1 RESET:0x0"
          
         bitfld.long 0x00 2. " EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS_SET_BERR ,Set interrupt berr RESET:0x0"
          
         bitfld.long 0x00 3. " EMMC_QSPI_REG_QSPI_MST_RDMA_IRQ_STATUS_SET_UNFL ,Set interrupt unfl RESET:0x0"
          
tree.end

tree "ETHOS_REGFILE"
base e:0x40303000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_CFGSRAMHASH0_39_TO_8, Enables NPU to stripe across AXI_SRAM ports 0 and 1 when needed RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_REGFILE_ETHOS_CFGSRAMHASH0_39_TO_8_CFGSRAMHASH0_39_TO_8 ,Bits 39 to 8 of CFGSRAMHASH0 RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_CFGSRAMHASH0_7_TO_0, Enables NPU to stripe across AXI_SRAM ports 0 and 1 when needed RESET:0x80"
         hexmask.long 0x00 0.--7. 1. " ETHOS_REGFILE_ETHOS_CFGSRAMHASH0_7_TO_0_CFGSRAMHASH0_7_TO_0 ,Bits 7 to 0 of CFGSRAMHASH0 RESET:0x80"
          
group.long  0x8++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_CFGSRAMHASH1_39_TO_8, Enables NPU to stripe across AXI_SRAM ports 2 and 3 when present RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_REGFILE_ETHOS_CFGSRAMHASH1_39_TO_8_CFGSRAMHASH1_39_TO_8 ,Bits 39 to 8 of CFGSRAMHASH1 RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_CFGSRAMHASH1_7_TO_0, Enables NPU to stripe across AXI_SRAM ports 2 and 3 when needed RESET:0x40"
         hexmask.long 0x00 0.--7. 1. " ETHOS_REGFILE_ETHOS_CFGSRAMHASH1_7_TO_0_CFGSRAMHASH1_7_TO_0 ,Bits 7 to 0 of CFGSRAMHASH1 RESET:0x40"
          
group.long  0x10++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_CFGEXTHASH0_39_TO_8, Enables NPU to stripe across AXI_EXT ports when present RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_REGFILE_ETHOS_CFGEXTHASH0_39_TO_8_CFGEXTHASH0_39_TO_8 ,Bits 39 to 8 of CFGEXTHASH0 RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_CFGEXTHASH0_7_TO_0, Enables NPU to stripe across AXI_EXT ports when present RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " ETHOS_REGFILE_ETHOS_CFGEXTHASH0_7_TO_0_CFGEXTHASH0_7_TO_0 ,Bits 7 to 0 of CFGEXTHASH0 RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_CFGSRAMCAP, Configuration capabilities for SRAM ports RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_REGFILE_ETHOS_CFGSRAMCAP_CFGSRAMCAP ,cfgsramcap RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_CFGEXTCAP, Configuration capabilities for EXT ports RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " ETHOS_REGFILE_ETHOS_CFGEXTCAP_CFGEXTCAP ,cfgextcap RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "ETHOS_REGFILE_CTRL_ETHOS, ETHOS sideband control signals RESET:0x3"
         bitfld.long 0x00 0. " ETHOS_REGFILE_CTRL_ETHOS_PORPL ,ETHOS Power On Reset Privilege Level RESET:0x1"
          
         bitfld.long 0x00 1. " ETHOS_REGFILE_CTRL_ETHOS_PORSL ,ETHOS Power On Reset Security Level RESET:0x1"
          
rgroup.long 0x24++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_CLK_PWR_MGMT_O, Outputs for the management of clk and pwr signals RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_REGFILE_ETHOS_CLK_PWR_MGMT_O_CLKQACTIVE ,Indicates that NPU requires CLK to be active RESET:0x0"
          
         bitfld.long 0x00 1. " ETHOS_REGFILE_ETHOS_CLK_PWR_MGMT_O_CLKQACCEPTN ,Indicates that NPU accepts the clock controller request (active low) RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_REGFILE_ETHOS_CLK_PWR_MGMT_O_CLKQDENY ,Indicates that the NPU denies the clock controller request RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_REGFILE_ETHOS_CLK_PWR_MGMT_O_PWRQACTIVE ,Indicates that the NPU needs power RESET:0x0"
          
         bitfld.long 0x00 4. " ETHOS_REGFILE_ETHOS_CLK_PWR_MGMT_O_PWRQACCEPTN ,Indicates that the NPU accepts the power controller request (active low) RESET:0x0"
          
         bitfld.long 0x00 5. " ETHOS_REGFILE_ETHOS_CLK_PWR_MGMT_O_PWRQDENY ,Indicates that the NPU denies power controller reqest RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_CLK_PWR_MGMT_I, Inputs for the management of clk and pwr signals RESET:0x3"
         bitfld.long 0x00 0. " ETHOS_REGFILE_ETHOS_CLK_PWR_MGMT_I_CLKQREQN ,Indicates that the clock controller wants to gate the clock (active low) RESET:0x1"
          
         bitfld.long 0x00 1. " ETHOS_REGFILE_ETHOS_CLK_PWR_MGMT_I_PWRQREQN ,Indicates that the power controller wants to power down (active low) RESET:0x1"
          
group.long  0x2c++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_CLKEN_AXIPORTS_I, Clock enable inputs for the AXI interfaces between the Ethos and the memories SRAM0-SRAM3, and clock enable inputs for the AXI interfaces between the Ethos and the external memories EXT0 and EXT1 (can be DRAM or Flash). Outputs remain constant when the clock enable is LOW. Inputs are sampled only when the clock enable is HIGH RESET:0x3f"
         bitfld.long 0x00 0. " ETHOS_REGFILE_ETHOS_CLKEN_AXIPORTS_I_CLKENSRAM0 ,Indicates that AXI interface will not accept or drive transactions. RESET:0x1"
          
         bitfld.long 0x00 1. " ETHOS_REGFILE_ETHOS_CLKEN_AXIPORTS_I_CLKENSRAM1 ,Indicates that AXI interface will not accept or drive transactions. RESET:0x1"
          
         bitfld.long 0x00 2. " ETHOS_REGFILE_ETHOS_CLKEN_AXIPORTS_I_CLKENSRAM2 ,Indicates that AXI interface will not accept or drive transactions. RESET:0x1"
          
         bitfld.long 0x00 3. " ETHOS_REGFILE_ETHOS_CLKEN_AXIPORTS_I_CLKENSRAM3 ,Indicates that AXI interface will not accept or drive transactions. RESET:0x1"
          
         bitfld.long 0x00 4. " ETHOS_REGFILE_ETHOS_CLKEN_AXIPORTS_I_CLKENEXT0 ,Indicates that AXI interface will not accept or drive transactions. RESET:0x1"
          
         bitfld.long 0x00 5. " ETHOS_REGFILE_ETHOS_CLKEN_AXIPORTS_I_CLKENEXT1 ,Indicates that AXI interface will not accept or drive transactions. RESET:0x1"
          
rgroup.long 0x30++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_WAKEUP_INDICATOR_O, Pending activity indicator. If a transfer is scheduled, the transmitting logic can activate if previously inactive. RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_REGFILE_ETHOS_WAKEUP_INDICATOR_O_AWAKEUPSRAM0 ,Pending activity indicator for the axi interface connected to sram0. RESET:0x0"
          
         bitfld.long 0x00 1. " ETHOS_REGFILE_ETHOS_WAKEUP_INDICATOR_O_AWAKEUPSRAM1 ,Pending activity indicator for the axi interface connected to sram1. RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_REGFILE_ETHOS_WAKEUP_INDICATOR_O_AWAKEUPSRAM2 ,Pending activity indicator for the axi interface connected to sram2. RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_REGFILE_ETHOS_WAKEUP_INDICATOR_O_AWAKEUPSRAM3 ,Pending activity indicator for the axi interface connected to sram3. RESET:0x0"
          
         bitfld.long 0x00 4. " ETHOS_REGFILE_ETHOS_WAKEUP_INDICATOR_O_AWAKEUPEXT0 ,Pending activity indicator for the axi interface connected to ext0. RESET:0x0"
          
         bitfld.long 0x00 5. " ETHOS_REGFILE_ETHOS_WAKEUP_INDICATOR_O_AWAKEUPEXT1 ,Pending activity indicator for the axi interface connected to ext1. RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_WARM_RESET_HALT_I, Input signals for warm reset halt RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_REGFILE_ETHOS_WARM_RESET_HALT_I_WRSTQREQ ,Indicates a request to halt the NPU (active high). RESET:0x0"
          
rgroup.long 0x38++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_WARM_RESET_HALT_O, Output signals for warm reset halt RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_REGFILE_ETHOS_WARM_RESET_HALT_O_WRSTQACK ,Indicates a request to halt the NPU (active high). RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_DBG_I, Input debug configurations RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_REGFILE_ETHOS_DBG_I_DBGEN ,Debug enable. RESET:0x0"
          
         bitfld.long 0x00 1. " ETHOS_REGFILE_ETHOS_DBG_I_SPIDEN ,Debug enable for secure state. RESET:0x0"
          
         bitfld.long 0x00 2. " ETHOS_REGFILE_ETHOS_DBG_I_DBGHALTREQ ,Indicates the debug halt request (active high). RESET:0x0"
          
         bitfld.long 0x00 3. " ETHOS_REGFILE_ETHOS_DBG_I_DBGRESTARTREQ ,Indicates the debug restart request (active high). RESET:0x0"
          
rgroup.long 0x40++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_DBG_O, Output debug configurations RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_REGFILE_ETHOS_DBG_O_DBGHALTACK ,Pulsed halt acknowledge (active high). RESET:0x0"
          
group.long  0x44++0x3
    line.long 0x00 "ETHOS_REGFILE_ETHOS_APB_CFG_I, Configuration of the APB interface RESET:0x3"
         bitfld.long 0x00 0. " ETHOS_REGFILE_ETHOS_APB_CFG_I_PWAKEUP ,Indicates activity at the APB interface RESET:0x1"
          
         bitfld.long 0x00 1. " ETHOS_REGFILE_ETHOS_APB_CFG_I_PCLKEN ,Clock enable RESET:0x1"
          
group.long  0x48++0x3
    line.long 0x00 "ETHOS_REGFILE_RESET_REG, Ethos SW register RESET:0x0"
         bitfld.long 0x00 0. " ETHOS_REGFILE_RESET_REG_SW_RESET_ETHOS_N ,SW trigger for reset_ethos_n of DPHY, active low RESET:0x0"
          
tree.end

tree "TOP"
base e:0x41000000
width 80.
group.long  0x0++0x3
    line.long 0x00 "TOP_CTRL_GPIO_MUX, Control GPIO MUX mode RESET:0x0"
         bitfld.long 0x00 0.--1. " TOP_CTRL_GPIO_MUX_FUNC_MODE ,GPIO MUX FUNCTIONAL MODE - 2'b00: func (default) - 2'b01: pwm - 2'b10: ulp1 - 2'b11: ulp2 RESET:0x0" "FUNC-0,PWM-1,ULP1-2,ULP2-3"
          
rgroup.long 0x4++0x3
    line.long 0x00 "TOP_STATUS_GPIO_MUX, None RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " TOP_STATUS_GPIO_MUX_MODE ,GPIO MUX mode RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "TOP_CTRL_CLK_ZBB, clk_zbb control RESET:0x3"
         bitfld.long 0x00 0. " TOP_CTRL_CLK_ZBB_EN_CLK ,Enable clk_zbb RESET:0x1"
          
         hexmask.long 0x00 1.--8. 1. " TOP_CTRL_CLK_ZBB_DIV ,Divider value of clk_zbb. freq(clk_zbb) = freq(clk_prim)/div. RESET:0x1"
          
group.long  0xc++0x3
    line.long 0x00 "TOP_CTRL_CLK_RBB, clk_rbb control RESET:0x1"
         bitfld.long 0x00 0. " TOP_CTRL_CLK_RBB_EN_CLK ,Enable clk_rbb RESET:0x1"
          
group.long  0x10++0x3
    line.long 0x00 "TOP_CTRL_CLK_EFUSE, clk_efuse div control RESET:0x2"
         bitfld.long 0x00 0. " TOP_CTRL_CLK_EFUSE_EN_CLK ,Enable clk_efuse RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " TOP_CTRL_CLK_EFUSE_DIV ,Divider value of clk_efuse. freq(clk_efuse) = freq(clk_prim)/div. This clock MUST be 25 MHz RESET:0x1"
          
group.long  0x14++0x3
    line.long 0x00 "TOP_CTRL_CLK_ADC, clk_adc control RESET:0x2"
         bitfld.long 0x00 0. " TOP_CTRL_CLK_ADC_EN_CLK ,Enable clk_adc RESET:0x0"
          
         hexmask.long 0x00 1.--8. 1. " TOP_CTRL_CLK_ADC_DIV ,Divider value of clk_adc. freq(clk_adc) = freq(clk_zbb)/div. RESET:0x1"
          
group.long  0x18++0x3
    line.long 0x00 "TOP_CTRL_CLK_FBIST_OUT, FBIST CLK_OUT control RESET:0x3"
         bitfld.long 0x00 0. " TOP_CTRL_CLK_FBIST_OUT_EN_CLK ,Enable CLK_OUT RESET:0x1"
          
         hexmask.long 0x00 1.--8. 1. " TOP_CTRL_CLK_FBIST_OUT_DIV ,Divider value of CLK_OUT. freq(CLK_OUT) = freq(clk_fbist)/div RESET:0x1"
          
group.long  0x1c++0x3
    line.long 0x00 "TOP_CTRL_CLK_MUX, Clock multiplexer control RESET:0x29"
         bitfld.long 0x00 0. " TOP_CTRL_CLK_MUX_SEL_CLK_PRIM0_CLKREF ,Select clk_prim0. If 1: clk = clk_ref; else: clk = clk_fll0 RESET:0x1"
          
         bitfld.long 0x00 1. " TOP_CTRL_CLK_MUX_SEL_CLK_PRIM1_CLK32 ,Select clk_prim1. If 1: clk = clk_32k; else: clk = clk_prim0 RESET:0x0"
          
