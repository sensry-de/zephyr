         bitfld.long 0x00 2. " TOP_CTRL_CLK_MUX_SEL_CLK_PRIM_PLL ,Select clk_prim. If 1: clk_prim = clk_pll; else: clk_prim = clk_prim1 RESET:0x0"
          
         bitfld.long 0x00 3. " TOP_CTRL_CLK_MUX_SEL_CLK_REF2000_FLL0 ,Select clk_ref2000. If 1: clk_ref2000 = clk_ref; else: clk_ref2000 = clk_fll0 RESET:0x1"
          
         bitfld.long 0x00 4. " TOP_CTRL_CLK_MUX_SEL_CLK_PLL ,Select clk_pll. If 1: clk_pll = clk_pll2000; else: clk_pll = clk_pll500 RESET:0x0"
          
         bitfld.long 0x00 5. " TOP_CTRL_CLK_MUX_SEL_CLK_ZBB0_CLK50M ,Select clk_zbb0. If 1: clk_zbb0 = clk_50m; else: clk_zbb0 = clk_32k RESET:0x1"
          
group.long  0x20++0x3
    line.long 0x00 "TOP_CTRL_ULP_IP, Control signals of ri_ulp, see datasheet for more details RESET:0x1d06121b"
         bitfld.long 0x00 0. " TOP_CTRL_ULP_IP_REQ_ULP_MODE ,None RESET:0x1"
          
         hexmask.long 0x00 1.--3. 1. " TOP_CTRL_ULP_IP_SEL_ULP_MODE ,None RESET:0x5"
          
         hexmask.long 0x00 4.--8. 1. " TOP_CTRL_ULP_IP_SEL_CLK_REF_CLKGEN_DIV ,None RESET:0x1"
          
         hexmask.long 0x00 9.--14. 1. " TOP_CTRL_ULP_IP_SEL_CLK_VAR_FB_DIV ,None RESET:0x9"
          
         hexmask.long 0x00 15.--16. 1. " TOP_CTRL_ULP_IP_SEL_CLK_VAR_FREQ_DIV ,None RESET:0x0"
          
         hexmask.long 0x00 17.--21. 1. " TOP_CTRL_ULP_IP_SEL_VDDVAR ,None RESET:0x3"
          
         bitfld.long 0x00 22. " TOP_CTRL_ULP_IP_SEL_CLK_AO0 ,None RESET:0x0"
          
         bitfld.long 0x00 23. " TOP_CTRL_ULP_IP_SEL_CLK_REF_EXT ,None RESET:0x0"
          
         hexmask.long 0x00 24.--26. 1. " TOP_CTRL_ULP_IP_SEL_CLK_REF_VAR_DIV ,None RESET:0x5"
          
         bitfld.long 0x00 27. " TOP_CTRL_ULP_IP_EN_VREF_06 ,None RESET:0x1"
          
         bitfld.long 0x00 28. " TOP_CTRL_ULP_IP_VDDCONST_PC_OVERRIDE ,None RESET:0x1"
          
group.long  0x24++0x3
    line.long 0x00 "TOP_CTRL_ULP_IP_2, More control signals of ri_ulp, see datasheet for more details RESET:0x1"
         bitfld.long 0x00 0. " TOP_CTRL_ULP_IP_2_VDDCONST_PDL_OVERRIDE ,None RESET:0x1"
          
         bitfld.long 0x00 1. " TOP_CTRL_ULP_IP_2_EN_POW_EXT ,None RESET:0x0"
          
         bitfld.long 0x00 2. " TOP_CTRL_ULP_IP_2_ACK_ULP_MODE ,holds the ack bit from ulp until PMU is present RESET:0x0"
          
         bitfld.long 0x00 3. " TOP_CTRL_ULP_IP_2_REQ_VDDVAR ,None RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "TOP_SW_CHIP_RESET_N, SW global chip reset_n RESET:0x1"
         bitfld.long 0x00 0. " TOP_SW_CHIP_RESET_N_RES_N ,None RESET:0x1"
          
rgroup.long 0x2c++0x3
    line.long 0x00 "TOP_BOOT_MODE, Register containing the boot mode values from pads RESET:0x0"
         bitfld.long 0x00 0. " TOP_BOOT_MODE_M0 ,None RESET:0x0"
          
         bitfld.long 0x00 1. " TOP_BOOT_MODE_M1 ,None RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "TOP_PAD_CTRL, Register to control GPIO pads RESET:0x0"
         bitfld.long 0x00 0. " TOP_PAD_CTRL_EN_CLK_REF_OVERRIDE ,Set '1' to force the clk_ref enable. RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "TOP_SEMAPHORE0, writing zero clears the semaphore / writing a value != zero is only successful in case the current value is zero RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " TOP_SEMAPHORE0_ID ,None RESET:0x0"
          
          
group.long  0x38++0x3
    line.long 0x00 "TOP_SEMAPHORE1, writing zero clears the semaphore / writing a value != zero is only successful in case the current value is zero RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " TOP_SEMAPHORE1_ID ,None RESET:0x0"
          
          
group.long  0x3c++0x3
    line.long 0x00 "TOP_SEMAPHORE2, writing zero clears the semaphore / writing a value != zero is only successful in case the current value is zero RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " TOP_SEMAPHORE2_ID ,None RESET:0x0"
          
          
group.long  0x40++0x3
    line.long 0x00 "TOP_SEMAPHORE3, writing zero clears the semaphore / writing a value != zero is only successful in case the current value is zero RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " TOP_SEMAPHORE3_ID ,None RESET:0x0"
          
          
group.long  0x44++0x3
    line.long 0x00 "TOP_SEMAPHORE4, writing zero clears the semaphore / writing a value != zero is only successful in case the current value is zero RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " TOP_SEMAPHORE4_ID ,None RESET:0x0"
          
          
group.long  0x48++0x3
    line.long 0x00 "TOP_SEMAPHORE5, writing zero clears the semaphore / writing a value != zero is only successful in case the current value is zero RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " TOP_SEMAPHORE5_ID ,None RESET:0x0"
          
          
group.long  0x4c++0x3
    line.long 0x00 "TOP_SCRATCH0, scratch registers are only reset to zero via RESET_N / they survive power down of ARMCM85 and ARMCM4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TOP_SCRATCH0_VALUE ,None RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "TOP_SCRATCH1, scratch registers are only reset to zero via RESET_N / they survive power down of ARMCM85 and ARMCM4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TOP_SCRATCH1_VALUE ,None RESET:0x0"
          
group.long  0x54++0x3
    line.long 0x00 "TOP_SCRATCH2, scratch registers are only reset to zero via RESET_N / they survive power down of ARMCM85 and ARMCM4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TOP_SCRATCH2_VALUE ,None RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "TOP_SCRATCH3, scratch registers are only reset to zero via RESET_N / they survive power down of ARMCM85 and ARMCM4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TOP_SCRATCH3_VALUE ,None RESET:0x0"
          
group.long  0x5c++0x3
    line.long 0x00 "TOP_SCRATCH4, scratch registers are only reset to zero via RESET_N / they survive power down of ARMCM85 and ARMCM4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TOP_SCRATCH4_VALUE ,None RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "TOP_SCRATCH5, scratch registers are only reset to zero via RESET_N / they survive power down of ARMCM85 and ARMCM4 RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TOP_SCRATCH5_VALUE ,None RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "TOP_RESET_EVENT, Reset event flags RESET:0x0"
         bitfld.long 0x00 0. " TOP_RESET_EVENT_WATCHDOG ,If 1, WDOGRES was triggered RESET:0x0"
          
         bitfld.long 0x00 1. " TOP_RESET_EVENT_POWERON ,If 1, power-on reset (from pad) was triggered RESET:0x0"
          
         bitfld.long 0x00 2. " TOP_RESET_EVENT_M85_SYSRESET ,If 1, m85 SysReset was triggered RESET:0x0"
          
         bitfld.long 0x00 3. " TOP_RESET_EVENT_M4_SYSRESET ,If 1, m4 SysReset was triggered RESET:0x0"
          
tree.end
    

tree "TOP__SW_IRQ0"
base e:0x41000070
width 80.
group.long  0x0++0x3
    line.long 0x00 "TOP_SW_IRQ0_STATUS, Indicates status of SW IRQ RESET:0x0"
         bitfld.long 0x00 0. " TOP_SW_IRQ0_STATUS_BIT0 ,None RESET:0x0"
          
         bitfld.long 0x00 1. " TOP_SW_IRQ0_STATUS_BIT1 ,None RESET:0x0"
          
         bitfld.long 0x00 2. " TOP_SW_IRQ0_STATUS_BIT2 ,None RESET:0x0"
          
         bitfld.long 0x00 3. " TOP_SW_IRQ0_STATUS_BIT3 ,None RESET:0x0"
          
         bitfld.long 0x00 4. " TOP_SW_IRQ0_STATUS_BIT4 ,None RESET:0x0"
          
         bitfld.long 0x00 5. " TOP_SW_IRQ0_STATUS_BIT5 ,None RESET:0x0"
          
         bitfld.long 0x00 6. " TOP_SW_IRQ0_STATUS_BIT6 ,None RESET:0x0"
          
         bitfld.long 0x00 7. " TOP_SW_IRQ0_STATUS_BIT7 ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "TOP_SW_IRQ0_STATUS_ENABLE, Enable mask to generate interrupt from status.bits RESET:0x0"
         bitfld.long 0x00 0. " TOP_SW_IRQ0_STATUS_ENABLE_BIT0 ,None RESET:0x0"
          
         bitfld.long 0x00 1. " TOP_SW_IRQ0_STATUS_ENABLE_BIT1 ,None RESET:0x0"
          
         bitfld.long 0x00 2. " TOP_SW_IRQ0_STATUS_ENABLE_BIT2 ,None RESET:0x0"
          
         bitfld.long 0x00 3. " TOP_SW_IRQ0_STATUS_ENABLE_BIT3 ,None RESET:0x0"
          
         bitfld.long 0x00 4. " TOP_SW_IRQ0_STATUS_ENABLE_BIT4 ,None RESET:0x0"
          
         bitfld.long 0x00 5. " TOP_SW_IRQ0_STATUS_ENABLE_BIT5 ,None RESET:0x0"
          
         bitfld.long 0x00 6. " TOP_SW_IRQ0_STATUS_ENABLE_BIT6 ,None RESET:0x0"
          
         bitfld.long 0x00 7. " TOP_SW_IRQ0_STATUS_ENABLE_BIT7 ,None RESET:0x0"
          
wgroup.long 0x8++0x3
    line.long 0x00 "TOP_SW_IRQ0_STATUS_SET, Set status register bits. If the corresponding bit in status_enable is 1, this will trigger an SW IRQ RESET:0x0"
         bitfld.long 0x00 0. " TOP_SW_IRQ0_STATUS_SET_BIT0 ,None RESET:0x0"
          
         bitfld.long 0x00 1. " TOP_SW_IRQ0_STATUS_SET_BIT1 ,None RESET:0x0"
          
         bitfld.long 0x00 2. " TOP_SW_IRQ0_STATUS_SET_BIT2 ,None RESET:0x0"
          
         bitfld.long 0x00 3. " TOP_SW_IRQ0_STATUS_SET_BIT3 ,None RESET:0x0"
          
         bitfld.long 0x00 4. " TOP_SW_IRQ0_STATUS_SET_BIT4 ,None RESET:0x0"
          
         bitfld.long 0x00 5. " TOP_SW_IRQ0_STATUS_SET_BIT5 ,None RESET:0x0"
          
         bitfld.long 0x00 6. " TOP_SW_IRQ0_STATUS_SET_BIT6 ,None RESET:0x0"
          
         bitfld.long 0x00 7. " TOP_SW_IRQ0_STATUS_SET_BIT7 ,None RESET:0x0"
          
tree.end
    

tree "TOP__SW_IRQ1"
base e:0x41000080
width 80.
group.long  0x0++0x3
    line.long 0x00 "TOP_SW_IRQ1_STATUS, Indicates status of SW IRQ RESET:0x0"
         bitfld.long 0x00 0. " TOP_SW_IRQ1_STATUS_BIT0 ,None RESET:0x0"
          
         bitfld.long 0x00 1. " TOP_SW_IRQ1_STATUS_BIT1 ,None RESET:0x0"
          
         bitfld.long 0x00 2. " TOP_SW_IRQ1_STATUS_BIT2 ,None RESET:0x0"
          
         bitfld.long 0x00 3. " TOP_SW_IRQ1_STATUS_BIT3 ,None RESET:0x0"
          
         bitfld.long 0x00 4. " TOP_SW_IRQ1_STATUS_BIT4 ,None RESET:0x0"
          
         bitfld.long 0x00 5. " TOP_SW_IRQ1_STATUS_BIT5 ,None RESET:0x0"
          
         bitfld.long 0x00 6. " TOP_SW_IRQ1_STATUS_BIT6 ,None RESET:0x0"
          
         bitfld.long 0x00 7. " TOP_SW_IRQ1_STATUS_BIT7 ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "TOP_SW_IRQ1_STATUS_ENABLE, Enable mask to generate interrupt from status.bits RESET:0x0"
         bitfld.long 0x00 0. " TOP_SW_IRQ1_STATUS_ENABLE_BIT0 ,None RESET:0x0"
          
         bitfld.long 0x00 1. " TOP_SW_IRQ1_STATUS_ENABLE_BIT1 ,None RESET:0x0"
          
         bitfld.long 0x00 2. " TOP_SW_IRQ1_STATUS_ENABLE_BIT2 ,None RESET:0x0"
          
         bitfld.long 0x00 3. " TOP_SW_IRQ1_STATUS_ENABLE_BIT3 ,None RESET:0x0"
          
         bitfld.long 0x00 4. " TOP_SW_IRQ1_STATUS_ENABLE_BIT4 ,None RESET:0x0"
          
         bitfld.long 0x00 5. " TOP_SW_IRQ1_STATUS_ENABLE_BIT5 ,None RESET:0x0"
          
         bitfld.long 0x00 6. " TOP_SW_IRQ1_STATUS_ENABLE_BIT6 ,None RESET:0x0"
          
         bitfld.long 0x00 7. " TOP_SW_IRQ1_STATUS_ENABLE_BIT7 ,None RESET:0x0"
          
wgroup.long 0x8++0x3
    line.long 0x00 "TOP_SW_IRQ1_STATUS_SET, Set status register bits. If the corresponding bit in status_enable is 1, this will trigger an SW IRQ RESET:0x0"
         bitfld.long 0x00 0. " TOP_SW_IRQ1_STATUS_SET_BIT0 ,None RESET:0x0"
          
         bitfld.long 0x00 1. " TOP_SW_IRQ1_STATUS_SET_BIT1 ,None RESET:0x0"
          
         bitfld.long 0x00 2. " TOP_SW_IRQ1_STATUS_SET_BIT2 ,None RESET:0x0"
          
         bitfld.long 0x00 3. " TOP_SW_IRQ1_STATUS_SET_BIT3 ,None RESET:0x0"
          
         bitfld.long 0x00 4. " TOP_SW_IRQ1_STATUS_SET_BIT4 ,None RESET:0x0"
          
         bitfld.long 0x00 5. " TOP_SW_IRQ1_STATUS_SET_BIT5 ,None RESET:0x0"
          
         bitfld.long 0x00 6. " TOP_SW_IRQ1_STATUS_SET_BIT6 ,None RESET:0x0"
          
         bitfld.long 0x00 7. " TOP_SW_IRQ1_STATUS_SET_BIT7 ,None RESET:0x0"
          
tree.end
    

tree "TOP__SW_IRQ2"
base e:0x41000090
width 80.
group.long  0x0++0x3
    line.long 0x00 "TOP_SW_IRQ2_STATUS, Indicates status of SW IRQ RESET:0x0"
         bitfld.long 0x00 0. " TOP_SW_IRQ2_STATUS_BIT0 ,None RESET:0x0"
          
         bitfld.long 0x00 1. " TOP_SW_IRQ2_STATUS_BIT1 ,None RESET:0x0"
          
         bitfld.long 0x00 2. " TOP_SW_IRQ2_STATUS_BIT2 ,None RESET:0x0"
          
         bitfld.long 0x00 3. " TOP_SW_IRQ2_STATUS_BIT3 ,None RESET:0x0"
          
         bitfld.long 0x00 4. " TOP_SW_IRQ2_STATUS_BIT4 ,None RESET:0x0"
          
         bitfld.long 0x00 5. " TOP_SW_IRQ2_STATUS_BIT5 ,None RESET:0x0"
          
         bitfld.long 0x00 6. " TOP_SW_IRQ2_STATUS_BIT6 ,None RESET:0x0"
          
         bitfld.long 0x00 7. " TOP_SW_IRQ2_STATUS_BIT7 ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "TOP_SW_IRQ2_STATUS_ENABLE, Enable mask to generate interrupt from status.bits RESET:0x0"
         bitfld.long 0x00 0. " TOP_SW_IRQ2_STATUS_ENABLE_BIT0 ,None RESET:0x0"
          
         bitfld.long 0x00 1. " TOP_SW_IRQ2_STATUS_ENABLE_BIT1 ,None RESET:0x0"
          
         bitfld.long 0x00 2. " TOP_SW_IRQ2_STATUS_ENABLE_BIT2 ,None RESET:0x0"
          
         bitfld.long 0x00 3. " TOP_SW_IRQ2_STATUS_ENABLE_BIT3 ,None RESET:0x0"
          
         bitfld.long 0x00 4. " TOP_SW_IRQ2_STATUS_ENABLE_BIT4 ,None RESET:0x0"
          
         bitfld.long 0x00 5. " TOP_SW_IRQ2_STATUS_ENABLE_BIT5 ,None RESET:0x0"
          
         bitfld.long 0x00 6. " TOP_SW_IRQ2_STATUS_ENABLE_BIT6 ,None RESET:0x0"
          
         bitfld.long 0x00 7. " TOP_SW_IRQ2_STATUS_ENABLE_BIT7 ,None RESET:0x0"
          
wgroup.long 0x8++0x3
    line.long 0x00 "TOP_SW_IRQ2_STATUS_SET, Set status register bits. If the corresponding bit in status_enable is 1, this will trigger an SW IRQ RESET:0x0"
         bitfld.long 0x00 0. " TOP_SW_IRQ2_STATUS_SET_BIT0 ,None RESET:0x0"
          
         bitfld.long 0x00 1. " TOP_SW_IRQ2_STATUS_SET_BIT1 ,None RESET:0x0"
          
         bitfld.long 0x00 2. " TOP_SW_IRQ2_STATUS_SET_BIT2 ,None RESET:0x0"
          
         bitfld.long 0x00 3. " TOP_SW_IRQ2_STATUS_SET_BIT3 ,None RESET:0x0"
          
         bitfld.long 0x00 4. " TOP_SW_IRQ2_STATUS_SET_BIT4 ,None RESET:0x0"
          
         bitfld.long 0x00 5. " TOP_SW_IRQ2_STATUS_SET_BIT5 ,None RESET:0x0"
          
         bitfld.long 0x00 6. " TOP_SW_IRQ2_STATUS_SET_BIT6 ,None RESET:0x0"
          
         bitfld.long 0x00 7. " TOP_SW_IRQ2_STATUS_SET_BIT7 ,None RESET:0x0"
          
tree.end

tree "ABB"
base e:0x41001000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ABB_TMUX_CTRL, ABB TMUX/ESD control using register RESET:0x1"
         bitfld.long 0x00 0. " ABB_TMUX_CTRL_EN ,Set '1' to enable the TMUX. Enabled by reset; cleared by software. RESET:0x1"
          
group.long  0x4++0x3
    line.long 0x00 "ABB_CTRL_0, ctrl_0 register RESET:0x1"
         bitfld.long 0x00 0. " ABB_CTRL_0_ENABLE ,Enabled/Disable RI_ABB control RESET:0x1"
          
         bitfld.long 0x00 1. " ABB_CTRL_0_OVERRIDE ,Override the Enable signal from the PMU RESET:0x0"
          
          
group.long  0x8++0x3
    line.long 0x00 "ABB_STATUS_0, status_0 register RESET:0x0"
         bitfld.long 0x00 0. " ABB_STATUS_0_REQ_STATUS ,Status Capture bit; write '1' to trigger capture of the status RESET:0x0"
          
         bitfld.long 0x00 1. " ABB_STATUS_0_LOCKED ,This register shows the locked state of RI_ABB controlling and the stable operation state of adaptive body bias controlled logic. The save operation state is reached if the LOCKED flag is high. RESET:0x0"
          
         bitfld.long 0x00 2. " ABB_STATUS_0_STATUS_VALID ,Status Valid bit. This bit will indicate that status capture is complete. This bit is cleared when a req_status is requested and set once status is valid RESET:0x0"
          
          
group.long  0xc++0x3
    line.long 0x00 "ABB_STATUS_1, status_1 register RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " ABB_STATUS_1_RINGO_COUNT_P ,This register bits shows the actually ring oscillator (type P) count value. RESET:0x0"
          
         hexmask.long 0x00 13.--25. 1. " ABB_STATUS_1_RINGO_COUNT_N ,This register bits shows the actually ring oscillator (type N) count value. RESET:0x0"
          
         bitfld.long 0x00 26. " ABB_STATUS_1_CALIB_DONE ,This register bit show the CALIBRATION_DONE flag RESET:0x0"
          
         bitfld.long 0x00 27. " ABB_STATUS_1_BIST_DONE ,This register bit show the BIST_DONE flag. RESET:0x0"
          
         bitfld.long 0x00 28. " ABB_STATUS_1_BIST_PASS ,This register bit show the BIST_PASS flag RESET:0x0"
          
          
group.long  0x10++0x3
    line.long 0x00 "ABB_ABB_0_CONFIG_CTRL_1, ctrl_1 register. Note: mode field is set for open-loop mode, other reset values are for low-performance mode with ABB = 50 MHz (unsued in open-loop mode). RESET:0x80f002"
         bitfld.long 0x00 0.--1. " ABB_ABB_0_CONFIG_CTRL_1_MODE ,Operation mode of RI_ABB controller: 00 = auto (default) 01 = single PVT monitor readout (for test) 10 = open loop PWM charge pump drive (for test) 11 = zero bias charge pump mode, both VNW and VPW pins are actively tied to VSS RESET:0x2" "MODE_AUTO-0,MODE_SINGLE_PVT-1,MODE_OPENLOOP_PWN_CP-2,MODE_ZERO_BIAS_CP-3"
          
         bitfld.long 0x00 2.--3. " ABB_ABB_0_CONFIG_CTRL_1_TESTMODE ,Test mode of RI_ABB controller: 00 = normal operation (default) 01 = PVT monitor test, testclock switched to internal ripple counter (see TIMER_CONFIG_VAL) 10 = ripple counter bist mode 11 = reserved RESET:0x0" "TESTMODE_NORMAL-0,TESTMODE_PVT_MON_TEST-1,TESTMODE_RIPPLE_CNT-2"
          
         bitfld.long 0x00 4.--5. " ABB_ABB_0_CONFIG_CTRL_1_STATUS_OUTPUT_SELECT ,Define the status output which can capture at status registers: 00 = ringo count value and calibration done flag set at ri_abb_status_o 01 = locked status information, preliminary feature debugging only 10 = filter status information, preliminary feature debugging only 11 = ring oscillator information, preliminary feature debugging only RESET:0x0" "RINGO_CNT_CAL-0,LOCKED_STATUS-1,FILTER_STATUS-2,RING_OSC-3"
          
          
         bitfld.long 0x00 8.--9. " ABB_ABB_0_CONFIG_CTRL_1_CHARGE_PUMP_SELECT_EN ,Enable additional charge pump slices thereby defining the drive strength of the body bias charge pump. The available settings depend on the drive strength option: When DS_X010:   Field value is not applicable, because one slice is always active. When DS_X030:   00 : no additional slice enabled   01 : second slice enabled   10 : third slice enabled   11 : second and third slice enabled RESET:0x0" "NONE-0,SECOND-1,THIRD-2,SECOND_THIRD-3"
          
         bitfld.long 0x00 10.--11. " ABB_ABB_0_CONFIG_CTRL_1_CHARGE_PUMP_SELECT_EN_LOCK ,Defines charge pump stages enabled during lock-in (before lock is detected). The available settings depend on the drive strength option: When DS_X010: Field value is not applicable, because one slice is always active. When DS_X030: 00 : no additional slice enabled 01 : second slice enabled 10 : third slice enabled 11 : second and third slice enabledOverride the Enable signal from the PMU RESET:0x0" "NONE-0,SECOND-1,THIRD-2,SECOND_THIRD-3"
          
         hexmask.long 0x00 12.--15. 1. " ABB_ABB_0_CONFIG_CTRL_1_PVTMON_CYCLES ,Configures the internal monitor. Please refer to ri_abb_gf22fdx_ref_value_specification or contact Racyics. RESET:0xf"
          
         hexmask.long 0x00 16.--31. 1. " ABB_ABB_0_CONFIG_CTRL_1_TIMER_CONFIG_VAL ,Defines the length of a closed loop control cycle. Note: Value also used for testmode; please refer to ri_abb_gf22fdx_datasheet or contact Racyics. RESET:0x80"
          
group.long  0x14++0x3
    line.long 0x00 "ABB_ABB_0_CONFIG_CTRL_2, ctrl_2 register. Note: reset values are for low-performance mode with ABB = 50 MHz (unsued in open-loop mode). RESET:0x71005f"
         hexmask.long 0x00 0.--12. 1. " ABB_ABB_0_CONFIG_CTRL_2_RINGO_TARGET_VAL_N ,Target performance for VNW biased devices. Value is defined by Racyics; please refer to ri_abb_gf22fdx_ref_value_specification or contact Racyics. RESET:0x5f"
          
          
         hexmask.long 0x00 16.--28. 1. " ABB_ABB_0_CONFIG_CTRL_2_RINGO_TARGET_VAL_P ,Target performance for VPW biased devices. Value is defined by Racyics; please refer to ri_abb_gf22fdx_ref_value_specification or contact Racyics. RESET:0x71"
          
          
group.long  0x18++0x3
    line.long 0x00 "ABB_ABB_0_CONFIG_CTRL_3, ctrl_3 register. Note: reset values are for low-performance mode with ABB = 50 MHz (unsued in open-loop mode). RESET:0xe2b1231"
         hexmask.long 0x00 0.--7. 1. " ABB_ABB_0_CONFIG_CTRL_3_LOCK_RANGE_HIGH_P ,Lock range high boundary for VPW biased devices. Please refer to the ri_abb_gf22fdx_ref_value_specification” document or contact Racyics. RESET:0x31"
          
         hexmask.long 0x00 8.--15. 1. " ABB_ABB_0_CONFIG_CTRL_3_LOCK_RANGE_LOW_P ,Lock range low boundary for VPW biased devices. Please refer to the ri_abb_gf22fdx_ref_value_specification” document or contact Racyics. RESET:0x12"
          
         hexmask.long 0x00 16.--23. 1. " ABB_ABB_0_CONFIG_CTRL_3_LOCK_RANGE_HIGH_N ,Lock range high boundary for VNW biased devices. Please refer to the ri_abb_gf22fdx_ref_value_specification” document or contact Racyics. RESET:0x2b"
          
         hexmask.long 0x00 24.--31. 1. " ABB_ABB_0_CONFIG_CTRL_3_LOCK_RANGE_LOW_N ,Lock range low boundary for VNW biased devices. Please refer to the ri_abb_gf22fdx_ref_value_specification” document or contact Racyics. RESET:0xe"
          
group.long  0x1c++0x3
    line.long 0x00 "ABB_ABB_0_CONFIG_CTRL_4, ctrl_4 register. Note: cp field reset value is set for open-loop mode. RESET:0x57fff"
         hexmask.long 0x00 0.--15. 1. " ABB_ABB_0_CONFIG_CTRL_4_CP ,Proportional path coefficient of the closed loop body bias controller. RESET:0x7fff"
          
         hexmask.long 0x00 16.--18. 1. " ABB_ABB_0_CONFIG_CTRL_4_CI ,Integral path coefficient of the closed loop body bias controller. Value also used in open loop mode; please refer to ri_abb_gf22fdx_datasheet. RESET:0x5"
          
          
group.long  0x20++0x3
    line.long 0x00 "ABB_ABB_0_CONFIG_VENDOR_0, vendor_0 register RESET:0xf60c0008"
         hexmask.long 0x00 0.--17. 1. " ABB_ABB_0_CONFIG_VENDOR_0_VENDOR_RESERVED_0 ,vendor_reserved_0 RESET:0x8"
          
         hexmask.long 0x00 18.--19. 1. " ABB_ABB_0_CONFIG_VENDOR_0_VENDOR_RESERVED_1 ,vendor_reserved_1 RESET:0x3"
          
         hexmask.long 0x00 20.--23. 1. " ABB_ABB_0_CONFIG_VENDOR_0_VENDOR_RESERVED_2 ,vendor_reserved_2 RESET:0x0"
          
         bitfld.long 0x00 24. " ABB_ABB_0_CONFIG_VENDOR_0_VENDOR_RESERVED_3 ,vendor_reserved_3 RESET:0x0"
          
         hexmask.long 0x00 25.--27. 1. " ABB_ABB_0_CONFIG_VENDOR_0_VENDOR_RESERVED_4 ,vendor_reserved_4 RESET:0x3"
          
         hexmask.long 0x00 28.--30. 1. " ABB_ABB_0_CONFIG_VENDOR_0_SLOPE_CNT ,slope count : depends on selected XO10,20,30 and biased Area[mmm2] / refer to ri_abb_gf22fdx_datasheet RESET:0x7"
          
         bitfld.long 0x00 31. " ABB_ABB_0_CONFIG_VENDOR_0_VENDOR_RESERVED_5 ,vendor_reserved_5, bit 3 RESET:0x1"
          
group.long  0x24++0x3
    line.long 0x00 "ABB_ABB_0_CONFIG_VENDOR_1, vendor_1 register RESET:0x129fb"
         hexmask.long 0x00 0.--20. 1. " ABB_ABB_0_CONFIG_VENDOR_1_VENDOR_RESERVED_5 ,vendor_reserved_5, bits 24:4 RESET:0x129fb"
          
          
group.long  0x28++0x3
    line.long 0x00 "ABB_ABB_1_CONFIG_CTRL_1, ctrl_1 register. Note: reset values are for high-performance mode with ABB = 50 MHz. RESET:0x804000"
         bitfld.long 0x00 0.--1. " ABB_ABB_1_CONFIG_CTRL_1_MODE ,Operation mode of RI_ABB controller: 00 = auto (default) 01 = single PVT monitor readout (for test) 10 = open loop PWM charge pump drive (for test) 11 = zero bias charge pump mode, both VNW and VPW pins are actively tied to VSS RESET:0x0" "MODE_AUTO-0,MODE_SINGLE_PVT-1,MODE_OPENLOOP_PWN_CP-2,MODE_ZERO_BIAS_CP-3"
          
         bitfld.long 0x00 2.--3. " ABB_ABB_1_CONFIG_CTRL_1_TESTMODE ,Test mode of RI_ABB controller: 00 = normal operation (default) 01 = PVT monitor test, testclock switched to internal ripple counter (see TIMER_CONFIG_VAL) 10 = ripple counter bist mode 11 = reserved RESET:0x0" "TESTMODE_NORMAL-0,TESTMODE_PVT_MON_TEST-1,TESTMODE_RIPPLE_CNT-2"
          
         bitfld.long 0x00 4.--5. " ABB_ABB_1_CONFIG_CTRL_1_STATUS_OUTPUT_SELECT ,Define the status output which can capture at status registers: 00 = ringo count value and calibration done flag set at ri_abb_status_o 01 = locked status information, preliminary feature debugging only 10 = filter status information, preliminary feature debugging only 11 = ring oscillator information, preliminary feature debugging only RESET:0x0" "RINGO_CNT_CAL-0,LOCKED_STATUS-1,FILTER_STATUS-2,RING_OSC-3"
          
          
         bitfld.long 0x00 8.--9. " ABB_ABB_1_CONFIG_CTRL_1_CHARGE_PUMP_SELECT_EN ,Enable additional charge pump slices thereby defining the drive strength of the body bias charge pump. The available settings depend on the drive strength option: When DS_X010:   Field value is not applicable, because one slice is always active. When DS_X030:   00 : no additional slice enabled   01 : second slice enabled   10 : third slice enabled   11 : second and third slice enabled RESET:0x0" "NONE-0,SECOND-1,THIRD-2,SECOND_THIRD-3"
          
         bitfld.long 0x00 10.--11. " ABB_ABB_1_CONFIG_CTRL_1_CHARGE_PUMP_SELECT_EN_LOCK ,Defines charge pump stages enabled during lock-in (before lock is detected). The available settings depend on the drive strength option: When DS_X010: Field value is not applicable, because one slice is always active. When DS_X030: 00 : no additional slice enabled 01 : second slice enabled 10 : third slice enabled 11 : second and third slice enabledOverride the Enable signal from the PMU RESET:0x0" "NONE-0,SECOND-1,THIRD-2,SECOND_THIRD-3"
          
         hexmask.long 0x00 12.--15. 1. " ABB_ABB_1_CONFIG_CTRL_1_PVTMON_CYCLES ,Configures the internal monitor. Please refer to ri_abb_gf22fdx_ref_value_specification or contact Racyics. RESET:0x4"
          
         hexmask.long 0x00 16.--31. 1. " ABB_ABB_1_CONFIG_CTRL_1_TIMER_CONFIG_VAL ,Defines the length of a closed loop control cycle. Note: Value also used for testmode; please refer to ri_abb_gf22fdx_datasheet or contact Racyics. RESET:0x80"
          
group.long  0x2c++0x3
    line.long 0x00 "ABB_ABB_1_CONFIG_CTRL_2, ctrl_2 register. Note: reset values are for high-performance mode with ABB = 50 MHz. RESET:0x760071"
         hexmask.long 0x00 0.--12. 1. " ABB_ABB_1_CONFIG_CTRL_2_RINGO_TARGET_VAL_N ,Target performance for VNW biased devices. Value is defined by Racyics; please refer to ri_abb_gf22fdx_ref_value_specification or contact Racyics. RESET:0x71"
          
          
         hexmask.long 0x00 16.--28. 1. " ABB_ABB_1_CONFIG_CTRL_2_RINGO_TARGET_VAL_P ,Target performance for VPW biased devices. Value is defined by Racyics; please refer to ri_abb_gf22fdx_ref_value_specification or contact Racyics. RESET:0x76"
          
          
group.long  0x30++0x3
    line.long 0x00 "ABB_ABB_1_CONFIG_CTRL_3, ctrl_3 register. Note: reset values are for high-performance mode with ABB = 50 MHz. RESET:0x152c172e"
         hexmask.long 0x00 0.--7. 1. " ABB_ABB_1_CONFIG_CTRL_3_LOCK_RANGE_HIGH_P ,Lock range high boundary for VPW biased devices. Please refer to the ri_abb_gf22fdx_ref_value_specification” document or contact Racyics. RESET:0x2e"
          
         hexmask.long 0x00 8.--15. 1. " ABB_ABB_1_CONFIG_CTRL_3_LOCK_RANGE_LOW_P ,Lock range low boundary for VPW biased devices. Please refer to the ri_abb_gf22fdx_ref_value_specification” document or contact Racyics. RESET:0x17"
          
         hexmask.long 0x00 16.--23. 1. " ABB_ABB_1_CONFIG_CTRL_3_LOCK_RANGE_HIGH_N ,Lock range high boundary for VNW biased devices. Please refer to the ri_abb_gf22fdx_ref_value_specification” document or contact Racyics. RESET:0x2c"
          
         hexmask.long 0x00 24.--31. 1. " ABB_ABB_1_CONFIG_CTRL_3_LOCK_RANGE_LOW_N ,Lock range low boundary for VNW biased devices. Please refer to the ri_abb_gf22fdx_ref_value_specification” document or contact Racyics. RESET:0x15"
          
group.long  0x34++0x3
    line.long 0x00 "ABB_ABB_1_CONFIG_CTRL_4, ctrl_4 register RESET:0x50800"
         hexmask.long 0x00 0.--15. 1. " ABB_ABB_1_CONFIG_CTRL_4_CP ,Proportional path coefficient of the closed loop body bias controller. RESET:0x800"
          
         hexmask.long 0x00 16.--18. 1. " ABB_ABB_1_CONFIG_CTRL_4_CI ,Integral path coefficient of the closed loop body bias controller. Value also used in open loop mode; please refer to ri_abb_gf22fdx_datasheet. RESET:0x5"
          
          
group.long  0x38++0x3
    line.long 0x00 "ABB_ABB_1_CONFIG_VENDOR_0, vendor_0 register RESET:0xf60c0008"
         hexmask.long 0x00 0.--17. 1. " ABB_ABB_1_CONFIG_VENDOR_0_VENDOR_RESERVED_0 ,vendor_reserved_0 RESET:0x8"
          
         hexmask.long 0x00 18.--19. 1. " ABB_ABB_1_CONFIG_VENDOR_0_VENDOR_RESERVED_1 ,vendor_reserved_1 RESET:0x3"
          
         hexmask.long 0x00 20.--23. 1. " ABB_ABB_1_CONFIG_VENDOR_0_VENDOR_RESERVED_2 ,vendor_reserved_2 RESET:0x0"
          
         bitfld.long 0x00 24. " ABB_ABB_1_CONFIG_VENDOR_0_VENDOR_RESERVED_3 ,vendor_reserved_3 RESET:0x0"
          
         hexmask.long 0x00 25.--27. 1. " ABB_ABB_1_CONFIG_VENDOR_0_VENDOR_RESERVED_4 ,vendor_reserved_4 RESET:0x3"
          
         hexmask.long 0x00 28.--30. 1. " ABB_ABB_1_CONFIG_VENDOR_0_SLOPE_CNT ,slope count : depends on selected XO10,20,30 and biased Area[mmm2] / refer to ri_abb_gf22fdx_datasheet RESET:0x7"
          
         bitfld.long 0x00 31. " ABB_ABB_1_CONFIG_VENDOR_0_VENDOR_RESERVED_5 ,vendor_reserved_5, bit 3 RESET:0x1"
          
group.long  0x3c++0x3
    line.long 0x00 "ABB_ABB_1_CONFIG_VENDOR_1, vendor_1 register RESET:0x129fb"
         hexmask.long 0x00 0.--20. 1. " ABB_ABB_1_CONFIG_VENDOR_1_VENDOR_RESERVED_5 ,vendor_reserved_5, bits 24:4 RESET:0x129fb"
          
          
group.long  0x40++0x3
    line.long 0x00 "ABB_BYPASS_EN, bypass_en register RESET:0x0"
         bitfld.long 0x00 0. " ABB_BYPASS_EN_ABB_LOCKED ,Enable abb_locked Bypass RESET:0x0"
          
group.long  0x44++0x3
    line.long 0x00 "ABB_BYPASS_VAL, bypass_val register RESET:0x0"
         bitfld.long 0x00 0. " ABB_BYPASS_VAL_ABB_LOCKED ,abb_locked value (in Bypass Mode) RESET:0x0"
          
tree.end

tree "GPIO_MUX"
base e:0x41002000
width 80.
group.long  0x0++0x3
    line.long 0x00 "GPIO_MUX_CLK_REF_I_CTRL, None RESET:0x448"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_CLK_REF_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_CLK_REF_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_CLK_REF_I_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_CLK_REF_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_CLK_REF_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_CLK_REF_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_CLK_REF_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_CLK_REF_I_CTRL_STE ,None RESET:0x1"
          
         bitfld.long 0x00 12. " GPIO_MUX_CLK_REF_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "GPIO_MUX_EN_XTAL_32K_BYP_I_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_EN_XTAL_32K_BYP_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_EN_XTAL_32K_BYP_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_EN_XTAL_32K_BYP_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_EN_XTAL_32K_BYP_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_EN_XTAL_32K_BYP_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_EN_XTAL_32K_BYP_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_EN_XTAL_32K_BYP_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_EN_XTAL_32K_BYP_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_EN_XTAL_32K_BYP_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "GPIO_MUX_CLK_OUT_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_CLK_OUT_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_CLK_OUT_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_CLK_OUT_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_CLK_OUT_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_CLK_OUT_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_CLK_OUT_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_CLK_OUT_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_CLK_OUT_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_CLK_OUT_O_CTRL_DO_SEL ,None RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "GPIO_MUX_RESET_N_I_CTRL, None RESET:0x448"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_RESET_N_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 6. " GPIO_MUX_RESET_N_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_RESET_N_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_RESET_N_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_RESET_N_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_RESET_N_I_CTRL_STE ,None RESET:0x1"
          
         bitfld.long 0x00 12. " GPIO_MUX_RESET_N_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "GPIO_MUX_EN_CLK_REF_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_EN_CLK_REF_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_EN_CLK_REF_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_EN_CLK_REF_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_EN_CLK_REF_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_EN_CLK_REF_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_EN_CLK_REF_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_EN_CLK_REF_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_EN_CLK_REF_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_EN_CLK_REF_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "GPIO_MUX_SEL_CLK_REF_I_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_SEL_CLK_REF_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_SEL_CLK_REF_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_SEL_CLK_REF_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_SEL_CLK_REF_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_SEL_CLK_REF_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_SEL_CLK_REF_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_SEL_CLK_REF_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_SEL_CLK_REF_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_SEL_CLK_REF_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "GPIO_MUX_BOOT_MODE0_I_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_BOOT_MODE0_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_BOOT_MODE0_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_BOOT_MODE0_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_BOOT_MODE0_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_BOOT_MODE0_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_BOOT_MODE0_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_BOOT_MODE0_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_BOOT_MODE0_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_BOOT_MODE0_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "GPIO_MUX_BOOT_MODE1_I_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_BOOT_MODE1_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_BOOT_MODE1_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_BOOT_MODE1_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_BOOT_MODE1_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_BOOT_MODE1_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_BOOT_MODE1_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_BOOT_MODE1_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_BOOT_MODE1_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_BOOT_MODE1_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "GPIO_MUX_EN_PWRGEN_I_CTRL, None RESET:0x58"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_EN_PWRGEN_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_EN_PWRGEN_I_CTRL_PU_EN ,None RESET:0x1"
          
         bitfld.long 0x00 5. " GPIO_MUX_EN_PWRGEN_I_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_EN_PWRGEN_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_EN_PWRGEN_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_EN_PWRGEN_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_EN_PWRGEN_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_EN_PWRGEN_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_EN_PWRGEN_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "GPIO_MUX_FLL_LOCK_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_FLL_LOCK_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_FLL_LOCK_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_FLL_LOCK_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_FLL_LOCK_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_FLL_LOCK_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_FLL_LOCK_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_FLL_LOCK_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_FLL_LOCK_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_FLL_LOCK_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "GPIO_MUX_GPIO0_B_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_GPIO0_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_GPIO0_B_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_GPIO0_B_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_GPIO0_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_GPIO0_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_GPIO0_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_GPIO0_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_GPIO0_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_GPIO0_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "GPIO_MUX_GPIO1_B_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_GPIO1_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_GPIO1_B_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_GPIO1_B_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_GPIO1_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_GPIO1_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_GPIO1_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_GPIO1_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_GPIO1_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_GPIO1_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "GPIO_MUX_GPIO2_B_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_GPIO2_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_GPIO2_B_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_GPIO2_B_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_GPIO2_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_GPIO2_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_GPIO2_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_GPIO2_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_GPIO2_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_GPIO2_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "GPIO_MUX_GPIO3_B_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_GPIO3_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_GPIO3_B_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_GPIO3_B_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_GPIO3_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_GPIO3_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_GPIO3_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_GPIO3_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_GPIO3_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_GPIO3_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "GPIO_MUX_GPIO4_B_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_GPIO4_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_GPIO4_B_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_GPIO4_B_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_GPIO4_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_GPIO4_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_GPIO4_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_GPIO4_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_GPIO4_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_GPIO4_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "GPIO_MUX_GPIO5_B_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_GPIO5_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_GPIO5_B_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_GPIO5_B_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_GPIO5_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_GPIO5_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_GPIO5_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_GPIO5_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_GPIO5_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_GPIO5_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "GPIO_MUX_GPIO6_B_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_GPIO6_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_GPIO6_B_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_GPIO6_B_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_GPIO6_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_GPIO6_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_GPIO6_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_GPIO6_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_GPIO6_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_GPIO6_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x44++0x3
    line.long 0x00 "GPIO_MUX_GPIO7_B_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_GPIO7_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_GPIO7_B_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_GPIO7_B_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_GPIO7_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_GPIO7_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_GPIO7_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_GPIO7_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_GPIO7_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_GPIO7_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "GPIO_MUX_GPIO8_B_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_GPIO8_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_GPIO8_B_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_GPIO8_B_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_GPIO8_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_GPIO8_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_GPIO8_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_GPIO8_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_GPIO8_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_GPIO8_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "GPIO_MUX_GPIO9_B_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_GPIO9_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_GPIO9_B_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_GPIO9_B_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_GPIO9_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_GPIO9_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_GPIO9_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_GPIO9_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_GPIO9_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_GPIO9_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "GPIO_MUX_GPO10_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_GPO10_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_GPO10_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_GPO10_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_GPO10_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_GPO10_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_GPO10_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_GPO10_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_GPO10_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_GPO10_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x54++0x3
    line.long 0x00 "GPIO_MUX_UART_TX_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_UART_TX_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_UART_TX_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_UART_TX_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_UART_TX_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_UART_TX_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_UART_TX_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_UART_TX_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_UART_TX_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_UART_TX_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "GPIO_MUX_UART_RX_I_CTRL, None RESET:0x58"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_UART_RX_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_UART_RX_I_CTRL_PU_EN ,None RESET:0x1"
          
         bitfld.long 0x00 5. " GPIO_MUX_UART_RX_I_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_UART_RX_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_UART_RX_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_UART_RX_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_UART_RX_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_UART_RX_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_UART_RX_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x5c++0x3
    line.long 0x00 "GPIO_MUX_SWDIO_B_CTRL, None RESET:0x58"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_SWDIO_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_SWDIO_B_CTRL_PU_EN ,None RESET:0x1"
          
         bitfld.long 0x00 5. " GPIO_MUX_SWDIO_B_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_SWDIO_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_SWDIO_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_SWDIO_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_SWDIO_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_SWDIO_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_SWDIO_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "GPIO_MUX_SWCLK_I_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_SWCLK_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_SWCLK_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_SWCLK_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_SWCLK_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_SWCLK_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_SWCLK_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_SWCLK_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_SWCLK_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_SWCLK_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "GPIO_MUX_JTAG_TCK_I_CTRL, None RESET:0x868"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_JTAG_TCK_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_JTAG_TCK_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_JTAG_TCK_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_JTAG_TCK_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_JTAG_TCK_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_JTAG_TCK_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_JTAG_TCK_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_JTAG_TCK_I_CTRL_STE ,None RESET:0x2"
          
         bitfld.long 0x00 12. " GPIO_MUX_JTAG_TCK_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x68++0x3
    line.long 0x00 "GPIO_MUX_JTAG_TMS_I_CTRL, None RESET:0x58"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_JTAG_TMS_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_JTAG_TMS_I_CTRL_PU_EN ,None RESET:0x1"
          
         bitfld.long 0x00 5. " GPIO_MUX_JTAG_TMS_I_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_JTAG_TMS_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_JTAG_TMS_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_JTAG_TMS_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_JTAG_TMS_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_JTAG_TMS_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_JTAG_TMS_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x6c++0x3
    line.long 0x00 "GPIO_MUX_JTAG_TDI_I_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_JTAG_TDI_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_JTAG_TDI_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_JTAG_TDI_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_JTAG_TDI_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_JTAG_TDI_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_JTAG_TDI_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_JTAG_TDI_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_JTAG_TDI_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_JTAG_TDI_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x70++0x3
    line.long 0x00 "GPIO_MUX_JTAG_TDO_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_JTAG_TDO_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_JTAG_TDO_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_JTAG_TDO_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_JTAG_TDO_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_JTAG_TDO_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_JTAG_TDO_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_JTAG_TDO_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_JTAG_TDO_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_JTAG_TDO_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x74++0x3
    line.long 0x00 "GPIO_MUX_JTAG_TRSTN_I_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_JTAG_TRSTN_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_JTAG_TRSTN_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_JTAG_TRSTN_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_JTAG_TRSTN_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_JTAG_TRSTN_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_JTAG_TRSTN_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_JTAG_TRSTN_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_JTAG_TRSTN_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_JTAG_TRSTN_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x78++0x3
    line.long 0x00 "GPIO_MUX_QSPI_DISP_SCLK_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_QSPI_DISP_SCLK_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_QSPI_DISP_SCLK_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_QSPI_DISP_SCLK_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_QSPI_DISP_SCLK_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_QSPI_DISP_SCLK_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_QSPI_DISP_SCLK_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_QSPI_DISP_SCLK_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_QSPI_DISP_SCLK_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_QSPI_DISP_SCLK_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x7c++0x3
    line.long 0x00 "GPIO_MUX_QSPI_DISP_SSN_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_QSPI_DISP_SSN_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_QSPI_DISP_SSN_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_QSPI_DISP_SSN_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_QSPI_DISP_SSN_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_QSPI_DISP_SSN_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_QSPI_DISP_SSN_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_QSPI_DISP_SSN_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_QSPI_DISP_SSN_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_QSPI_DISP_SSN_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x80++0x3
    line.long 0x00 "GPIO_MUX_QSPI_DISP_IO0_B_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_QSPI_DISP_IO0_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_QSPI_DISP_IO0_B_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_QSPI_DISP_IO0_B_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_QSPI_DISP_IO0_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_QSPI_DISP_IO0_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_QSPI_DISP_IO0_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_QSPI_DISP_IO0_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_QSPI_DISP_IO0_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_QSPI_DISP_IO0_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x84++0x3
    line.long 0x00 "GPIO_MUX_QSPI_DISP_IO1_B_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_QSPI_DISP_IO1_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_QSPI_DISP_IO1_B_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_QSPI_DISP_IO1_B_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_QSPI_DISP_IO1_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_QSPI_DISP_IO1_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_QSPI_DISP_IO1_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_QSPI_DISP_IO1_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_QSPI_DISP_IO1_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_QSPI_DISP_IO1_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x88++0x3
    line.long 0x00 "GPIO_MUX_QSPI_DISP_IO2_B_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_QSPI_DISP_IO2_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_QSPI_DISP_IO2_B_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_QSPI_DISP_IO2_B_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_QSPI_DISP_IO2_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_QSPI_DISP_IO2_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_QSPI_DISP_IO2_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_QSPI_DISP_IO2_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_QSPI_DISP_IO2_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_QSPI_DISP_IO2_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x8c++0x3
    line.long 0x00 "GPIO_MUX_QSPI_DISP_IO3_B_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_QSPI_DISP_IO3_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_QSPI_DISP_IO3_B_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_QSPI_DISP_IO3_B_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_QSPI_DISP_IO3_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_QSPI_DISP_IO3_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_QSPI_DISP_IO3_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_QSPI_DISP_IO3_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_QSPI_DISP_IO3_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_QSPI_DISP_IO3_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x90++0x3
    line.long 0x00 "GPIO_MUX_SPI_M_SCLK_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_SPI_M_SCLK_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_SPI_M_SCLK_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_SPI_M_SCLK_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_SPI_M_SCLK_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_SPI_M_SCLK_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_SPI_M_SCLK_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_SPI_M_SCLK_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_SPI_M_SCLK_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_SPI_M_SCLK_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x94++0x3
    line.long 0x00 "GPIO_MUX_SPI_M_MOSI_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_SPI_M_MOSI_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_SPI_M_MOSI_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_SPI_M_MOSI_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_SPI_M_MOSI_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_SPI_M_MOSI_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_SPI_M_MOSI_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_SPI_M_MOSI_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_SPI_M_MOSI_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_SPI_M_MOSI_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x98++0x3
    line.long 0x00 "GPIO_MUX_SPI_M_MISO_I_CTRL, None RESET:0x58"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_SPI_M_MISO_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_SPI_M_MISO_I_CTRL_PU_EN ,None RESET:0x1"
          
         bitfld.long 0x00 5. " GPIO_MUX_SPI_M_MISO_I_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_SPI_M_MISO_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_SPI_M_MISO_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_SPI_M_MISO_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_SPI_M_MISO_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_SPI_M_MISO_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_SPI_M_MISO_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x9c++0x3
    line.long 0x00 "GPIO_MUX_IRSPI_M_SCLK_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_IRSPI_M_SCLK_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_IRSPI_M_SCLK_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_IRSPI_M_SCLK_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_IRSPI_M_SCLK_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_IRSPI_M_SCLK_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_IRSPI_M_SCLK_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_IRSPI_M_SCLK_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_IRSPI_M_SCLK_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_IRSPI_M_SCLK_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xa0++0x3
    line.long 0x00 "GPIO_MUX_IRSPI_M_MOSI_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_IRSPI_M_MOSI_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_IRSPI_M_MOSI_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_IRSPI_M_MOSI_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_IRSPI_M_MOSI_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_IRSPI_M_MOSI_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_IRSPI_M_MOSI_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_IRSPI_M_MOSI_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_IRSPI_M_MOSI_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_IRSPI_M_MOSI_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xa4++0x3
    line.long 0x00 "GPIO_MUX_IRSPI_M_MISO_I_CTRL, None RESET:0x58"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_IRSPI_M_MISO_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_IRSPI_M_MISO_I_CTRL_PU_EN ,None RESET:0x1"
          
         bitfld.long 0x00 5. " GPIO_MUX_IRSPI_M_MISO_I_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_IRSPI_M_MISO_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_IRSPI_M_MISO_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_IRSPI_M_MISO_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_IRSPI_M_MISO_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_IRSPI_M_MISO_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_IRSPI_M_MISO_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xa8++0x3
    line.long 0x00 "GPIO_MUX_IRSPI_M_SSN_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_IRSPI_M_SSN_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_IRSPI_M_SSN_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_IRSPI_M_SSN_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_IRSPI_M_SSN_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_IRSPI_M_SSN_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_IRSPI_M_SSN_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_IRSPI_M_SSN_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_IRSPI_M_SSN_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_IRSPI_M_SSN_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xac++0x3
    line.long 0x00 "GPIO_MUX_BTSPI_M_SCLK_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_BTSPI_M_SCLK_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_BTSPI_M_SCLK_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_BTSPI_M_SCLK_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_BTSPI_M_SCLK_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_BTSPI_M_SCLK_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_BTSPI_M_SCLK_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_BTSPI_M_SCLK_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_BTSPI_M_SCLK_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_BTSPI_M_SCLK_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xb0++0x3
    line.long 0x00 "GPIO_MUX_BTSPI_M_MOSI_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_BTSPI_M_MOSI_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_BTSPI_M_MOSI_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_BTSPI_M_MOSI_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_BTSPI_M_MOSI_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_BTSPI_M_MOSI_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_BTSPI_M_MOSI_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_BTSPI_M_MOSI_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_BTSPI_M_MOSI_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_BTSPI_M_MOSI_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xb4++0x3
    line.long 0x00 "GPIO_MUX_BTSPI_M_MISO_I_CTRL, None RESET:0x58"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_BTSPI_M_MISO_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_BTSPI_M_MISO_I_CTRL_PU_EN ,None RESET:0x1"
          
         bitfld.long 0x00 5. " GPIO_MUX_BTSPI_M_MISO_I_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_BTSPI_M_MISO_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_BTSPI_M_MISO_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_BTSPI_M_MISO_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_BTSPI_M_MISO_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_BTSPI_M_MISO_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_BTSPI_M_MISO_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xb8++0x3
    line.long 0x00 "GPIO_MUX_DECTSPI_M_SCLK_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_DECTSPI_M_SCLK_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_DECTSPI_M_SCLK_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_DECTSPI_M_SCLK_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_DECTSPI_M_SCLK_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_DECTSPI_M_SCLK_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_DECTSPI_M_SCLK_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_DECTSPI_M_SCLK_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_DECTSPI_M_SCLK_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_DECTSPI_M_SCLK_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xbc++0x3
    line.long 0x00 "GPIO_MUX_DECTSPI_M_MOSI_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_DECTSPI_M_MOSI_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_DECTSPI_M_MOSI_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_DECTSPI_M_MOSI_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_DECTSPI_M_MOSI_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_DECTSPI_M_MOSI_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_DECTSPI_M_MOSI_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_DECTSPI_M_MOSI_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_DECTSPI_M_MOSI_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_DECTSPI_M_MOSI_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xc0++0x3
    line.long 0x00 "GPIO_MUX_DECTSPI_M_MISO_I_CTRL, None RESET:0x58"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_DECTSPI_M_MISO_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_DECTSPI_M_MISO_I_CTRL_PU_EN ,None RESET:0x1"
          
         bitfld.long 0x00 5. " GPIO_MUX_DECTSPI_M_MISO_I_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_DECTSPI_M_MISO_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_DECTSPI_M_MISO_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_DECTSPI_M_MISO_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_DECTSPI_M_MISO_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_DECTSPI_M_MISO_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_DECTSPI_M_MISO_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xc4++0x3
    line.long 0x00 "GPIO_MUX_DECTSPI_S_SCLK_I_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_DECTSPI_S_SCLK_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_DECTSPI_S_SCLK_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_DECTSPI_S_SCLK_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_DECTSPI_S_SCLK_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_DECTSPI_S_SCLK_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_DECTSPI_S_SCLK_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_DECTSPI_S_SCLK_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_DECTSPI_S_SCLK_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_DECTSPI_S_SCLK_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xc8++0x3
    line.long 0x00 "GPIO_MUX_DECTSPI_S_MOSI_I_CTRL, None RESET:0x58"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_DECTSPI_S_MOSI_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_DECTSPI_S_MOSI_I_CTRL_PU_EN ,None RESET:0x1"
          
         bitfld.long 0x00 5. " GPIO_MUX_DECTSPI_S_MOSI_I_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_DECTSPI_S_MOSI_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_DECTSPI_S_MOSI_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_DECTSPI_S_MOSI_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_DECTSPI_S_MOSI_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_DECTSPI_S_MOSI_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_DECTSPI_S_MOSI_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xcc++0x3
    line.long 0x00 "GPIO_MUX_DECTSPI_S_MISO_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_DECTSPI_S_MISO_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_DECTSPI_S_MISO_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_DECTSPI_S_MISO_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_DECTSPI_S_MISO_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_DECTSPI_S_MISO_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_DECTSPI_S_MISO_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_DECTSPI_S_MISO_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_DECTSPI_S_MISO_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_DECTSPI_S_MISO_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xd0++0x3
    line.long 0x00 "GPIO_MUX_DECTSPI_S_SSN_I_CTRL, None RESET:0x58"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_DECTSPI_S_SSN_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_DECTSPI_S_SSN_I_CTRL_PU_EN ,None RESET:0x1"
          
         bitfld.long 0x00 5. " GPIO_MUX_DECTSPI_S_SSN_I_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_DECTSPI_S_SSN_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_DECTSPI_S_SSN_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_DECTSPI_S_SSN_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_DECTSPI_S_SSN_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_DECTSPI_S_SSN_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_DECTSPI_S_SSN_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xd4++0x3
    line.long 0x00 "GPIO_MUX_I2C_M_SCL_B_CTRL, None RESET:0x58"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_I2C_M_SCL_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_I2C_M_SCL_B_CTRL_PU_EN ,None RESET:0x1"
          
         bitfld.long 0x00 5. " GPIO_MUX_I2C_M_SCL_B_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_I2C_M_SCL_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_I2C_M_SCL_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_I2C_M_SCL_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_I2C_M_SCL_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_I2C_M_SCL_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_I2C_M_SCL_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xd8++0x3
    line.long 0x00 "GPIO_MUX_I2C_M_SDA_B_CTRL, None RESET:0x58"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_I2C_M_SDA_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_I2C_M_SDA_B_CTRL_PU_EN ,None RESET:0x1"
          
         bitfld.long 0x00 5. " GPIO_MUX_I2C_M_SDA_B_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_I2C_M_SDA_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_I2C_M_SDA_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_I2C_M_SDA_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_I2C_M_SDA_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_I2C_M_SDA_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_I2C_M_SDA_B_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xdc++0x3
    line.long 0x00 "GPIO_MUX_I2S_S1_SCK_I_CTRL, None RESET:0x468"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_I2S_S1_SCK_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_I2S_S1_SCK_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_I2S_S1_SCK_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_I2S_S1_SCK_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_I2S_S1_SCK_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_I2S_S1_SCK_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_I2S_S1_SCK_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_I2S_S1_SCK_I_CTRL_STE ,None RESET:0x1"
          
         bitfld.long 0x00 12. " GPIO_MUX_I2S_S1_SCK_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xe0++0x3
    line.long 0x00 "GPIO_MUX_I2S_S1_SD_I_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_I2S_S1_SD_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_I2S_S1_SD_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_I2S_S1_SD_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_I2S_S1_SD_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_I2S_S1_SD_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_I2S_S1_SD_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_I2S_S1_SD_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_I2S_S1_SD_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_I2S_S1_SD_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xe4++0x3
    line.long 0x00 "GPIO_MUX_I2S_S1_WS_I_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_I2S_S1_WS_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_I2S_S1_WS_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_I2S_S1_WS_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_I2S_S1_WS_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_I2S_S1_WS_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_I2S_S1_WS_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_I2S_S1_WS_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_I2S_S1_WS_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_I2S_S1_WS_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xe8++0x3
    line.long 0x00 "GPIO_MUX_I2S_S2_SCK_I_CTRL, None RESET:0x468"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_I2S_S2_SCK_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_I2S_S2_SCK_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_I2S_S2_SCK_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_I2S_S2_SCK_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_I2S_S2_SCK_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_I2S_S2_SCK_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_I2S_S2_SCK_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_I2S_S2_SCK_I_CTRL_STE ,None RESET:0x1"
          
         bitfld.long 0x00 12. " GPIO_MUX_I2S_S2_SCK_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xec++0x3
    line.long 0x00 "GPIO_MUX_I2S_S2_SD_I_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_I2S_S2_SD_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_I2S_S2_SD_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_I2S_S2_SD_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_I2S_S2_SD_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_I2S_S2_SD_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_I2S_S2_SD_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_I2S_S2_SD_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_I2S_S2_SD_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_I2S_S2_SD_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xf0++0x3
    line.long 0x00 "GPIO_MUX_I2S_S2_WS_I_CTRL, None RESET:0x68"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_I2S_S2_WS_I_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_I2S_S2_WS_I_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_I2S_S2_WS_I_CTRL_PD_EN ,None RESET:0x1"
          
         bitfld.long 0x00 6. " GPIO_MUX_I2S_S2_WS_I_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_I2S_S2_WS_I_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_I2S_S2_WS_I_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_I2S_S2_WS_I_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_I2S_S2_WS_I_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_I2S_S2_WS_I_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xf4++0x3
    line.long 0x00 "GPIO_MUX_I2S_M_SCK_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_I2S_M_SCK_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_I2S_M_SCK_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_I2S_M_SCK_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_I2S_M_SCK_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_I2S_M_SCK_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_I2S_M_SCK_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_I2S_M_SCK_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_I2S_M_SCK_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_I2S_M_SCK_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xf8++0x3
    line.long 0x00 "GPIO_MUX_I2S_M_SD_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_I2S_M_SD_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_I2S_M_SD_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_I2S_M_SD_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_I2S_M_SD_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_I2S_M_SD_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_I2S_M_SD_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_I2S_M_SD_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_I2S_M_SD_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_I2S_M_SD_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0xfc++0x3
    line.long 0x00 "GPIO_MUX_I2S_M_WS_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_I2S_M_WS_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_I2S_M_WS_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_I2S_M_WS_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_I2S_M_WS_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_I2S_M_WS_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_I2S_M_WS_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_I2S_M_WS_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_I2S_M_WS_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_I2S_M_WS_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x100++0x3
    line.long 0x00 "GPIO_MUX_MDC_O_CTRL, None RESET:0x48"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_MDC_O_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_MDC_O_CTRL_PU_EN ,None RESET:0x0"
          
         bitfld.long 0x00 5. " GPIO_MUX_MDC_O_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_MDC_O_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_MDC_O_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_MDC_O_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_MDC_O_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_MDC_O_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_MDC_O_CTRL_DO_SEL ,None RESET:0x0"
          
group.long  0x104++0x3
    line.long 0x00 "GPIO_MUX_MDIO_B_CTRL, None RESET:0x58"
         hexmask.long 0x00 0.--3. 1. " GPIO_MUX_MDIO_B_CTRL_DS ,None RESET:0x8"
          
         bitfld.long 0x00 4. " GPIO_MUX_MDIO_B_CTRL_PU_EN ,None RESET:0x1"
          
         bitfld.long 0x00 5. " GPIO_MUX_MDIO_B_CTRL_PD_EN ,None RESET:0x0"
          
         bitfld.long 0x00 6. " GPIO_MUX_MDIO_B_CTRL_SR ,None RESET:0x1"
          
         bitfld.long 0x00 7. " GPIO_MUX_MDIO_B_CTRL_CO ,None RESET:0x0"
          
         bitfld.long 0x00 8. " GPIO_MUX_MDIO_B_CTRL_ODN ,None RESET:0x0"
          
         bitfld.long 0x00 9. " GPIO_MUX_MDIO_B_CTRL_ODP ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " GPIO_MUX_MDIO_B_CTRL_STE ,None RESET:0x0"
          
         bitfld.long 0x00 12. " GPIO_MUX_MDIO_B_CTRL_DO_SEL ,None RESET:0x0"
          
tree.end

tree "ULP"
base e:0x41003000
width 80.
tree.end

tree "ULP__ULP_CTRL_REGFILE"
base e:0x41003000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ULP_ULP_CTRL_REGFILE_SAFETY_TIMER_CONFIG, None RESET:0xffff"
         hexmask.long 0x00 0.--15. 1. " ULP_ULP_CTRL_REGFILE_SAFETY_TIMER_CONFIG_DCDC_DISABLE_TIMER_MAX_COUNT ,None RESET:0xffff"
          
group.long  0x4++0x3
    line.long 0x00 "ULP_ULP_CTRL_REGFILE_SAFETY_TIMER_CONFIG_OVERRIDE, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_ULP_CTRL_REGFILE_SAFETY_TIMER_CONFIG_OVERRIDE_DCDC_DISABLE_TIMER_MAX_COUNT_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
group.long  0x8++0x3
    line.long 0x00 "ULP_ULP_CTRL_REGFILE_STATUS_0, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_ULP_CTRL_REGFILE_STATUS_0_STATUS_ACK ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ULP_ULP_CTRL_REGFILE_STATUS_0_GET_STATUS ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ULP_ULP_CTRL_REGFILE_STATUS_1, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_ULP_CTRL_REGFILE_STATUS_1_POWER_GOOD_LDO ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ULP_ULP_CTRL_REGFILE_STATUS_1_POWER_GOOD_DCDC_CONST ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ULP_ULP_CTRL_REGFILE_STATUS_1_POWER_GOOD_DCDC_VAR ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ULP_ULP_CTRL_REGFILE_STATUS_1_IS_ACTIVE_DCDC_CONST ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ULP_ULP_CTRL_REGFILE_STATUS_1_IS_ACTIVE_DCDC_VAR ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ULP_ULP_CTRL_REGFILE_STATUS_1_FLL_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 6. " ULP_ULP_CTRL_REGFILE_STATUS_1_PLL_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 7. " ULP_ULP_CTRL_REGFILE_STATUS_1_REF_CLK_FAILURE ,None RESET:0x0"
          
         hexmask.long 0x00 8.--10. 1. " ULP_ULP_CTRL_REGFILE_STATUS_1_REQUEST_MODE_FSM_ACTIVE_STATE ,None RESET:0x0"
          
         hexmask.long 0x00 11.--15. 1. " ULP_ULP_CTRL_REGFILE_STATUS_1_MODE_CHANGE_FSM_ACTIVE_STATE ,None RESET:0x0"
          
         hexmask.long 0x00 16.--18. 1. " ULP_ULP_CTRL_REGFILE_STATUS_1_ULP_ACTIVE_MODE ,None RESET:0x0"
          
         hexmask.long 0x00 19.--21. 1. " ULP_ULP_CTRL_REGFILE_STATUS_1_ULP_REQUESTED_MODE ,None RESET:0x0"
          
         bitfld.long 0x00 22. " ULP_ULP_CTRL_REGFILE_STATUS_1_IS_FSM_IN_SAFETY ,None RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "ULP_ULP_CTRL_REGFILE_VERSION, None RESET:0x0"
         bitfld.long 0x00 0.--5. " ULP_ULP_CTRL_REGFILE_VERSION_VERSION ,None RESET:0x0" "V1_1_1-0"
          
tree.end

tree "ULP__DCDC_VAR_REGFILE"
base e:0x41003020
width 80.
group.long  0x0++0x3
    line.long 0x00 "ULP_DCDC_VAR_REGFILE_CTRL, None RESET:0x2"
         bitfld.long 0x00 0. " ULP_DCDC_VAR_REGFILE_CTRL_ENABLE ,None RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 1. " ULP_DCDC_VAR_REGFILE_CTRL_ALLOW_VREG_DISCHARGE ,None RESET:0x1" "NOT_ALLOWED-0,ALLOWED-1"
          
group.long  0x4++0x3
    line.long 0x00 "ULP_DCDC_VAR_REGFILE_CTRL_OVERRIDE, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_DCDC_VAR_REGFILE_CTRL_OVERRIDE_ENABLE_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 1. " ULP_DCDC_VAR_REGFILE_CTRL_OVERRIDE_ALLOW_VREG_DISCHARGE_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
group.long  0x8++0x3
    line.long 0x00 "ULP_DCDC_VAR_REGFILE_DCDC_CONFIG, None RESET:0x190"
         hexmask.long 0x00 0.--4. 1. " ULP_DCDC_VAR_REGFILE_DCDC_CONFIG_VTARGET ,None RESET:0x10"
          
         hexmask.long 0x00 5.--11. 1. " ULP_DCDC_VAR_REGFILE_DCDC_CONFIG_T_HS_MAX ,None RESET:0xc"
          
         bitfld.long 0x00 12. " ULP_DCDC_VAR_REGFILE_DCDC_CONFIG_CONFIG_REQ ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ULP_DCDC_VAR_REGFILE_CONFIG_OVERRIDE, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_DCDC_VAR_REGFILE_CONFIG_OVERRIDE_VTARGET_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 1. " ULP_DCDC_VAR_REGFILE_CONFIG_OVERRIDE_T_HS_MAX_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 2. " ULP_DCDC_VAR_REGFILE_CONFIG_OVERRIDE_CONFIG_REQ_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
group.long  0x10++0x3
    line.long 0x00 "ULP_DCDC_VAR_REGFILE_STATUS_0, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_DCDC_VAR_REGFILE_STATUS_0_CONFIG_ACK ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ULP_DCDC_VAR_REGFILE_STATUS_0_POWER_GOOD ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ULP_DCDC_VAR_REGFILE_STATUS_0_IS_ENABLED ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ULP_DCDC_VAR_REGFILE_STATUS_0_DCDC_STATUS_ACK ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ULP_DCDC_VAR_REGFILE_STATUS_0_GET_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ULP_DCDC_VAR_REGFILE_STATUS_0_STATUS_CAPTURE_OVR ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ULP_DCDC_VAR_REGFILE_STATUS_1, None RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " ULP_DCDC_VAR_REGFILE_STATUS_1_STATUS_T_LS ,None RESET:0x0"
          
         hexmask.long 0x00 9.--15. 1. " ULP_DCDC_VAR_REGFILE_STATUS_1_STATUS_T_HS ,None RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ULP_DCDC_VAR_REGFILE_STATUS_1_STATUS_T_WAIT ,None RESET:0x0"
          
tree.end

tree "ULP__DCDC_CONST_REGFILE"
base e:0x41003040
width 80.
group.long  0x0++0x3
    line.long 0x00 "ULP_DCDC_CONST_REGFILE_CTRL, None RESET:0x2"
         bitfld.long 0x00 0. " ULP_DCDC_CONST_REGFILE_CTRL_ENABLE ,None RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 1. " ULP_DCDC_CONST_REGFILE_CTRL_ALLOW_VREG_DISCHARGE ,None RESET:0x1" "NOT_ALLOWED-0,ALLOWED-1"
          
group.long  0x4++0x3
    line.long 0x00 "ULP_DCDC_CONST_REGFILE_CTRL_OVERRIDE, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_DCDC_CONST_REGFILE_CTRL_OVERRIDE_ENABLE_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 1. " ULP_DCDC_CONST_REGFILE_CTRL_OVERRIDE_ALLOW_VREG_DISCHARGE_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
group.long  0x8++0x3
    line.long 0x00 "ULP_DCDC_CONST_REGFILE_DCDC_CONFIG, None RESET:0x190"
         hexmask.long 0x00 0.--4. 1. " ULP_DCDC_CONST_REGFILE_DCDC_CONFIG_VTARGET ,None RESET:0x10"
          
         hexmask.long 0x00 5.--11. 1. " ULP_DCDC_CONST_REGFILE_DCDC_CONFIG_T_HS_MAX ,None RESET:0xc"
          
         bitfld.long 0x00 12. " ULP_DCDC_CONST_REGFILE_DCDC_CONFIG_CONFIG_REQ ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ULP_DCDC_CONST_REGFILE_CONFIG_OVERRIDE, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_DCDC_CONST_REGFILE_CONFIG_OVERRIDE_VTARGET_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 1. " ULP_DCDC_CONST_REGFILE_CONFIG_OVERRIDE_T_HS_MAX_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 2. " ULP_DCDC_CONST_REGFILE_CONFIG_OVERRIDE_CONFIG_REQ_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
group.long  0x10++0x3
    line.long 0x00 "ULP_DCDC_CONST_REGFILE_STATUS_0, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_DCDC_CONST_REGFILE_STATUS_0_CONFIG_ACK ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ULP_DCDC_CONST_REGFILE_STATUS_0_POWER_GOOD ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ULP_DCDC_CONST_REGFILE_STATUS_0_IS_ENABLED ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ULP_DCDC_CONST_REGFILE_STATUS_0_DCDC_STATUS_ACK ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ULP_DCDC_CONST_REGFILE_STATUS_0_GET_STATUS ,None RESET:0x0"
          
         bitfld.long 0x00 5. " ULP_DCDC_CONST_REGFILE_STATUS_0_STATUS_CAPTURE_OVR ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ULP_DCDC_CONST_REGFILE_STATUS_1, None RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " ULP_DCDC_CONST_REGFILE_STATUS_1_STATUS_T_LS ,None RESET:0x0"
          
         hexmask.long 0x00 9.--15. 1. " ULP_DCDC_CONST_REGFILE_STATUS_1_STATUS_T_HS ,None RESET:0x0"
          
         hexmask.long 0x00 16.--31. 1. " ULP_DCDC_CONST_REGFILE_STATUS_1_STATUS_T_WAIT ,None RESET:0x0"
          
tree.end

tree "ULP__PLL_REGFILE"
base e:0x41003060
width 80.
group.long  0x0++0x3
    line.long 0x00 "ULP_PLL_REGFILE_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_PLL_REGFILE_CTRL_ENABLE ,None RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 1. " ULP_PLL_REGFILE_CTRL_PWR_ON ,None RESET:0x0" "DISABLED-0,ENABLED-1"
          
group.long  0x4++0x3
    line.long 0x00 "ULP_PLL_REGFILE_CTRL_OVERRIDE, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_PLL_REGFILE_CTRL_OVERRIDE_ENABLE_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 1. " ULP_PLL_REGFILE_CTRL_OVERRIDE_PWR_ON_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
group.long  0x8++0x3
    line.long 0x00 "ULP_PLL_REGFILE_ADPLL_CONFIG_0, None RESET:0x10012aa4"
         hexmask.long 0x00 0.--4. 1. " ULP_PLL_REGFILE_ADPLL_CONFIG_0_C_CI ,None RESET:0x4"
          
         hexmask.long 0x00 5.--12. 1. " ULP_PLL_REGFILE_ADPLL_CONFIG_0_C_CP ,None RESET:0x55"
          
         bitfld.long 0x00 13. " ULP_PLL_REGFILE_ADPLL_CONFIG_0_C_MAIN_DIV_N1 ,None RESET:0x1"
          
         hexmask.long 0x00 14.--15. 1. " ULP_PLL_REGFILE_ADPLL_CONFIG_0_C_MAIN_DIV_N2 ,None RESET:0x0"
          
         hexmask.long 0x00 16.--18. 1. " ULP_PLL_REGFILE_ADPLL_CONFIG_0_C_MAIN_DIV_N3 ,None RESET:0x1"
          
         hexmask.long 0x00 19.--20. 1. " ULP_PLL_REGFILE_ADPLL_CONFIG_0_C_OUT_DIV ,None RESET:0x0"
          
         bitfld.long 0x00 21. " ULP_PLL_REGFILE_ADPLL_CONFIG_0_C_OPEN_LOOP ,None RESET:0x0"
          
         hexmask.long 0x00 22.--29. 1. " ULP_PLL_REGFILE_ADPLL_CONFIG_0_C_FT ,None RESET:0x40"
          
group.long  0xc++0x3
    line.long 0x00 "ULP_PLL_REGFILE_ADPLL_CONFIG_1, None RESET:0x848"
         hexmask.long 0x00 0.--5. 1. " ULP_PLL_REGFILE_ADPLL_CONFIG_1_C_COARSE ,None RESET:0x8"
          
         bitfld.long 0x00 6. " ULP_PLL_REGFILE_ADPLL_CONFIG_1_C_AUTO_COARSETUNE ,None RESET:0x1"
          
         bitfld.long 0x00 7. " ULP_PLL_REGFILE_ADPLL_CONFIG_1_C_ENFORCE_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 8. " ULP_PLL_REGFILE_ADPLL_CONFIG_1_C_PFD_SELECT ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ULP_PLL_REGFILE_ADPLL_CONFIG_1_C_LOCK_WINDOW_SEL ,None RESET:0x0"
          
         hexmask.long 0x00 10.--11. 1. " ULP_PLL_REGFILE_ADPLL_CONFIG_1_C_FILTER_SHIFT ,None RESET:0x2"
          
         bitfld.long 0x00 12. " ULP_PLL_REGFILE_ADPLL_CONFIG_1_C_SET_OP_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 13. " ULP_PLL_REGFILE_ADPLL_CONFIG_1_C_DISABLE_LOCK ,None RESET:0x0"
          
         bitfld.long 0x00 14. " ULP_PLL_REGFILE_ADPLL_CONFIG_1_C_REF_BYPASS ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "ULP_PLL_REGFILE_CONFIG_OVERRIDE, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_CI_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 1. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_CP_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 2. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_MAIN_DIV_N1_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 3. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_MAIN_DIV_N2_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 4. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_MAIN_DIV_N3_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 5. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_OUT_DIV_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 6. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_OPEN_LOOP_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 7. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_FT_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 8. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_COARSE_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 9. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_AUTO_COARSETUNE_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 10. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_ENFORCE_LOCK_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 11. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_PFD_SELECT_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 12. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_LOCK_WINDOW_SEL_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 13. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_FILTER_SHIFT_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 14. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_SET_OP_LOCK_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 15. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_DISABLE_LOCK_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 16. " ULP_PLL_REGFILE_CONFIG_OVERRIDE_C_REF_BYPASS_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
group.long  0x14++0x3
    line.long 0x00 "ULP_PLL_REGFILE_STATUS_0, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_PLL_REGFILE_STATUS_0_ADPLL_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ULP_PLL_REGFILE_STATUS_0_PWR_ON_ACK ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ULP_PLL_REGFILE_STATUS_0_PWR_OFF_ACK ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ULP_PLL_REGFILE_STATUS_0_ADPLL_STATUS_ACK ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ULP_PLL_REGFILE_STATUS_0_GET_STATUS ,None RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "ULP_PLL_REGFILE_STATUS_1, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_PLL_REGFILE_STATUS_1_PLL_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ULP_PLL_REGFILE_STATUS_1_PLL_FT_OF ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ULP_PLL_REGFILE_STATUS_1_PLL_FT_UF ,None RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " ULP_PLL_REGFILE_STATUS_1_PLL_FT ,None RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " ULP_PLL_REGFILE_STATUS_1_PLL_STATE ,None RESET:0x0"
          
         hexmask.long 0x00 13.--18. 1. " ULP_PLL_REGFILE_STATUS_1_PLL_COARSE_TUNE ,None RESET:0x0"
          
         bitfld.long 0x00 19. " ULP_PLL_REGFILE_STATUS_1_PLL_CT_OF ,None RESET:0x0"
          
         bitfld.long 0x00 20. " ULP_PLL_REGFILE_STATUS_1_PLL_CT_UF ,None RESET:0x0"
          
tree.end

tree "ULP__FLL_REGFILE"
base e:0x41003080
width 80.
group.long  0x0++0x3
    line.long 0x00 "ULP_FLL_REGFILE_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_FLL_REGFILE_CTRL_ENABLE ,None RESET:0x0" "DISABLED-0,ENABLED-1"
          
group.long  0x4++0x3
    line.long 0x00 "ULP_FLL_REGFILE_CTRL_OVERRIDE, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_FLL_REGFILE_CTRL_OVERRIDE_ENABLE_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
group.long  0x8++0x3
    line.long 0x00 "ULP_FLL_REGFILE_ADFLL_CONFIG, None RESET:0xbea1"
         hexmask.long 0x00 0.--4. 1. " ULP_FLL_REGFILE_ADFLL_CONFIG_C_REF_DIV_SEL ,None RESET:0x1"
          
         hexmask.long 0x00 5.--16. 1. " ULP_FLL_REGFILE_ADFLL_CONFIG_C_FREQ_MULT ,None RESET:0x5f5"
          
         bitfld.long 0x00 17. " ULP_FLL_REGFILE_ADFLL_CONFIG_C_OPEN_LOOP ,None RESET:0x0"
          
         bitfld.long 0x00 18. " ULP_FLL_REGFILE_ADFLL_CONFIG_C_FORCE_CLK ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ULP_FLL_REGFILE_CONFIG_OVERRIDE, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_FLL_REGFILE_CONFIG_OVERRIDE_C_REF_DIV_SEL_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 1. " ULP_FLL_REGFILE_CONFIG_OVERRIDE_C_FREQ_MULT_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 2. " ULP_FLL_REGFILE_CONFIG_OVERRIDE_C_OPEN_LOOP_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 3. " ULP_FLL_REGFILE_CONFIG_OVERRIDE_C_FORCE_CLK_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
group.long  0x10++0x3
    line.long 0x00 "ULP_FLL_REGFILE_STATUS_0, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_FLL_REGFILE_STATUS_0_ADFLL_PRELOCK ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ULP_FLL_REGFILE_STATUS_0_ADFLL_LOCKED ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ULP_FLL_REGFILE_STATUS_0_REF_CLK_FAILURE ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ULP_FLL_REGFILE_STATUS_0_ADFLL_STATUS_ACK ,None RESET:0x0"
          
         bitfld.long 0x00 4. " ULP_FLL_REGFILE_STATUS_0_GET_STATUS ,None RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "ULP_FLL_REGFILE_STATUS_1, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_FLL_REGFILE_STATUS_1_FLL_ENABLE_SYNC ,None RESET:0x0"
          
         bitfld.long 0x00 1. " ULP_FLL_REGFILE_STATUS_1_FLL_LOCKED_C ,None RESET:0x0"
          
         bitfld.long 0x00 2. " ULP_FLL_REGFILE_STATUS_1_FLL_FILTER_C_OF ,None RESET:0x0"
          
         bitfld.long 0x00 3. " ULP_FLL_REGFILE_STATUS_1_FLL_FILTER_C_UF ,None RESET:0x0"
          
         hexmask.long 0x00 4.--8. 1. " ULP_FLL_REGFILE_STATUS_1_FLL_FILTER_C ,None RESET:0x0"
          
         bitfld.long 0x00 9. " ULP_FLL_REGFILE_STATUS_1_FLL_LOCKED_F ,None RESET:0x0"
          
         bitfld.long 0x00 10. " ULP_FLL_REGFILE_STATUS_1_FLL_FILTER_F_OF ,None RESET:0x0"
          
         bitfld.long 0x00 11. " ULP_FLL_REGFILE_STATUS_1_FLL_FILTER_F_UF ,None RESET:0x0"
          
         hexmask.long 0x00 12.--18. 1. " ULP_FLL_REGFILE_STATUS_1_FLL_FILTER_F ,None RESET:0x0"
          
         hexmask.long 0x00 19.--30. 1. " ULP_FLL_REGFILE_STATUS_1_FLL_CNT ,None RESET:0x0"
          
         bitfld.long 0x00 31. " ULP_FLL_REGFILE_STATUS_1_FLL_CNT_OF ,None RESET:0x0"
          
tree.end

tree "ULP__LDO_REGFILE"
base e:0x410030a0
width 80.
group.long  0x0++0x3
    line.long 0x00 "ULP_LDO_REGFILE_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_LDO_REGFILE_CTRL_DISABLE_LDO ,None RESET:0x0" "ENABLED-0,DISABLED-1"
          
         bitfld.long 0x00 1. " ULP_LDO_REGFILE_CTRL_POWER_GOOD_DISABLE ,None RESET:0x0" "ENABLED-0,DISABLED-1"
          
group.long  0x4++0x3
    line.long 0x00 "ULP_LDO_REGFILE_CTRL_OVERRIDE, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_LDO_REGFILE_CTRL_OVERRIDE_DISABLE_LDO_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 1. " ULP_LDO_REGFILE_CTRL_OVERRIDE_POWER_GOOD_DISABLE_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
rgroup.long 0x8++0x3
    line.long 0x00 "ULP_LDO_REGFILE_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_LDO_REGFILE_STATUS_POWER_GOOD ,None RESET:0x0"
          
tree.end

tree "ULP__BGR_REGFILE"
base e:0x410030c0
width 80.
group.long  0x0++0x3
    line.long 0x00 "ULP_BGR_REGFILE_CTRL, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_BGR_REGFILE_CTRL_V0D60_ENABLE ,None RESET:0x0" "DISABLED-0,ENABLED-1"
          
group.long  0x4++0x3
    line.long 0x00 "ULP_BGR_REGFILE_CTRL_OVERRIDE, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_BGR_REGFILE_CTRL_OVERRIDE_V0D60_ENABLE_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
group.long  0x8++0x3
    line.long 0x00 "ULP_BGR_REGFILE_TRIM_0D040V, None RESET:0x4000"
         hexmask.long 0x00 0.--30. 1. " ULP_BGR_REGFILE_TRIM_0D040V_TRIM_VALUE ,None RESET:0x4000"
          
group.long  0xc++0x3
    line.long 0x00 "ULP_BGR_REGFILE_TRIM_0D060V, None RESET:0x4000"
         hexmask.long 0x00 0.--30. 1. " ULP_BGR_REGFILE_TRIM_0D060V_TRIM_VALUE ,None RESET:0x4000"
          
group.long  0x10++0x3
    line.long 0x00 "ULP_BGR_REGFILE_TRIM_IBIAS, None RESET:0x3"
         hexmask.long 0x00 0.--2. 1. " ULP_BGR_REGFILE_TRIM_IBIAS_TRIM_VALUE ,None RESET:0x3"
          
tree.end

tree "ULP__ULP_CLK_SEL_REGFILE"
base e:0x410030e0
width 80.
group.long  0x0++0x3
    line.long 0x00 "ULP_ULP_CLK_SEL_REGFILE_CTRL, None RESET:0xa0"
         bitfld.long 0x00 0. " ULP_ULP_CLK_SEL_REGFILE_CTRL_SEL_CLK_EXT_FOR_CLK_50M_OUTPUT ,None RESET:0x0" "SEL_FLL_CLK50M-0,SEL_CLK_EXT-1"
          
         bitfld.long 0x00 1.--2. " ULP_ULP_CLK_SEL_REGFILE_CTRL_SEL_CLK_AO ,None RESET:0x0" "SEL_FLL_CLK_AO-0,SEL_CLK_REF-1,SEL_CLK_EXT-2"
          
         bitfld.long 0x00 3. " ULP_ULP_CLK_SEL_REGFILE_CTRL_SEL_CLK_EXT_FOR_DCDC ,None RESET:0x0" "SEL_FLL_CLK50M-0,SEL_CLK_EXT-1"
          
         bitfld.long 0x00 4. " ULP_ULP_CLK_SEL_REGFILE_CTRL_SEL_CLK_EXT_FOR_REF_OF_CLK_VAR ,None RESET:0x0" "SEL_FLL_CLK50M-0,SEL_CLK_EXT-1"
          
         hexmask.long 0x00 5.--7. 1. " ULP_ULP_CLK_SEL_REGFILE_CTRL_SEL_CLK_REF_VAR_DIV ,None RESET:0x5"
          
group.long  0x4++0x3
    line.long 0x00 "ULP_ULP_CLK_SEL_REGFILE_CTRL_OVERRIDE, None RESET:0x0"
         bitfld.long 0x00 0. " ULP_ULP_CLK_SEL_REGFILE_CTRL_OVERRIDE_SEL_CLK_EXT_FOR_CLK_50M_OUTPUT_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 1. " ULP_ULP_CLK_SEL_REGFILE_CTRL_OVERRIDE_SEL_CLK_AO_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 2. " ULP_ULP_CLK_SEL_REGFILE_CTRL_OVERRIDE_SEL_CLK_EXT_FOR_DCDC_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 3. " ULP_ULP_CLK_SEL_REGFILE_CTRL_OVERRIDE_SEL_CLK_EXT_FOR_REF_OF_CLK_VAR_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 4. " ULP_ULP_CLK_SEL_REGFILE_CTRL_OVERRIDE_SEL_CLK_REF_VAR_DIV_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
         bitfld.long 0x00 5. " ULP_ULP_CLK_SEL_REGFILE_CTRL_OVERRIDE_REF_CLK_FAILURE_OVR ,None RESET:0x0" "DO_NOT_OVERRIDE-0,OVERRIDE-1"
          
tree.end
    

tree "ADC_VTSENS"
base e:0x41004000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ADC_VTSENS_CTRL, ADC Control Register RESET:0x2"
         bitfld.long 0x00 0. " ADC_VTSENS_CTRL_ENABLE ,High active ADC enable, acts as low-active reset RESET:0x0"
          
         bitfld.long 0x00 1. " ADC_VTSENS_CTRL_PD_N ,Low-active power down of analog circuits RESET:0x1"
          
         hexmask.long 0x00 2.--4. 1. " ADC_VTSENS_CTRL_OSR ,Oversampling ratio. Defines the number of modulator cycles used for one conversion: OSR = 2^(osr_i+5) RESET:0x0"
          
         bitfld.long 0x00 5.--6. " ADC_VTSENS_CTRL_CH_SEL ,Input channel select RESET:0x0" "V_IN_0-0,V_IN_1-1,V_IN_2-2,INTERNAL-3"
          
         bitfld.long 0x00 7. " ADC_VTSENS_CTRL_REF_SEL ,Reference input select. Internal 1.23V or external v_ref_i RESET:0x0" "INTERNAL-0,EXTERNAL-1"
          
         bitfld.long 0x00 8. " ADC_VTSENS_CTRL_BIAS_SEL ,Select bias current generation. RESET:0x0" "DIODE_RES-0,PTAT-1"
          
         bitfld.long 0x00 9. " ADC_VTSENS_CTRL_AUTO ,Enable automatic measurement mode RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "ADC_VTSENS_RESULT, None RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " ADC_VTSENS_RESULT_RESULT0 ,Conversion result RESET:0x0"
          
         hexmask.long 0x00 12.--23. 1. " ADC_VTSENS_RESULT_RESULT1 ,Conversion result (only during auto mode) RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "ADC_VTSENS_IRQ_STATUS, ADC Interrupt Status Register RESET:0x0"
         bitfld.long 0x00 0. " ADC_VTSENS_IRQ_STATUS_CH0_READY ,IRQ Status for ADC Data Ready (CH0) RESET:0x0"
          
         bitfld.long 0x00 1. " ADC_VTSENS_IRQ_STATUS_CH1_READY ,IRQ Status for ADC Data Ready (CH1) RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ADC_VTSENS_IRQ_STATUS_ENABLE, ADC Interrupt Enable Register RESET:0x0"
         bitfld.long 0x00 0. " ADC_VTSENS_IRQ_STATUS_ENABLE_CH0_READY ,Enable IRQ for ADC Data Ready (CH0) RESET:0x0"
          
         bitfld.long 0x00 1. " ADC_VTSENS_IRQ_STATUS_ENABLE_CH1_READY ,Enable IRQ for ADC Data Ready (CH1) RESET:0x0"
          
wgroup.long 0x10++0x3
    line.long 0x00 "ADC_VTSENS_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev). RESET:0x0"
         bitfld.long 0x00 0. " ADC_VTSENS_IRQ_STATUS_SET_CH0_READY ,Set interrupt ready (CH0). RESET:0x0"
          
         bitfld.long 0x00 1. " ADC_VTSENS_IRQ_STATUS_SET_CH1_READY ,Set interrupt ready (CH1). RESET:0x0"
          
tree.end

tree "ADPLL2G"
base e:0x41005000
width 80.
tree.end

tree "ADPLL2G__ADPLL2G"
base e:0x41005000
width 80.
group.long  0x0++0x3
    line.long 0x00 "ADPLL2G_ADPLL2G_CTRL_0, Control register 0 / reset settings for 10MHz input, 60MHz output RESET:0x212bde"
         bitfld.long 0x00 0. " ADPLL2G_ADPLL2G_CTRL_0_EN_ADPLL ,Enable the PLL RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 1. " ADPLL2G_ADPLL2G_CTRL_0_MAINDIV_N1 ,N1 of ADPLL main loop divider RESET:0x1" "ONE-0,TWO-1"
          
         bitfld.long 0x00 2.--3. " ADPLL2G_ADPLL2G_CTRL_0_MAINDIV_N2 ,N2 of ADPLL main loop divider RESET:0x3" "TWO-0,THREE-1,FOUR-2,FIVE-3"
          
         bitfld.long 0x00 4.--5. " ADPLL2G_ADPLL2G_CTRL_0_MAINDIV_N3 ,N3 of ADPLL main loop divider RESET:0x1" "TWO-0,THREE-1,FOUR-2,FIVE-3"
          
         bitfld.long 0x00 6.--7. " ADPLL2G_ADPLL2G_CTRL_0_MAINDIV_N4 ,N4 of ADPLL main loop divider RESET:0x3" "ONE-0,TWO-1,THREE-2,FOUR-3"
          
         bitfld.long 0x00 8.--9. " ADPLL2G_ADPLL2G_CTRL_0_OUTDIV_SEL ,ADPLL output divider RESET:0x3" "NODIV-0,DIV2-1,DIV4-2,DIV8-3"
          
         bitfld.long 0x00 10. " ADPLL2G_ADPLL2G_CTRL_0_OPEN_LOOP ,Enable open loop (PLL starts without loop regulation) RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 11.--12. " ADPLL2G_ADPLL2G_CTRL_0_DIVCORE_SEL ,Frequency divider setting for core output clock RESET:0x1" "NODIV-0,DIV3-1,DIV5-2,DIV10-3"
          
         bitfld.long 0x00 13. " ADPLL2G_ADPLL2G_CTRL_0_AUTO_CT ,Enable for automatic coarse tune RESET:0x1" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 14. " ADPLL2G_ADPLL2G_CTRL_0_PFD_SEL ,enable/disable synchronizer for PFD RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 15. " ADPLL2G_ADPLL2G_CTRL_0_LOCK_WINDOW_SEL ,Lock Detection Window selection RESET:0x0" "LONG-0,SHORT-1"
          
         bitfld.long 0x00 16. " ADPLL2G_ADPLL2G_CTRL_0_DIVCORE_MUX_SEL ,selects the divider chain for clk_core. Only COREDIV or OUTDIV + COREDIV RESET:0x1" "COREDIV-0,COREDIV_OUTDIV-1"
          
         bitfld.long 0x00 17. " ADPLL2G_ADPLL2G_CTRL_0_EN_FAST_LOCK ,Enable internal fast lock-in for fine tune value using binary search RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 18. " ADPLL2G_ADPLL2G_CTRL_0_ENFORCE_LOCK ,Overwrite locked-bit (Note: locked status can still read on adpll_status_o) RESET:0x0" "UNENFORCED-0,ENFORCED-1"
          
         bitfld.long 0x00 19. " ADPLL2G_ADPLL2G_CTRL_0_SET_OP_LOCK ,Force locked bit to 1 in OP mode. This mode bypasses the lock detection RESET:0x0" "UNENFORCED-0,FORCED1-1"
          
         bitfld.long 0x00 20. " ADPLL2G_ADPLL2G_CTRL_0_DISABLE_LOCK ,Force locked bit to 0 (Note: locked status can still read on adpll_status_o) RESET:0x0" "UNENFORCED-0,FORCED0-1"
          
         bitfld.long 0x00 21. " ADPLL2G_ADPLL2G_CTRL_0_REF_BYPASS ,enable/disable reference clock bypass to ADPLL core clock output RESET:0x1" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 22. " ADPLL2G_ADPLL2G_CTRL_0_BIST_MODE ,Set BIST mode or normal PLL usage mode RESET:0x0" "NORMAL-0,BIST-1"
          
         bitfld.long 0x00 23. " ADPLL2G_ADPLL2G_CTRL_0_CT_COMPENSATION ,Enable automatic increase/decrease of coarsetune value in case of finetune overflow/underflow RESET:0x0" "DISABLED-0,ENABLED-1"
          
group.long  0x4++0x3
    line.long 0x00 "ADPLL2G_ADPLL2G_CTRL_1, Control register 1 RESET:0x11100604"
         hexmask.long 0x00 0.--4. 1. " ADPLL2G_ADPLL2G_CTRL_1_CI ,Integral coefficient of loop filter RESET:0x4"
          
         hexmask.long 0x00 5.--12. 1. " ADPLL2G_ADPLL2G_CTRL_1_CP ,Proportional coefficient of loop filter RESET:0x30"
          
         hexmask.long 0x00 13.--20. 1. " ADPLL2G_ADPLL2G_CTRL_1_FT ,ADPLL fine-tune value for open-loop mode and for automatic coarse tune RESET:0x80"
          
         hexmask.long 0x00 21.--26. 1. " ADPLL2G_ADPLL2G_CTRL_1_CT ,Coarse tune value for open loop (CT>=4!) and in the case AUTO_CT = 0 RESET:0x8"
          
         hexmask.long 0x00 27.--28. 1. " ADPLL2G_ADPLL2G_CTRL_1_FILTER_SHIFT ,Shift filter coefficients CI and CP left by FILTER_SHIFT when not locked RESET:0x2"
          
group.long  0x8++0x3
    line.long 0x00 "ADPLL2G_ADPLL2G_CTRL_2, Control register 2 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " ADPLL2G_ADPLL2G_CTRL_2_SAR_LIMIT ,Limit for binary search fast lock-in RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "ADPLL2G_ADPLL2G_STATUS_CAPTURE, None RESET:0x0"
         bitfld.long 0x00 0. " ADPLL2G_ADPLL2G_STATUS_CAPTURE_CAPTURE ,Triggers capture of status* registers; This bit is cleared by HW when status is ready RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "ADPLL2G_ADPLL2G_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " ADPLL2G_ADPLL2G_STATUS_PLL_LOCKED ,locked bit RESET:0x0"
          
         bitfld.long 0x00 1. " ADPLL2G_ADPLL2G_STATUS_PLL_FT_OF ,overflow flag for fine tune RESET:0x0"
          
         bitfld.long 0x00 2. " ADPLL2G_ADPLL2G_STATUS_PLL_FT_UF ,underflow flag for fine tune RESET:0x0"
          
         hexmask.long 0x00 3.--10. 1. " ADPLL2G_ADPLL2G_STATUS_PLL_FT ,fine tune Value RESET:0x0"
          
         hexmask.long 0x00 11.--12. 1. " ADPLL2G_ADPLL2G_STATUS_PLL_STATE ,ADPLL FSM state RESET:0x0"
          
         hexmask.long 0x00 13.--18. 1. " ADPLL2G_ADPLL2G_STATUS_PLL_COARSE_TUNE ,coarse tune value RESET:0x0"
          
         bitfld.long 0x00 19. " ADPLL2G_ADPLL2G_STATUS_PLL_CT_OF ,overflow flag for coarse tune RESET:0x0"
          
         bitfld.long 0x00 20. " ADPLL2G_ADPLL2G_STATUS_PLL_CT_UF ,underflow flag for coarse tune RESET:0x0"
          
         bitfld.long 0x00 21. " ADPLL2G_ADPLL2G_STATUS_BIST_BUSY ,1:BIST is still running; 0:BIST finished RESET:0x0"
          
         bitfld.long 0x00 22. " ADPLL2G_ADPLL2G_STATUS_BIST_FAIL_COARSE ,1:BIST fail for coarsetune (monotony error or BIST was not correct started); 0:BIST pass RESET:0x0"
          
         bitfld.long 0x00 23. " ADPLL2G_ADPLL2G_STATUS_BIST_FAIL_FINE ,1:BIST fail for finetune (monotony error or BIST was not correct started); 0:BIST pass RESET:0x0"
          
tree.end
    

tree "OSC32K"
base e:0x41006000
width 80.
group.long  0x0++0x3
    line.long 0x00 "OSC32K_CTRL, OSC32K Control Register RESET:0x1"
         bitfld.long 0x00 0. " OSC32K_CTRL_ENABLE ,Enable OSC32K RESET:0x1" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 1. " OSC32K_CTRL_BYPASS ,Enable bypass RESET:0x0" "DISABLED-0,ENABLED-1"
          
         bitfld.long 0x00 2. " OSC32K_CTRL_ENABLE_HIGH_LOAD ,Enable high load capacitance RESET:0x0" "DISABLED-0,ENABLED-1"
          
rgroup.long 0x4++0x3
    line.long 0x00 "OSC32K_STATUS, OSC32K Status Register RESET:0x0"
         bitfld.long 0x00 0. " OSC32K_STATUS_VALID ,Clock signal is valid RESET:0x0"
          
tree.end

tree "FBIST"
base e:0x41007000
width 80.
tree.end

tree "FBIST__FBIST"
base e:0x41007000
width 80.
group.long  0x0++0x3
    line.long 0x00 "FBIST_FBIST_CTRL, FBIST Control Register RESET:0x0"
         bitfld.long 0x00 0. " FBIST_FBIST_CTRL_BIST_EN ,Enable Frequency BIST RESET:0x0" "DISABLED-0,ENABLED-1"
          
group.long  0x4++0x3
    line.long 0x00 "FBIST_FBIST_CFG, FBIST Configuration Register RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " FBIST_FBIST_CFG_COUNTER_CHECK_VALUE ,Expected counter result RESET:0x0"
          
         hexmask.long 0x00 20.--23. 1. " FBIST_FBIST_CFG_COUNTER_CHECK_RANGE ,Tolerance range for result comparison RESET:0x0"
          
         hexmask.long 0x00 24.--27. 1. " FBIST_FBIST_CFG_SOURCE_SELECT ,Select clock or meaurement RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "FBIST_FBIST_CFG_PRESCALER, FBIST Configuration Register Prescaler RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " FBIST_FBIST_CFG_PRESCALER_PS ,Reference clock pre-scaling (2^prescaler+2) RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "FBIST_FBIST_STATUS, FBIST Status Register RESET:0x0"
         hexmask.long 0x00 0.--19. 1. " FBIST_FBIST_STATUS_COUNTER_RESULT ,Counter result RESET:0x0"
          
         bitfld.long 0x00 20. " FBIST_FBIST_STATUS_DONE ,FBIST done RESET:0x0"
          
         bitfld.long 0x00 21. " FBIST_FBIST_STATUS_PASS ,FBIST result RESET:0x0"
          
tree.end

tree "EFUSE"
base e:0x41008000
width 80.
group.long  0x0++0x3
    line.long 0x00 "EFUSE_CONTROL, eFUSE Control Register RESET:0x0"
         bitfld.long 0x00 0. " EFUSE_CONTROL_PROGEN ,enable programming / this adds some protection against accidential programming RESET:0x0"
          
         bitfld.long 0x00 1. " EFUSE_CONTROL_BULKREAD ,trigger read of all 256 eFUSE bits into the data0..31 shadow registers RESET:0x0"
          
         bitfld.long 0x00 2. " EFUSE_CONTROL_PROTECT ,protect eFUSE from beeing programmed until the next reset. field = swwel ? current : new RESET:0x0"
          
         hexmask.long 0x00 3.--4. 1. " EFUSE_CONTROL_MR ,adjust the margin read mode / 00,11:RES_1K5(default) 01:RES_1K 10:RES_3K RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "EFUSE_STATUS, eFUSE IRQ status Register RESET:0x0"
         bitfld.long 0x00 0. " EFUSE_STATUS_DONE ,last operation (bulkread or programming) is done RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "EFUSE_PROG, eFUSE Program Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EFUSE_PROG_BITNUMBER ,bitnumber of the eFUSE that shall be programmed to one RESET:0x0"
          
rgroup.long 0xc++0x3
    line.long 0x00 "EFUSE_WORD0, eFUSE word0 0x0 shadow Register / control.bulkread will copy the eFUSE content to data[0..31] RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EFUSE_WORD0_BYTE0 ,byte 0 of word 0 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " EFUSE_WORD0_BYTE1 ,byte 1 of word 0 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " EFUSE_WORD0_BYTE2 ,byte 2 of word 0 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " EFUSE_WORD0_BYTE3 ,byte 3 of word 0 of the eFUSE RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "EFUSE_WORD1, eFUSE word 0x1 shadow Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EFUSE_WORD1_BYTE0 ,byte 0 of word 1 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " EFUSE_WORD1_BYTE1 ,byte 1 of word 1 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " EFUSE_WORD1_BYTE2 ,byte 2 of word 1 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " EFUSE_WORD1_BYTE3 ,byte 3 of word 1 of the eFUSE RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "EFUSE_WORD2, eFUSE word 0x2 shadow Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EFUSE_WORD2_BYTE0 ,byte 0 of word 2 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " EFUSE_WORD2_BYTE1 ,byte 1 of word 2 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " EFUSE_WORD2_BYTE2 ,byte 2 of word 2 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " EFUSE_WORD2_BYTE3 ,byte 3 of word 2 of the eFUSE RESET:0x0"
          
rgroup.long 0x18++0x3
    line.long 0x00 "EFUSE_WORD3, eFUSE word 0x3 shadow Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EFUSE_WORD3_BYTE0 ,byte 0 of word 3 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " EFUSE_WORD3_BYTE1 ,byte 1 of word 3 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " EFUSE_WORD3_BYTE2 ,byte 2 of word 3 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " EFUSE_WORD3_BYTE3 ,byte 3 of word 3 of the eFUSE RESET:0x0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "EFUSE_WORD4, eFUSE word 0x4 shadow Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EFUSE_WORD4_BYTE0 ,byte 0 of word 4 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " EFUSE_WORD4_BYTE1 ,byte 1 of word 4 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " EFUSE_WORD4_BYTE2 ,byte 2 of word 4 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " EFUSE_WORD4_BYTE3 ,byte 3 of word 4 of the eFUSE RESET:0x0"
          
rgroup.long 0x20++0x3
    line.long 0x00 "EFUSE_WORD5, eFUSE word 0x5 shadow Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EFUSE_WORD5_BYTE0 ,byte 0 of word 5 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " EFUSE_WORD5_BYTE1 ,byte 1 of word 5 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " EFUSE_WORD5_BYTE2 ,byte 2 of word 5 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " EFUSE_WORD5_BYTE3 ,byte 3 of word 5 of the eFUSE RESET:0x0"
          
rgroup.long 0x24++0x3
    line.long 0x00 "EFUSE_WORD6, eFUSE word 0x6 shadow Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EFUSE_WORD6_BYTE0 ,byte 0 of word 6 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " EFUSE_WORD6_BYTE1 ,byte 1 of word 6 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " EFUSE_WORD6_BYTE2 ,byte 2 of word 6 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " EFUSE_WORD6_BYTE3 ,byte 3 of word 6 of the eFUSE RESET:0x0"
          
rgroup.long 0x28++0x3
    line.long 0x00 "EFUSE_WORD7, eFUSE word 0x7 shadow Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " EFUSE_WORD7_BYTE0 ,byte 0 of word 7 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " EFUSE_WORD7_BYTE1 ,byte 1 of word 7 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 16.--23. 1. " EFUSE_WORD7_BYTE2 ,byte 2 of word 7 of the eFUSE RESET:0x0"
          
         hexmask.long 0x00 24.--31. 1. " EFUSE_WORD7_BYTE3 ,byte 3 of word 7 of the eFUSE RESET:0x0"
          
tree.end

tree "GPIO"
base e:0x41009000
width 80.
rgroup.long 0x0++0x3
    line.long 0x00 "GPIO_DATAIN, Sampled input data value RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_DATAIN_DATAIN ,Sampled data at pin RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "GPIO_DATAOUT, Data output status RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_DATAOUT_DATAOUT ,Current value of data output register RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "GPIO_DATAOUTSET, Data output set RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_DATAOUTSET_DATAOUTSET ,1 -> sets output bit | 0 -> No effect RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "GPIO_DATAOUTCLR, Data output clear RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_DATAOUTCLR_DATAOUTCLR ,1 -> clears output bit | 0 -> No effect RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "GPIO_OUTEN, Output enable status RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_OUTEN_OUTEN ,0 -> Direction is input 1 -> Direction is output RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "GPIO_OUTENSET, Output enable set RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_OUTENSET_OUTENSET ,0 -> No Effect 1 -> Set output enable bit for indicating the signal direction as output RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "GPIO_OUTENCLR, Output enable clear RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_OUTENCLR_OUTENCLR ,0 -> No Effect 1 -> Clear output enable bit for indicating the signal direction as output RESET:0x0"
          
rgroup.long 0x1c++0x3
    line.long 0x00 "GPIO_INTEN, Interrupt enable status RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_INTEN_INTEN ,0 : Interrupt disabled 1: Interrupt enabled. Interrupt enable register is used to mask the interrupt line (module output gpioint_oi). It does not mask the intstatus register RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "GPIO_INTENSET, Interrupt enable set RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_INTENSET_INTENSET ,0 : No Effect 1: Set up interrupt enable bit RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "GPIO_INTENCLR, Interrupt enable clear RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_INTENCLR_INTENCLR ,0 : No Effect 1: Clear up interrupt enable bit RESET:0x0"
          
rgroup.long 0x28++0x3
    line.long 0x00 "GPIO_INTTYPE, Interrupt type status RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_INTTYPE_INTTYPE ,0 : Level detection 1: Edge detection RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "GPIO_INTTYPESET, Interrupt type set RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_INTTYPESET_INTTYPESET ,0 : No Effect 1: Set interrupt type bit for edge detection RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "GPIO_INTTYPECLR, Interrupt type clear RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_INTTYPECLR_INTTYPECLR ,0 : No Effect 1: Clear interrupt type bit for edge detection RESET:0x0"
          
rgroup.long 0x34++0x3
    line.long 0x00 "GPIO_INTPOLHIGH, Interrupt polarity high status RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_INTPOLHIGH_INTPOLHIGH ,0 : Triggering on HIGH level or rising edge disabled. If corresponding intpollow bit is also set to 0, the IRQ logic will not trigger on any level or edges. This case corresponds a masking of the intstatus register. 1 : Triggering on HIGH level or rising edge enabled. If corresponding intpollow bit is also set to 1,    the IRQ logic will trigger on both edges (rising, falling),    if edge triggering is selected in inttype register.         Note that setting both intpolhigh and intpollow bit to 1 is not sensible            in case that level triggering is selected in inttype register.            Triggering on both levels (LOW, HIGH) would cause a permanent met interrupt condition. RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "GPIO_INTPOLHIGHSET, Interrupt polarity high set RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_INTPOLHIGHSET_INTPOLHIGHSET ,0 : No Effect 1: Set interrupt polarity high bit to enable triggering on HIGH level or rising edge RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "GPIO_INTPOLHIGHCLR, Interrupt polarity high clear RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_INTPOLHIGHCLR_INTPOLHIGHCLR ,0 : No Effect 1: Clear interrupt polarity high bit to enable triggering on HIGH level or rising edge RESET:0x0"
          
rgroup.long 0x40++0x3
    line.long 0x00 "GPIO_INTPOLLOW, Interrupt polarity low status RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_INTPOLLOW_INTPOLLOW ,0 : Triggering on LOW level or falling edge disabled. If corresponding intpollow bit is also set to 0, the IRQ logic will not trigger on any level or edges. This case corresponds a masking of the intstatus register. 1 : Triggering on LOW level or falling edge enabled. If corresponding intpollow bit is also set to 1,    the IRQ logic will trigger on both edges (rising, falling),    if edge triggering is selected in inttype register.         Note that setting both intpolhigh and intpollow bit to 1 is not sensible            in case that level triggering is selected in inttype register.            Triggering on both levels (LOW, HIGH) would cause a permanent met interrupt condition. RESET:0x0"
          
group.long  0x44++0x3
    line.long 0x00 "GPIO_INTPOLLOWSET, Interrupt polarity low set RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_INTPOLLOWSET_INTPOLLOWSET ,0 : No Effect 1: Set interrupt polarity high bit to enable triggering on LOW level or falling edge RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "GPIO_INTPOLLOWCLR, Interrupt polarity low clear RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_INTPOLLOWCLR_INTPOLLOWCLR ,0 : No Effect 1: Clear interrupt polarity high bit to enable triggering on LOW level or falling edge RESET:0x0"
          
rgroup.long 0x4c++0x3
    line.long 0x00 "GPIO_INTSTATUS, Interrupt status RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_INTSTATUS_INTSTATUS ,0 : No Interrupt request 1: An interrupt condition was met according to config in inttype, intpolhigh and intpollow RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "GPIO_INTCLEAR, Interrupt status clear RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " GPIO_INTCLEAR_INTCLEAR ,0 : No Effect 1: Clear interrupt request in intstatus RESET:0x0"
          
tree.end

tree "PMU"
base e:0x4100a000
width 80.
group.long  0x0++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_M85, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_M85_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_M85_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_ETHOS, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_ETHOS_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_ETHOS_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_H264, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_H264_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_H264_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_EMMC, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_EMMC_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_EMMC_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_CAMERA, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_CAMERA_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_CAMERA_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_CAMERA, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_CAMERA_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_CAMERA_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_CAMERA_VP, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_CAMERA_VP_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_CAMERA_VP_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_DISPLAY, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_DISPLAY_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_DISPLAY_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_DISPLAY, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_DISPLAY_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_DISPLAY_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_DISPLAY_VP, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_DISPLAY_VP_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_DISPLAY_VP_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_GPU, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_GPU_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_GPU_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_LPDDR4, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_LPDDR4_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_LPDDR4_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_LPDDR4, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_LPDDR4_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_LPDDR4_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_ETHERNET, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_ETHERNET_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_RBB_SW_ETHERNET_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_ETHERNET, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_ETHERNET_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_ETHERNET_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_ETHERNET_PHY100, Control/Status register for a Racyics power switch instance test signals only RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_ETHERNET_PHY100_CTRL_TEST_IN ,None RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWRSW_CTRL_STATUS_ZBB_SW_ETHERNET_PHY100_STATUS_TEST_OUT ,None RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_CFG, cfg register for ri_sram_pwrgrp_ctrl RESET:0x17700f"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_CFG_PRECHARGE_CNT ,SRAM precharge duration RESET:0xf"
          
         hexmask.long 0x00 8.--23. 1. " PMU_RI_SRAM_PWRGRP_CTRL_CFG_CLKGATE_DELAY_CNT ,SRAM clock enable/disable delay duration RESET:0x1770"
          
group.long  0x44++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_CONTROL_FSM_DISPLAY, Mode control register for ri_sram_pwrgrp_ctrl FSM (mode and request) RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_CONTROL_FSM_DISPLAY_MODE ,Requested mode RESET:0x2" "STANDBY-0,POWERDOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2. " PMU_RI_SRAM_PWRGRP_CTRL_CONTROL_FSM_DISPLAY_REQ ,Write '1' to make the request (cleared by hardware) RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_EN_DISPLAY, Bypass enable register for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_EN_DISPLAY_PDRET ,Enable bypass of pdret RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_EN_DISPLAY_SRAM_PD_CLKEN ,Enable bypass of sram clock enable RESET:0x0"
          
rgroup.long 0x4c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_DISPLAY, Software status register for ri_sram_pwrgrp_ctrl instance (state, mode and busy) RESET:0x0"
         bitfld.long 0x00 26.--27. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_DISPLAY_MODE ,Current mode of the sram_pwrgrp_ctrl FSM instance. RESET:0x0" "STANDBY-0,POWERDOWN-2,RETENTION-3"
          
         bitfld.long 0x00 28.--30. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_DISPLAY_STATE ,Current state of the sram_pwrgrp_ctrl FSM instance. RESET:0x0" "S_IDLE-0,S_CHECK_TARGET-1,S_POWERDOWN-2,S_RETENTION-3,S_PRECHARGE-4,S_CLKGATE-5,S_STANDBY-6,S_CHECK_DONE-7"
          
         bitfld.long 0x00 31. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_DISPLAY_BUSY ,Indicates sram_pwrgrp_ctrl FSM instance in busy responding to a request. RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_DISPLAY_DSW_CACHE_A, Enable for each dsw_cache_a SRAM powerdomain. Note: is part of the 'display' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_display' and 'ri_sram_pwrgrp_ctrl_status_fsm_display' registers) RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_DISPLAY_DSW_CACHE_A_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x54++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_DISPLAY_DSW_CACHE_A, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_DISPLAY_DSW_CACHE_A_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x58++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_DISPLAY_DSW_CACHE_A, Bypass sram_pd_clken register for pdret RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_DISPLAY_DSW_CACHE_A_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x5c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_DISPLAY_DSW_CACHE_A, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_DISPLAY_DSW_CACHE_A_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_DISPLAY_DSW_CACHE_B, Enable for each dsw_cache_b SRAM powerdomain. Note: is part of the 'display' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_display' and 'ri_sram_pwrgrp_ctrl_status_fsm_display' registers) RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_DISPLAY_DSW_CACHE_B_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_DISPLAY_DSW_CACHE_B, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_DISPLAY_DSW_CACHE_B_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x68++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_DISPLAY_DSW_CACHE_B, Bypass sram_pd_clken register for pdret RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_DISPLAY_DSW_CACHE_B_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x6c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_DISPLAY_DSW_CACHE_B, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_DISPLAY_DSW_CACHE_B_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x70++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_DISPLAY_DSW_AXI, Enable for each dsw_axi SRAM powerdomain. Note: is part of the 'display' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_display' and 'ri_sram_pwrgrp_ctrl_status_fsm_display' registers) RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_DISPLAY_DSW_AXI_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x74++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_DISPLAY_DSW_AXI, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_DISPLAY_DSW_AXI_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x78++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_DISPLAY_DSW_AXI, Bypass sram_pd_clken register for pdret RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_DISPLAY_DSW_AXI_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x7c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_DISPLAY_DSW_AXI, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_DISPLAY_DSW_AXI_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x80++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_DISPLAY_DCU_SCAL_L, Enable for each dcu_scal_l SRAM powerdomain. Note: is part of the 'display' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_display' and 'ri_sram_pwrgrp_ctrl_status_fsm_display' registers) RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_DISPLAY_DCU_SCAL_L_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x84++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_DISPLAY_DCU_SCAL_L, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_DISPLAY_DCU_SCAL_L_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x88++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_DISPLAY_DCU_SCAL_L, Bypass sram_pd_clken register for pdret RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_DISPLAY_DCU_SCAL_L_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x8c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_DISPLAY_DCU_SCAL_L, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_DISPLAY_DCU_SCAL_L_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x90++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_DISPLAY_DCU_SCAL_H, Enable for each dcu_scal_h SRAM powerdomain. Note: is part of the 'display' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_display' and 'ri_sram_pwrgrp_ctrl_status_fsm_display' registers) RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_DISPLAY_DCU_SCAL_H_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x94++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_DISPLAY_DCU_SCAL_H, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_DISPLAY_DCU_SCAL_H_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x98++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_DISPLAY_DCU_SCAL_H, Bypass sram_pd_clken register for pdret RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_DISPLAY_DCU_SCAL_H_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x9c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_DISPLAY_DCU_SCAL_H, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_DISPLAY_DCU_SCAL_H_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0xa0++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_DISPLAY_DCU, Enable for each dcu SRAM powerdomain. Note: is part of the 'display' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_display' and 'ri_sram_pwrgrp_ctrl_status_fsm_display' registers) RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_DISPLAY_DCU_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0xa4++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_DISPLAY_DCU, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_DISPLAY_DCU_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0xa8++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_DISPLAY_DCU, Bypass sram_pd_clken register for pdret RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_DISPLAY_DCU_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0xac++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_DISPLAY_DCU, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_DISPLAY_DCU_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0xb0++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_CONTROL_FSM_ETHOS, Mode control register for ri_sram_pwrgrp_ctrl FSM (mode and request) RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_CONTROL_FSM_ETHOS_MODE ,Requested mode RESET:0x2" "STANDBY-0,POWERDOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2. " PMU_RI_SRAM_PWRGRP_CTRL_CONTROL_FSM_ETHOS_REQ ,Write '1' to make the request (cleared by hardware) RESET:0x0"
          
group.long  0xb4++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_EN_ETHOS, Bypass enable register for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_EN_ETHOS_PDRET ,Enable bypass of pdret RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_EN_ETHOS_SRAM_PD_CLKEN ,Enable bypass of sram clock enable RESET:0x0"
          
rgroup.long 0xb8++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_ETHOS, Software status register for ri_sram_pwrgrp_ctrl instance (state, mode and busy) RESET:0x0"
         bitfld.long 0x00 26.--27. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_ETHOS_MODE ,Current mode of the sram_pwrgrp_ctrl FSM instance. RESET:0x0" "STANDBY-0,POWERDOWN-2,RETENTION-3"
          
         bitfld.long 0x00 28.--30. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_ETHOS_STATE ,Current state of the sram_pwrgrp_ctrl FSM instance. RESET:0x0" "S_IDLE-0,S_CHECK_TARGET-1,S_POWERDOWN-2,S_RETENTION-3,S_PRECHARGE-4,S_CLKGATE-5,S_STANDBY-6,S_CHECK_DONE-7"
          
         bitfld.long 0x00 31. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_ETHOS_BUSY ,Indicates sram_pwrgrp_ctrl FSM instance in busy responding to a request. RESET:0x0"
          
group.long  0xbc++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_ETHOS_AB, Enable for each ab SRAM powerdomain. Note: is part of the 'ethos' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_ethos' and 'ri_sram_pwrgrp_ctrl_status_fsm_ethos' registers) RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_ETHOS_AB_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0xc0++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_ETHOS_AB, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_ETHOS_AB_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0xc4++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_ETHOS_AB, Bypass sram_pd_clken register for pdret RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_ETHOS_AB_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0xc8++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_ETHOS_AB, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_ETHOS_AB_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0xcc++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_ETHOS_LUT, Enable for each lut SRAM powerdomain. Note: is part of the 'ethos' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_ethos' and 'ri_sram_pwrgrp_ctrl_status_fsm_ethos' registers) RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_ETHOS_LUT_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0xd0++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_ETHOS_LUT, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_ETHOS_LUT_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0xd4++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_ETHOS_LUT, Bypass sram_pd_clken register for pdret RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_ETHOS_LUT_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0xd8++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_ETHOS_LUT, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_ETHOS_LUT_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0xdc++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_ETHOS_UTP, Enable for each utp SRAM powerdomain. Note: is part of the 'ethos' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_ethos' and 'ri_sram_pwrgrp_ctrl_status_fsm_ethos' registers) RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_ETHOS_UTP_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0xe0++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_ETHOS_UTP, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_ETHOS_UTP_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0xe4++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_ETHOS_UTP, Bypass sram_pd_clken register for pdret RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_ETHOS_UTP_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0xe8++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_ETHOS_UTP, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_ETHOS_UTP_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0xec++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_CONTROL_FSM_M85, Mode control register for ri_sram_pwrgrp_ctrl FSM (mode and request) RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_CONTROL_FSM_M85_MODE ,Requested mode RESET:0x2" "STANDBY-0,POWERDOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2. " PMU_RI_SRAM_PWRGRP_CTRL_CONTROL_FSM_M85_REQ ,Write '1' to make the request (cleared by hardware) RESET:0x0"
          
group.long  0xf0++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_EN_M85, Bypass enable register for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_EN_M85_PDRET ,Enable bypass of pdret RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_EN_M85_SRAM_PD_CLKEN ,Enable bypass of sram clock enable RESET:0x0"
          
rgroup.long 0xf4++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_M85, Software status register for ri_sram_pwrgrp_ctrl instance (state, mode and busy) RESET:0x0"
         bitfld.long 0x00 26.--27. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_M85_MODE ,Current mode of the sram_pwrgrp_ctrl FSM instance. RESET:0x0" "STANDBY-0,POWERDOWN-2,RETENTION-3"
          
         bitfld.long 0x00 28.--30. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_M85_STATE ,Current state of the sram_pwrgrp_ctrl FSM instance. RESET:0x0" "S_IDLE-0,S_CHECK_TARGET-1,S_POWERDOWN-2,S_RETENTION-3,S_PRECHARGE-4,S_CLKGATE-5,S_STANDBY-6,S_CHECK_DONE-7"
          
         bitfld.long 0x00 31. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_M85_BUSY ,Indicates sram_pwrgrp_ctrl FSM instance in busy responding to a request. RESET:0x0"
          
group.long  0xf8++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_M85_ITCM, Enable for each itcm SRAM powerdomain. Note: is part of the 'm85' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_m85' and 'ri_sram_pwrgrp_ctrl_status_fsm_m85' registers) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_M85_ITCM_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0xfc++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_ITCM, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0xaaaa"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_ITCM_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2.--3. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_ITCM_PD1 ,power domain 1 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 4.--5. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_ITCM_PD2 ,power domain 2 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 6.--7. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_ITCM_PD3 ,power domain 3 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 8.--9. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_ITCM_PD4 ,power domain 4 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 10.--11. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_ITCM_PD5 ,power domain 5 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 12.--13. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_ITCM_PD6 ,power domain 6 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 14.--15. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_ITCM_PD7 ,power domain 7 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x100++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_M85_ITCM, Bypass sram_pd_clken register for pdret RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_M85_ITCM_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x104++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_M85_ITCM, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_M85_ITCM_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x108++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_M85_D3TCM, Enable for each d3tcm SRAM powerdomain. Note: is part of the 'm85' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_m85' and 'ri_sram_pwrgrp_ctrl_status_fsm_m85' registers) RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_M85_D3TCM_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x10c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_D3TCM, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0xa"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_D3TCM_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2.--3. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_D3TCM_PD1 ,power domain 1 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x110++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_M85_D3TCM, Bypass sram_pd_clken register for pdret RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_M85_D3TCM_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x114++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_M85_D3TCM, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_M85_D3TCM_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x118++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_M85_D2TCM, Enable for each d2tcm SRAM powerdomain. Note: is part of the 'm85' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_m85' and 'ri_sram_pwrgrp_ctrl_status_fsm_m85' registers) RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_M85_D2TCM_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x11c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_D2TCM, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0xa"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_D2TCM_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2.--3. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_D2TCM_PD1 ,power domain 1 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x120++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_M85_D2TCM, Bypass sram_pd_clken register for pdret RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_M85_D2TCM_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x124++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_M85_D2TCM, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_M85_D2TCM_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x128++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_M85_D1TCM, Enable for each d1tcm SRAM powerdomain. Note: is part of the 'm85' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_m85' and 'ri_sram_pwrgrp_ctrl_status_fsm_m85' registers) RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_M85_D1TCM_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x12c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_D1TCM, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0xa"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_D1TCM_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2.--3. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_D1TCM_PD1 ,power domain 1 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x130++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_M85_D1TCM, Bypass sram_pd_clken register for pdret RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_M85_D1TCM_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x134++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_M85_D1TCM, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_M85_D1TCM_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x138++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_M85_D0TCM, Enable for each d0tcm SRAM powerdomain. Note: is part of the 'm85' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_m85' and 'ri_sram_pwrgrp_ctrl_status_fsm_m85' registers) RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_M85_D0TCM_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x13c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_D0TCM, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0xa"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_D0TCM_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2.--3. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_D0TCM_PD1 ,power domain 1 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x140++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_M85_D0TCM, Bypass sram_pd_clken register for pdret RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_M85_D0TCM_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x144++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_M85_D0TCM, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_M85_D0TCM_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x148++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_M85_CACHE, Enable for each cache SRAM powerdomain. Note: is part of the 'm85' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_m85' and 'ri_sram_pwrgrp_ctrl_status_fsm_m85' registers) RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_M85_CACHE_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x14c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_CACHE, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_M85_CACHE_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x150++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_M85_CACHE, Bypass sram_pd_clken register for pdret RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_M85_CACHE_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x154++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_M85_CACHE, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_M85_CACHE_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x158++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_CONTROL_FSM_RBB, Mode control register for ri_sram_pwrgrp_ctrl FSM (mode and request) RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_CONTROL_FSM_RBB_MODE ,Requested mode RESET:0x2" "STANDBY-0,POWERDOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2. " PMU_RI_SRAM_PWRGRP_CTRL_CONTROL_FSM_RBB_REQ ,Write '1' to make the request (cleared by hardware) RESET:0x0"
          
group.long  0x15c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_EN_RBB, Bypass enable register for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_EN_RBB_PDRET ,Enable bypass of pdret RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_EN_RBB_SRAM_PD_CLKEN ,Enable bypass of sram clock enable RESET:0x0"
          
rgroup.long 0x160++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_RBB, Software status register for ri_sram_pwrgrp_ctrl instance (state, mode and busy) RESET:0x0"
         bitfld.long 0x00 26.--27. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_RBB_MODE ,Current mode of the sram_pwrgrp_ctrl FSM instance. RESET:0x0" "STANDBY-0,POWERDOWN-2,RETENTION-3"
          
         bitfld.long 0x00 28.--30. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_RBB_STATE ,Current state of the sram_pwrgrp_ctrl FSM instance. RESET:0x0" "S_IDLE-0,S_CHECK_TARGET-1,S_POWERDOWN-2,S_RETENTION-3,S_PRECHARGE-4,S_CLKGATE-5,S_STANDBY-6,S_CHECK_DONE-7"
          
         bitfld.long 0x00 31. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_FSM_RBB_BUSY ,Indicates sram_pwrgrp_ctrl FSM instance in busy responding to a request. RESET:0x0"
          
group.long  0x164++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_RBB_M4IRAM, Enable for each m4iram SRAM powerdomain. Note: is part of the 'rbb' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_rbb' and 'ri_sram_pwrgrp_ctrl_status_fsm_rbb' registers) RESET:0xf"
         hexmask.long 0x00 0.--3. 1. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_RBB_M4IRAM_PD_EN ,Requested pd_en RESET:0xf"
          
group.long  0x168++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_M4IRAM, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0xaa"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_M4IRAM_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2.--3. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_M4IRAM_PD1 ,power domain 1 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 4.--5. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_M4IRAM_PD2 ,power domain 2 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 6.--7. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_M4IRAM_PD3 ,power domain 3 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x16c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_RBB_M4IRAM, Bypass sram_pd_clken register for pdret RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_RBB_M4IRAM_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x170++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_RBB_M4IRAM, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_RBB_M4IRAM_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x174++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_RBB_M4DRAM, Enable for each m4dram SRAM powerdomain. Note: is part of the 'rbb' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_rbb' and 'ri_sram_pwrgrp_ctrl_status_fsm_rbb' registers) RESET:0x3"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_RBB_M4DRAM_PD_EN ,Requested pd_en RESET:0x3"
          
group.long  0x178++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_M4DRAM, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0xa"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_M4DRAM_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2.--3. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_M4DRAM_PD1 ,power domain 1 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x17c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_RBB_M4DRAM, Bypass sram_pd_clken register for pdret RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_RBB_M4DRAM_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x180++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_RBB_M4DRAM, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_RBB_M4DRAM_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x184++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_RBB_SRAM1, Enable for each sram1 SRAM powerdomain. Note: is part of the 'rbb' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_rbb' and 'ri_sram_pwrgrp_ctrl_status_fsm_rbb' registers) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_RBB_SRAM1_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x188++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM1, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0xaaaa"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM1_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2.--3. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM1_PD1 ,power domain 1 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 4.--5. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM1_PD2 ,power domain 2 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 6.--7. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM1_PD3 ,power domain 3 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 8.--9. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM1_PD4 ,power domain 4 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 10.--11. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM1_PD5 ,power domain 5 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 12.--13. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM1_PD6 ,power domain 6 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 14.--15. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM1_PD7 ,power domain 7 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x18c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_RBB_SRAM1, Bypass sram_pd_clken register for pdret RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_RBB_SRAM1_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x190++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_RBB_SRAM1, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_RBB_SRAM1_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x194++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_RBB_SRAM2, Enable for each sram2 SRAM powerdomain. Note: is part of the 'rbb' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_rbb' and 'ri_sram_pwrgrp_ctrl_status_fsm_rbb' registers) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_RBB_SRAM2_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x198++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM2, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0xaaaa"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM2_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2.--3. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM2_PD1 ,power domain 1 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 4.--5. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM2_PD2 ,power domain 2 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 6.--7. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM2_PD3 ,power domain 3 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 8.--9. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM2_PD4 ,power domain 4 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 10.--11. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM2_PD5 ,power domain 5 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 12.--13. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM2_PD6 ,power domain 6 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 14.--15. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM2_PD7 ,power domain 7 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x19c++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_RBB_SRAM2, Bypass sram_pd_clken register for pdret RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_RBB_SRAM2_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x1a0++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_RBB_SRAM2, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_RBB_SRAM2_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x1a4++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_RBB_SRAM3, Enable for each sram3 SRAM powerdomain. Note: is part of the 'rbb' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_rbb' and 'ri_sram_pwrgrp_ctrl_status_fsm_rbb' registers) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_RBB_SRAM3_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x1a8++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM3, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0xaaaa"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM3_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2.--3. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM3_PD1 ,power domain 1 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 4.--5. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM3_PD2 ,power domain 2 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 6.--7. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM3_PD3 ,power domain 3 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 8.--9. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM3_PD4 ,power domain 4 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 10.--11. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM3_PD5 ,power domain 5 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 12.--13. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM3_PD6 ,power domain 6 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 14.--15. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM3_PD7 ,power domain 7 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x1ac++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_RBB_SRAM3, Bypass sram_pd_clken register for pdret RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_RBB_SRAM3_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x1b0++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_RBB_SRAM3, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_RBB_SRAM3_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x1b4++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_RBB_SRAM4, Enable for each sram4 SRAM powerdomain. Note: is part of the 'rbb' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_rbb' and 'ri_sram_pwrgrp_ctrl_status_fsm_rbb' registers) RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_RBB_SRAM4_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x1b8++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM4, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0xaaaa"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM4_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 2.--3. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM4_PD1 ,power domain 1 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 4.--5. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM4_PD2 ,power domain 2 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 6.--7. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM4_PD3 ,power domain 3 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 8.--9. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM4_PD4 ,power domain 4 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 10.--11. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM4_PD5 ,power domain 5 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 12.--13. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM4_PD6 ,power domain 6 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
         bitfld.long 0x00 14.--15. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_SRAM4_PD7 ,power domain 7 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x1bc++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_RBB_SRAM4, Bypass sram_pd_clken register for pdret RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_RBB_SRAM4_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x1c0++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_RBB_SRAM4, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_RBB_SRAM4_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x1c4++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_RBB_KIVI, Enable for each kivi SRAM powerdomain. Note: is part of the 'rbb' powergroup (see 'ri_sram_pwrgrp_ctrl_control_fsm_rbb' and 'ri_sram_pwrgrp_ctrl_status_fsm_rbb' registers) RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_PD_EN_RBB_KIVI_PD_EN ,Requested pd_en RESET:0x0"
          
group.long  0x1c8++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_KIVI, Bypass pdret register for SRAM_PWRGRP_CTRL FSM RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_PDRET_RBB_KIVI_PD0 ,power domain 0 RESET:0x2" "STANDBY-0,PRECHARGE-1,POWER_DOWN-2,RETENTION-3"
          
group.long  0x1cc++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_RBB_KIVI, Bypass sram_pd_clken register for pdret RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_BYPASS_SRAM_PD_CLKEN_RBB_KIVI_SRAM_PD_CLKEN ,ri_sram_pwrgrp_ctrl bypass sram clock enable RESET:0x0"
          
rgroup.long 0x1d0++0x3
    line.long 0x00 "PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_RBB_KIVI, Status register (pd_en values) for ri_sram_pwrgrp_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_SRAM_PWRGRP_CTRL_STATUS_PD_EN_RBB_KIVI_PD_EN ,Enabled power domains of the sram_pwrgrp_ctrl FSM instance. RESET:0x0"
          
group.long  0x1d4++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_CTRL_CFG, None RESET:0x32"
         hexmask.long 0x00 0.--7. 1. " PMU_RI_PWR_DOMAIN_CTRL_CFG_PRECHARGE_CNT ,Precharge counter (Delay between setting RI_PWRSW precharge before setting enable.). RESET:0x32"
          
group.long  0x1d8++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_CTRL_M85, Software control register for ri_pwr_domain_ctrl RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_PWR_DOMAIN_CTRL_M85_MODE ,Requested mode RESET:0x2" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_CTRL_M85_REQ ,Write '1' to make the request (cleared by hardware) RESET:0x0"
          
group.long  0x1dc++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_EN_M85, Bypass enable register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_EN_M85_PC ,Enable bypass of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_EN_M85_PDL ,Enable bypass of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_EN_M85_RSTN ,Enable bypass of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_EN_M85_ISO_N ,Enable bypass of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_EN_M85_CLK_EN ,Enable bypass of clk_en RESET:0x0"
          
group.long  0x1e0++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_M85, Bypass register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_M85_PC ,Bypass value of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_M85_PDL ,Bypass value of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_M85_RSTN ,Bypass value of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_M85_ISO_N ,Bypass value of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_M85_CLK_EN ,Bypass value of clk_en RESET:0x0"
          
rgroup.long 0x1e4++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_STATUS_M85, Status register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0.--4. " PMU_RI_PWR_DOMAIN_STATUS_M85_FSM_STATE ,Current state of the FSM instance. RESET:0x0" "S_OFF-0,S_PRECHARGE-1,S_POWER_UP-2,S_PRE_ISO_CLK_EN-3,S_PRE_ISO_CLK_EN_ACK-4,S_REQ_MEM_STANDBY-5,S_MEM_STANDBY_DONE-6,S_DIS_RST-7,S_DIS_ISO-8,S_EN_CLK-9,S_ACTIVE-10,S_DIS_CLK-11,S_EN_ISO-12,S_EN_RST-13,S_REQ_MEM_POWERDOWN-14,S_MEM_POWERDOWN_DONE-15,S_POWER_DOWN-16,S_IDLE-17,S_REQ_MEM_RETENTION-18,S_MEM_RETENTION_DONE-19,S_RETENTION-20"
          
         bitfld.long 0x00 5.--6. " PMU_RI_PWR_DOMAIN_STATUS_M85_MODE ,Current mode of the FSM instance. RESET:0x0" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 31. " PMU_RI_PWR_DOMAIN_STATUS_M85_BUSY ,Indicates FSM instance in busy responding to a request. RESET:0x0"
          
group.long  0x1e8++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_CTRL_ETHOS, Software control register for ri_pwr_domain_ctrl RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_PWR_DOMAIN_CTRL_ETHOS_MODE ,Requested mode RESET:0x2" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_CTRL_ETHOS_REQ ,Write '1' to make the request (cleared by hardware) RESET:0x0"
          
group.long  0x1ec++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_EN_ETHOS, Bypass enable register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_EN_ETHOS_PC ,Enable bypass of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_EN_ETHOS_PDL ,Enable bypass of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_EN_ETHOS_RSTN ,Enable bypass of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_EN_ETHOS_ISO_N ,Enable bypass of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_EN_ETHOS_CLK_EN ,Enable bypass of clk_en RESET:0x0"
          
group.long  0x1f0++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_ETHOS, Bypass register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_ETHOS_PC ,Bypass value of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_ETHOS_PDL ,Bypass value of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_ETHOS_RSTN ,Bypass value of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_ETHOS_ISO_N ,Bypass value of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_ETHOS_CLK_EN ,Bypass value of clk_en RESET:0x0"
          
rgroup.long 0x1f4++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_STATUS_ETHOS, Status register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0.--4. " PMU_RI_PWR_DOMAIN_STATUS_ETHOS_FSM_STATE ,Current state of the FSM instance. RESET:0x0" "S_OFF-0,S_PRECHARGE-1,S_POWER_UP-2,S_PRE_ISO_CLK_EN-3,S_PRE_ISO_CLK_EN_ACK-4,S_REQ_MEM_STANDBY-5,S_MEM_STANDBY_DONE-6,S_DIS_RST-7,S_DIS_ISO-8,S_EN_CLK-9,S_ACTIVE-10,S_DIS_CLK-11,S_EN_ISO-12,S_EN_RST-13,S_REQ_MEM_POWERDOWN-14,S_MEM_POWERDOWN_DONE-15,S_POWER_DOWN-16,S_IDLE-17,S_REQ_MEM_RETENTION-18,S_MEM_RETENTION_DONE-19,S_RETENTION-20"
          
         bitfld.long 0x00 5.--6. " PMU_RI_PWR_DOMAIN_STATUS_ETHOS_MODE ,Current mode of the FSM instance. RESET:0x0" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 31. " PMU_RI_PWR_DOMAIN_STATUS_ETHOS_BUSY ,Indicates FSM instance in busy responding to a request. RESET:0x0"
          
group.long  0x1f8++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_CTRL_DISPLAY, Software control register for ri_pwr_domain_ctrl RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_PWR_DOMAIN_CTRL_DISPLAY_MODE ,Requested mode RESET:0x2" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_CTRL_DISPLAY_REQ ,Write '1' to make the request (cleared by hardware) RESET:0x0"
          
group.long  0x1fc++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_EN_DISPLAY, Bypass enable register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_EN_DISPLAY_PC ,Enable bypass of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_EN_DISPLAY_PDL ,Enable bypass of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_EN_DISPLAY_RSTN ,Enable bypass of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_EN_DISPLAY_ISO_N ,Enable bypass of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_EN_DISPLAY_CLK_EN ,Enable bypass of clk_en RESET:0x0"
          
group.long  0x200++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_DISPLAY, Bypass register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_DISPLAY_PC ,Bypass value of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_DISPLAY_PDL ,Bypass value of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_DISPLAY_RSTN ,Bypass value of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_DISPLAY_ISO_N ,Bypass value of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_DISPLAY_CLK_EN ,Bypass value of clk_en RESET:0x0"
          
rgroup.long 0x204++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_STATUS_DISPLAY, Status register for ri_pwr_domain_ctrl and ri_pwr_domain_nested_ctrl RESET:0x0"
         bitfld.long 0x00 0.--2. " PMU_RI_PWR_DOMAIN_STATUS_DISPLAY_NESTED_FSM_STATE ,Current state of the nested FSM instance. RESET:0x0" "S_WAIT_FOR_CHANGE-0,S_RAISE_PC-1,S_RAISE_PDL-2,S_LOWER_PC-3,S_LOWER_PDL-4,S_LOWER_PC_AND_PDL-5"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_STATUS_DISPLAY_NESTED_FSM_BUSY ,None RESET:0x0"
          
         bitfld.long 0x00 4.--8. " PMU_RI_PWR_DOMAIN_STATUS_DISPLAY_FSM_STATE ,Current state of the FSM instance. RESET:0x0" "S_OFF-0,S_PRECHARGE-1,S_POWER_UP-2,S_PRE_ISO_CLK_EN-3,S_PRE_ISO_CLK_EN_ACK-4,S_REQ_MEM_STANDBY-5,S_MEM_STANDBY_DONE-6,S_DIS_RST-7,S_DIS_ISO-8,S_EN_CLK-9,S_ACTIVE-10,S_DIS_CLK-11,S_EN_ISO-12,S_EN_RST-13,S_REQ_MEM_POWERDOWN-14,S_MEM_POWERDOWN_DONE-15,S_POWER_DOWN-16,S_IDLE-17,S_REQ_MEM_RETENTION-18,S_MEM_RETENTION_DONE-19,S_RETENTION-20"
          
         bitfld.long 0x00 9.--10. " PMU_RI_PWR_DOMAIN_STATUS_DISPLAY_MODE ,Current mode of the FSM instance. RESET:0x0" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 31. " PMU_RI_PWR_DOMAIN_STATUS_DISPLAY_BUSY ,Indicates FSM instance in busy responding to a request. RESET:0x0"
          
group.long  0x208++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_CTRL_LPDDR4, Software control register for ri_pwr_domain_ctrl RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_PWR_DOMAIN_CTRL_LPDDR4_MODE ,Requested mode RESET:0x2" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_CTRL_LPDDR4_REQ ,Write '1' to make the request (cleared by hardware) RESET:0x0"
          
group.long  0x20c++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_EN_LPDDR4, Bypass enable register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_EN_LPDDR4_PC ,Enable bypass of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_EN_LPDDR4_PDL ,Enable bypass of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_EN_LPDDR4_RSTN ,Enable bypass of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_EN_LPDDR4_ISO_N ,Enable bypass of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_EN_LPDDR4_CLK_EN ,Enable bypass of clk_en RESET:0x0"
          
group.long  0x210++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_LPDDR4, Bypass register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_LPDDR4_PC ,Bypass value of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_LPDDR4_PDL ,Bypass value of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_LPDDR4_RSTN ,Bypass value of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_LPDDR4_ISO_N ,Bypass value of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_LPDDR4_CLK_EN ,Bypass value of clk_en RESET:0x0"
          
rgroup.long 0x214++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_STATUS_LPDDR4, Status register for ri_pwr_domain_ctrl and ri_pwr_domain_nested_ctrl RESET:0x0"
         bitfld.long 0x00 0.--2. " PMU_RI_PWR_DOMAIN_STATUS_LPDDR4_NESTED_FSM_STATE ,Current state of the nested FSM instance. RESET:0x0" "S_WAIT_FOR_CHANGE-0,S_RAISE_PC-1,S_RAISE_PDL-2,S_LOWER_PC-3,S_LOWER_PDL-4,S_LOWER_PC_AND_PDL-5"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_STATUS_LPDDR4_NESTED_FSM_BUSY ,None RESET:0x0"
          
         bitfld.long 0x00 4.--8. " PMU_RI_PWR_DOMAIN_STATUS_LPDDR4_FSM_STATE ,Current state of the FSM instance. RESET:0x0" "S_OFF-0,S_PRECHARGE-1,S_POWER_UP-2,S_PRE_ISO_CLK_EN-3,S_PRE_ISO_CLK_EN_ACK-4,S_REQ_MEM_STANDBY-5,S_MEM_STANDBY_DONE-6,S_DIS_RST-7,S_DIS_ISO-8,S_EN_CLK-9,S_ACTIVE-10,S_DIS_CLK-11,S_EN_ISO-12,S_EN_RST-13,S_REQ_MEM_POWERDOWN-14,S_MEM_POWERDOWN_DONE-15,S_POWER_DOWN-16,S_IDLE-17,S_REQ_MEM_RETENTION-18,S_MEM_RETENTION_DONE-19,S_RETENTION-20"
          
         bitfld.long 0x00 9.--10. " PMU_RI_PWR_DOMAIN_STATUS_LPDDR4_MODE ,Current mode of the FSM instance. RESET:0x0" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 31. " PMU_RI_PWR_DOMAIN_STATUS_LPDDR4_BUSY ,Indicates FSM instance in busy responding to a request. RESET:0x0"
          
group.long  0x218++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_CTRL_CAMERA, Software control register for ri_pwr_domain_ctrl RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_PWR_DOMAIN_CTRL_CAMERA_MODE ,Requested mode RESET:0x2" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_CTRL_CAMERA_REQ ,Write '1' to make the request (cleared by hardware) RESET:0x0"
          
group.long  0x21c++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_EN_CAMERA, Bypass enable register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_EN_CAMERA_PC ,Enable bypass of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_EN_CAMERA_PDL ,Enable bypass of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_EN_CAMERA_RSTN ,Enable bypass of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_EN_CAMERA_ISO_N ,Enable bypass of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_EN_CAMERA_CLK_EN ,Enable bypass of clk_en RESET:0x0"
          
group.long  0x220++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_CAMERA, Bypass register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_CAMERA_PC ,Bypass value of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_CAMERA_PDL ,Bypass value of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_CAMERA_RSTN ,Bypass value of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_CAMERA_ISO_N ,Bypass value of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_CAMERA_CLK_EN ,Bypass value of clk_en RESET:0x0"
          
rgroup.long 0x224++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_STATUS_CAMERA, Status register for ri_pwr_domain_ctrl and ri_pwr_domain_nested_ctrl RESET:0x0"
         bitfld.long 0x00 0.--2. " PMU_RI_PWR_DOMAIN_STATUS_CAMERA_NESTED_FSM_STATE ,Current state of the nested FSM instance. RESET:0x0" "S_WAIT_FOR_CHANGE-0,S_RAISE_PC-1,S_RAISE_PDL-2,S_LOWER_PC-3,S_LOWER_PDL-4,S_LOWER_PC_AND_PDL-5"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_STATUS_CAMERA_NESTED_FSM_BUSY ,None RESET:0x0"
          
         bitfld.long 0x00 4.--8. " PMU_RI_PWR_DOMAIN_STATUS_CAMERA_FSM_STATE ,Current state of the FSM instance. RESET:0x0" "S_OFF-0,S_PRECHARGE-1,S_POWER_UP-2,S_PRE_ISO_CLK_EN-3,S_PRE_ISO_CLK_EN_ACK-4,S_REQ_MEM_STANDBY-5,S_MEM_STANDBY_DONE-6,S_DIS_RST-7,S_DIS_ISO-8,S_EN_CLK-9,S_ACTIVE-10,S_DIS_CLK-11,S_EN_ISO-12,S_EN_RST-13,S_REQ_MEM_POWERDOWN-14,S_MEM_POWERDOWN_DONE-15,S_POWER_DOWN-16,S_IDLE-17,S_REQ_MEM_RETENTION-18,S_MEM_RETENTION_DONE-19,S_RETENTION-20"
          
         bitfld.long 0x00 9.--10. " PMU_RI_PWR_DOMAIN_STATUS_CAMERA_MODE ,Current mode of the FSM instance. RESET:0x0" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 31. " PMU_RI_PWR_DOMAIN_STATUS_CAMERA_BUSY ,Indicates FSM instance in busy responding to a request. RESET:0x0"
          
group.long  0x228++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_CTRL_ETHERNET, Software control register for ri_pwr_domain_ctrl RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_PWR_DOMAIN_CTRL_ETHERNET_MODE ,Requested mode RESET:0x2" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_CTRL_ETHERNET_REQ ,Write '1' to make the request (cleared by hardware) RESET:0x0"
          
group.long  0x22c++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_EN_ETHERNET, Bypass enable register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_EN_ETHERNET_PC ,Enable bypass of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_EN_ETHERNET_PDL ,Enable bypass of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_EN_ETHERNET_RSTN ,Enable bypass of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_EN_ETHERNET_ISO_N ,Enable bypass of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_EN_ETHERNET_CLK_EN ,Enable bypass of clk_en RESET:0x0"
          
group.long  0x230++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_ETHERNET, Bypass register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_ETHERNET_PC ,Bypass value of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_ETHERNET_PDL ,Bypass value of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_ETHERNET_RSTN ,Bypass value of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_ETHERNET_ISO_N ,Bypass value of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_ETHERNET_CLK_EN ,Bypass value of clk_en RESET:0x0"
          
rgroup.long 0x234++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_STATUS_ETHERNET, Status register for ri_pwr_domain_ctrl and ri_pwr_domain_nested_ctrl RESET:0x0"
         bitfld.long 0x00 0.--2. " PMU_RI_PWR_DOMAIN_STATUS_ETHERNET_NESTED_FSM_STATE ,Current state of the nested FSM instance. RESET:0x0" "S_WAIT_FOR_CHANGE-0,S_RAISE_PC-1,S_RAISE_PDL-2,S_LOWER_PC-3,S_LOWER_PDL-4,S_LOWER_PC_AND_PDL-5"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_STATUS_ETHERNET_NESTED_FSM_BUSY ,None RESET:0x0"
          
         bitfld.long 0x00 4.--8. " PMU_RI_PWR_DOMAIN_STATUS_ETHERNET_FSM_STATE ,Current state of the FSM instance. RESET:0x0" "S_OFF-0,S_PRECHARGE-1,S_POWER_UP-2,S_PRE_ISO_CLK_EN-3,S_PRE_ISO_CLK_EN_ACK-4,S_REQ_MEM_STANDBY-5,S_MEM_STANDBY_DONE-6,S_DIS_RST-7,S_DIS_ISO-8,S_EN_CLK-9,S_ACTIVE-10,S_DIS_CLK-11,S_EN_ISO-12,S_EN_RST-13,S_REQ_MEM_POWERDOWN-14,S_MEM_POWERDOWN_DONE-15,S_POWER_DOWN-16,S_IDLE-17,S_REQ_MEM_RETENTION-18,S_MEM_RETENTION_DONE-19,S_RETENTION-20"
          
         bitfld.long 0x00 9.--10. " PMU_RI_PWR_DOMAIN_STATUS_ETHERNET_MODE ,Current mode of the FSM instance. RESET:0x0" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 31. " PMU_RI_PWR_DOMAIN_STATUS_ETHERNET_BUSY ,Indicates FSM instance in busy responding to a request. RESET:0x0"
          
group.long  0x238++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_CTRL_H264, Software control register for ri_pwr_domain_ctrl RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_PWR_DOMAIN_CTRL_H264_MODE ,Requested mode RESET:0x2" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_CTRL_H264_REQ ,Write '1' to make the request (cleared by hardware) RESET:0x0"
          
group.long  0x23c++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_EN_H264, Bypass enable register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_EN_H264_PC ,Enable bypass of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_EN_H264_PDL ,Enable bypass of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_EN_H264_RSTN ,Enable bypass of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_EN_H264_ISO_N ,Enable bypass of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_EN_H264_CLK_EN ,Enable bypass of clk_en RESET:0x0"
          
group.long  0x240++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_H264, Bypass register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_H264_PC ,Bypass value of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_H264_PDL ,Bypass value of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_H264_RSTN ,Bypass value of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_H264_ISO_N ,Bypass value of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_H264_CLK_EN ,Bypass value of clk_en RESET:0x0"
          
rgroup.long 0x244++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_STATUS_H264, Status register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0.--4. " PMU_RI_PWR_DOMAIN_STATUS_H264_FSM_STATE ,Current state of the FSM instance. RESET:0x0" "S_OFF-0,S_PRECHARGE-1,S_POWER_UP-2,S_PRE_ISO_CLK_EN-3,S_PRE_ISO_CLK_EN_ACK-4,S_REQ_MEM_STANDBY-5,S_MEM_STANDBY_DONE-6,S_DIS_RST-7,S_DIS_ISO-8,S_EN_CLK-9,S_ACTIVE-10,S_DIS_CLK-11,S_EN_ISO-12,S_EN_RST-13,S_REQ_MEM_POWERDOWN-14,S_MEM_POWERDOWN_DONE-15,S_POWER_DOWN-16,S_IDLE-17,S_REQ_MEM_RETENTION-18,S_MEM_RETENTION_DONE-19,S_RETENTION-20"
          
         bitfld.long 0x00 5.--6. " PMU_RI_PWR_DOMAIN_STATUS_H264_MODE ,Current mode of the FSM instance. RESET:0x0" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 31. " PMU_RI_PWR_DOMAIN_STATUS_H264_BUSY ,Indicates FSM instance in busy responding to a request. RESET:0x0"
          
group.long  0x248++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_CTRL_EMMC, Software control register for ri_pwr_domain_ctrl RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_PWR_DOMAIN_CTRL_EMMC_MODE ,Requested mode RESET:0x2" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_CTRL_EMMC_REQ ,Write '1' to make the request (cleared by hardware) RESET:0x0"
          
group.long  0x24c++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_EN_EMMC, Bypass enable register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_EN_EMMC_PC ,Enable bypass of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_EN_EMMC_PDL ,Enable bypass of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_EN_EMMC_RSTN ,Enable bypass of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_EN_EMMC_ISO_N ,Enable bypass of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_EN_EMMC_CLK_EN ,Enable bypass of clk_en RESET:0x0"
          
group.long  0x250++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_EMMC, Bypass register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_EMMC_PC ,Bypass value of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_EMMC_PDL ,Bypass value of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_EMMC_RSTN ,Bypass value of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_EMMC_ISO_N ,Bypass value of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_EMMC_CLK_EN ,Bypass value of clk_en RESET:0x0"
          
rgroup.long 0x254++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_STATUS_EMMC, Status register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0.--4. " PMU_RI_PWR_DOMAIN_STATUS_EMMC_FSM_STATE ,Current state of the FSM instance. RESET:0x0" "S_OFF-0,S_PRECHARGE-1,S_POWER_UP-2,S_PRE_ISO_CLK_EN-3,S_PRE_ISO_CLK_EN_ACK-4,S_REQ_MEM_STANDBY-5,S_MEM_STANDBY_DONE-6,S_DIS_RST-7,S_DIS_ISO-8,S_EN_CLK-9,S_ACTIVE-10,S_DIS_CLK-11,S_EN_ISO-12,S_EN_RST-13,S_REQ_MEM_POWERDOWN-14,S_MEM_POWERDOWN_DONE-15,S_POWER_DOWN-16,S_IDLE-17,S_REQ_MEM_RETENTION-18,S_MEM_RETENTION_DONE-19,S_RETENTION-20"
          
         bitfld.long 0x00 5.--6. " PMU_RI_PWR_DOMAIN_STATUS_EMMC_MODE ,Current mode of the FSM instance. RESET:0x0" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 31. " PMU_RI_PWR_DOMAIN_STATUS_EMMC_BUSY ,Indicates FSM instance in busy responding to a request. RESET:0x0"
          
group.long  0x258++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_CTRL_GPU, Software control register for ri_pwr_domain_ctrl RESET:0x2"
         bitfld.long 0x00 0.--1. " PMU_RI_PWR_DOMAIN_CTRL_GPU_MODE ,Requested mode RESET:0x2" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_CTRL_GPU_REQ ,Write '1' to make the request (cleared by hardware) RESET:0x0"
          
group.long  0x25c++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_EN_GPU, Bypass enable register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_EN_GPU_PC ,Enable bypass of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_EN_GPU_PDL ,Enable bypass of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_EN_GPU_RSTN ,Enable bypass of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_EN_GPU_ISO_N ,Enable bypass of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_EN_GPU_CLK_EN ,Enable bypass of clk_en RESET:0x0"
          
group.long  0x260++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_BYPASS_GPU, Bypass register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_BYPASS_GPU_PC ,Bypass value of pc (precharge) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_BYPASS_GPU_PDL ,Bypass value of pdl (powerdown active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_BYPASS_GPU_RSTN ,Bypass value of rstn RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_BYPASS_GPU_ISO_N ,Bypass value of iso_n RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_BYPASS_GPU_CLK_EN ,Bypass value of clk_en RESET:0x0"
          
rgroup.long 0x264++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_STATUS_GPU, Status register for ri_pwr_domain_ctrl RESET:0x0"
         bitfld.long 0x00 0.--4. " PMU_RI_PWR_DOMAIN_STATUS_GPU_FSM_STATE ,Current state of the FSM instance. RESET:0x0" "S_OFF-0,S_PRECHARGE-1,S_POWER_UP-2,S_PRE_ISO_CLK_EN-3,S_PRE_ISO_CLK_EN_ACK-4,S_REQ_MEM_STANDBY-5,S_MEM_STANDBY_DONE-6,S_DIS_RST-7,S_DIS_ISO-8,S_EN_CLK-9,S_ACTIVE-10,S_DIS_CLK-11,S_EN_ISO-12,S_EN_RST-13,S_REQ_MEM_POWERDOWN-14,S_MEM_POWERDOWN_DONE-15,S_POWER_DOWN-16,S_IDLE-17,S_REQ_MEM_RETENTION-18,S_MEM_RETENTION_DONE-19,S_RETENTION-20"
          
         bitfld.long 0x00 5.--6. " PMU_RI_PWR_DOMAIN_STATUS_GPU_MODE ,Current mode of the FSM instance. RESET:0x0" "ACTIVE-0,IDLE-1,OFF-2,RETENTION-3"
          
         bitfld.long 0x00 31. " PMU_RI_PWR_DOMAIN_STATUS_GPU_BUSY ,Indicates FSM instance in busy responding to a request. RESET:0x0"
          
group.long  0x268++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_CAMERA, None RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_CAMERA_RBB_SW_CAMERA_PC ,Enabled the bypass of camera HLB rbb_sw_camera precharge RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_CAMERA_RBB_SW_CAMERA_PDL ,Enabled the bypass of camera HLB rbb_sw_camera powerdown (active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_CAMERA_ZBB_SW_CAMERA_PC ,Enabled the bypass of camera HLB zbb_sw_camera precharge RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_CAMERA_ZBB_SW_CAMERA_PDL ,Enabled the bypass of camera HLB zbb_sw_camera powerdown (active-low) RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_CAMERA_ZBB_SW_CAMERA_VP_PC ,Enabled the bypass of camera HLB zbb_sw_camera_vp precharge RESET:0x0"
          
         bitfld.long 0x00 5. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_CAMERA_ZBB_SW_CAMERA_VP_PDL ,Enabled the bypass of camera HLB zbb_sw_camera_vp powerdown (active-low) RESET:0x0"
          
group.long  0x26c++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_NESTED_BYPASS_CAMERA, None RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_CAMERA_RBB_SW_CAMERA_PC ,Bypass value of camera HLB rbb_sw_camera precharge RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_CAMERA_RBB_SW_CAMERA_PDL ,Bypass value of camera HLB rbb_sw_camera powerdown (active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_CAMERA_ZBB_SW_CAMERA_PC ,Bypass value of camera HLB zbb_sw_camera precharge RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_CAMERA_ZBB_SW_CAMERA_PDL ,Bypass value of camera HLB zbb_sw_camera powerdown (active-low) RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_CAMERA_ZBB_SW_CAMERA_VP_PC ,Bypass value of camera HLB zbb_sw_camera_vp precharge RESET:0x0"
          
         bitfld.long 0x00 5. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_CAMERA_ZBB_SW_CAMERA_VP_PDL ,Bypass value of camera HLB zbb_sw_camera_vp powerdown (active-low) RESET:0x0"
          
group.long  0x270++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_DISPLAY, None RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_DISPLAY_RBB_SW_DISPLAY_PC ,Enabled the bypass of display HLB rbb_sw_display precharge RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_DISPLAY_RBB_SW_DISPLAY_PDL ,Enabled the bypass of display HLB rbb_sw_display powerdown (active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_DISPLAY_ZBB_SW_DISPLAY_PC ,Enabled the bypass of display HLB zbb_sw_display precharge RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_DISPLAY_ZBB_SW_DISPLAY_PDL ,Enabled the bypass of display HLB zbb_sw_display powerdown (active-low) RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_DISPLAY_ZBB_SW_DISPLAY_VP_PC ,Enabled the bypass of display HLB zbb_sw_display_vp precharge RESET:0x0"
          
         bitfld.long 0x00 5. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_DISPLAY_ZBB_SW_DISPLAY_VP_PDL ,Enabled the bypass of display HLB zbb_sw_display_vp powerdown (active-low) RESET:0x0"
          
group.long  0x274++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_NESTED_BYPASS_DISPLAY, None RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_DISPLAY_RBB_SW_DISPLAY_PC ,Bypass value of display HLB rbb_sw_display precharge RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_DISPLAY_RBB_SW_DISPLAY_PDL ,Bypass value of display HLB rbb_sw_display powerdown (active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_DISPLAY_ZBB_SW_DISPLAY_PC ,Bypass value of display HLB zbb_sw_display precharge RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_DISPLAY_ZBB_SW_DISPLAY_PDL ,Bypass value of display HLB zbb_sw_display powerdown (active-low) RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_DISPLAY_ZBB_SW_DISPLAY_VP_PC ,Bypass value of display HLB zbb_sw_display_vp precharge RESET:0x0"
          
         bitfld.long 0x00 5. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_DISPLAY_ZBB_SW_DISPLAY_VP_PDL ,Bypass value of display HLB zbb_sw_display_vp powerdown (active-low) RESET:0x0"
          
group.long  0x278++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_ETHERNET, None RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_ETHERNET_RBB_SW_ETHERNET_PC ,Enabled the bypass of ethernet HLB rbb_sw_ethernet precharge RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_ETHERNET_RBB_SW_ETHERNET_PDL ,Enabled the bypass of ethernet HLB rbb_sw_ethernet powerdown (active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_ETHERNET_ZBB_SW_ETHERNET_PC ,Enabled the bypass of ethernet HLB zbb_sw_ethernet precharge RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_ETHERNET_ZBB_SW_ETHERNET_PDL ,Enabled the bypass of ethernet HLB zbb_sw_ethernet powerdown (active-low) RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_ETHERNET_ZBB_SW_ETHERNET_PHY100_PC ,Enabled the bypass of ethernet HLB zbb_sw_ethernet_phy100 precharge RESET:0x0"
          
         bitfld.long 0x00 5. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_ETHERNET_ZBB_SW_ETHERNET_PHY100_PDL ,Enabled the bypass of ethernet HLB zbb_sw_ethernet_phy100 powerdown (active-low) RESET:0x0"
          
group.long  0x27c++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_NESTED_BYPASS_ETHERNET, None RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_ETHERNET_RBB_SW_ETHERNET_PC ,Bypass value of ethernet HLB rbb_sw_ethernet precharge RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_ETHERNET_RBB_SW_ETHERNET_PDL ,Bypass value of ethernet HLB rbb_sw_ethernet powerdown (active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_ETHERNET_ZBB_SW_ETHERNET_PC ,Bypass value of ethernet HLB zbb_sw_ethernet precharge RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_ETHERNET_ZBB_SW_ETHERNET_PDL ,Bypass value of ethernet HLB zbb_sw_ethernet powerdown (active-low) RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_ETHERNET_ZBB_SW_ETHERNET_PHY100_PC ,Bypass value of ethernet HLB zbb_sw_ethernet_phy100 precharge RESET:0x0"
          
         bitfld.long 0x00 5. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_ETHERNET_ZBB_SW_ETHERNET_PHY100_PDL ,Bypass value of ethernet HLB zbb_sw_ethernet_phy100 powerdown (active-low) RESET:0x0"
          
group.long  0x280++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_LPDDR4, None RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_LPDDR4_RBB_SW_LPDDR4_PC ,Enabled the bypass of lpddr4 HLB rbb_sw_lpddr4 precharge RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_LPDDR4_RBB_SW_LPDDR4_PDL ,Enabled the bypass of lpddr4 HLB rbb_sw_lpddr4 powerdown (active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_LPDDR4_ZBB_SW_LPDDR4_PC ,Enabled the bypass of lpddr4 HLB zbb_sw_lpddr4 precharge RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_EN_LPDDR4_ZBB_SW_LPDDR4_PDL ,Enabled the bypass of lpddr4 HLB zbb_sw_lpddr4 powerdown (active-low) RESET:0x0"
          
group.long  0x284++0x3
    line.long 0x00 "PMU_RI_PWR_DOMAIN_NESTED_BYPASS_LPDDR4, None RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_LPDDR4_RBB_SW_LPDDR4_PC ,Bypass value of lpddr4 HLB rbb_sw_lpddr4 precharge RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_LPDDR4_RBB_SW_LPDDR4_PDL ,Bypass value of lpddr4 HLB rbb_sw_lpddr4 powerdown (active-low) RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_LPDDR4_ZBB_SW_LPDDR4_PC ,Bypass value of lpddr4 HLB zbb_sw_lpddr4 precharge RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PWR_DOMAIN_NESTED_BYPASS_LPDDR4_ZBB_SW_LPDDR4_PDL ,Bypass value of lpddr4 HLB zbb_sw_lpddr4 powerdown (active-low) RESET:0x0"
          
group.long  0x288++0x3
    line.long 0x00 "PMU_WAKEUP_SRC_EN, Wakeup source control (enable/disable PMU wakeup sources) RESET:0x3"
         bitfld.long 0x00 0. " PMU_WAKEUP_SRC_EN_TIMER_WAKEUP ,Enable active-high, that  wakeups up the PMU. RESET:0x1"
          
         bitfld.long 0x00 1. " PMU_WAKEUP_SRC_EN_PIN_WAKEUP ,Enable active-high, that  wakeups up the PMU. RESET:0x1"
          
group.long  0x28c++0x3
    line.long 0x00 "PMU_IRQ_STATUS, PMU Interrupt Status Register RESET:0x0"
         bitfld.long 0x00 0. " PMU_IRQ_STATUS_TIMER_WAKEUP ,IRQ status for timer_wakeup RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_IRQ_STATUS_PIN_WAKEUP ,IRQ status for pin_wakeup RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_IRQ_STATUS_PMU_DONE ,IRQ status for pmu_done RESET:0x0"
          
group.long  0x290++0x3
    line.long 0x00 "PMU_IRQ_STATUS_ENABLE, PMU Interrupt Enable Register RESET:0x0"
         bitfld.long 0x00 0. " PMU_IRQ_STATUS_ENABLE_TIMER_WAKEUP ,Enable IRQ for timer_wakeup RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_IRQ_STATUS_ENABLE_PIN_WAKEUP ,Enable IRQ for pin_wakeup RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_IRQ_STATUS_ENABLE_PMU_DONE ,Enable IRQ for pmu_done RESET:0x0"
          
wgroup.long 0x294++0x3
    line.long 0x00 "PMU_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev). RESET:0x0"
         bitfld.long 0x00 0. " PMU_IRQ_STATUS_SET_TIMER_WAKEUP ,Set irq_status.timer_wakeup RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_IRQ_STATUS_SET_PIN_WAKEUP ,Set irq_status.pin_wakeup RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_IRQ_STATUS_SET_PMU_DONE ,Set irq_status.pmu_done RESET:0x0"
          
group.long  0x298++0x3
    line.long 0x00 "PMU_RI_ULP_CTRL_CONTROL, None RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_ULP_CTRL_CONTROL_CLKVAR_EN ,Enable the ULP variable-frequency clock (Note: ignored if mode is not BOTH_DCS or DC_CONST) RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_ULP_CTRL_CONTROL_REQ ,Write '1' to make the request (cleared by hardware) RESET:0x0"
          
rgroup.long 0x29c++0x3
    line.long 0x00 "PMU_RI_ULP_CTRL_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_ULP_CTRL_STATUS_BUSY ,indicates when the FSM is busy (active-high) RESET:0x0"
          
         bitfld.long 0x00 1.--4. " PMU_RI_ULP_CTRL_STATUS_FSM_STATE ,ri_ulp_ctrl fsm_state status RESET:0x0" "S_OFF-0,S_LDO_ONLY-1,S_SET_VDDVAR-2,S_SET_ULP_MODE-3,S_REQ_ULP_MODE-4,S_ULP_MODE_DONE-5,S_DC_CONST-6,S_BOTH_DCS-7,S_SET_NEW_VDDVAR-8,S_REQ_NEW_VDDVAR-9,S_ACK_NEW_VDDVAR-10,S_NEW_VDDVAR_DONE-11"
          
         bitfld.long 0x00 5.--6. " PMU_RI_ULP_CTRL_STATUS_MODE ,ri_ulp_ctrl mode status RESET:0x0" "OFF-1,LDO_ONLY-3,DC_CONST-2,BOTH_DCS-0"
          
         bitfld.long 0x00 7. " PMU_RI_ULP_CTRL_STATUS_CLK50_EN ,ULP 50 MHz clock is enabled (Note: ignored if mode is not LDO_ONLY) RESET:0x0"
          
         bitfld.long 0x00 8. " PMU_RI_ULP_CTRL_STATUS_CLKVAR_EN ,ULP variable-frequency clock is enabled (Note: ignored if mode is not BOTH_DCS or DC_CONST) RESET:0x0"
          
         hexmask.long 0x00 9.--13. 1. " PMU_RI_ULP_CTRL_STATUS_SEL_VDDVAR ,ULP VDDVAR voltage (Note: ignored when mode is not BOTH_DCS VDDVAR is not enabled RESET:0x0"
          
group.long  0x2a0++0x3
    line.long 0x00 "PMU_RI_PMU_CTRL_CONTROL, None RESET:0x1200"
         bitfld.long 0x00 0. " PMU_RI_PMU_CTRL_CONTROL_M85_EN ,Enable/Disable the m85 domain. RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PMU_CTRL_CONTROL_ETHOS_EN ,Enable/Disable the ethos domain. RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PMU_CTRL_CONTROL_DISPLAY_EN ,Enable/Disable the display domain. RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PMU_CTRL_CONTROL_LPDDR4_EN ,Enable/Disable the lpddr4 domain. RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PMU_CTRL_CONTROL_CAMERA_EN ,Enable/Disable the camera domain. RESET:0x0"
          
         bitfld.long 0x00 5. " PMU_RI_PMU_CTRL_CONTROL_ETHERNET_EN ,Enable/Disable the ethernet domain. RESET:0x0"
          
         bitfld.long 0x00 6. " PMU_RI_PMU_CTRL_CONTROL_H264_EN ,Enable/Disable the h264 domain. RESET:0x0"
          
         bitfld.long 0x00 7. " PMU_RI_PMU_CTRL_CONTROL_EMMC_EN ,Enable/Disable the emmc domain. RESET:0x0"
          
         bitfld.long 0x00 8. " PMU_RI_PMU_CTRL_CONTROL_GPU_EN ,Enable/Disable the gpu domain. RESET:0x0"
          
         bitfld.long 0x00 9. " PMU_RI_PMU_CTRL_CONTROL_ABB_CONFIG_SEL ,Select which ABB configuration to use. RESET:0x1"
          
         bitfld.long 0x00 10.--12. " PMU_RI_PMU_CTRL_CONTROL_MODE ,ri_pmu_ctrl mode control RESET:0x4" "OFF-0,SLEEP-1,RBB_RETENTION-2,IDLE-3,ACTIVE_LP-4,ACTIVE_HP-5"
          
         bitfld.long 0x00 13. " PMU_RI_PMU_CTRL_CONTROL_REQ ,None RESET:0x0"
          
rgroup.long 0x2a4++0x3
    line.long 0x00 "PMU_RI_PMU_CTRL_STATUS, None RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PMU_CTRL_STATUS_M85_EN ,Current enable/disable state of m85 domain. RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PMU_CTRL_STATUS_ETHOS_EN ,Current enable/disable state of ethos domain. RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PMU_CTRL_STATUS_DISPLAY_EN ,Current enable/disable state of display domain. RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_RI_PMU_CTRL_STATUS_LPDDR4_EN ,Current enable/disable state of lpddr4 domain. RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_RI_PMU_CTRL_STATUS_CAMERA_EN ,Current enable/disable state of camera domain. RESET:0x0"
          
         bitfld.long 0x00 5. " PMU_RI_PMU_CTRL_STATUS_ETHERNET_EN ,Current enable/disable state of ethernet domain. RESET:0x0"
          
         bitfld.long 0x00 6. " PMU_RI_PMU_CTRL_STATUS_H264_EN ,Current enable/disable state of h264 domain. RESET:0x0"
          
         bitfld.long 0x00 7. " PMU_RI_PMU_CTRL_STATUS_EMMC_EN ,Current enable/disable state of emmc domain. RESET:0x0"
          
         bitfld.long 0x00 8. " PMU_RI_PMU_CTRL_STATUS_GPU_EN ,Current enable/disable state of gpu domain. RESET:0x0"
          
         bitfld.long 0x00 9. " PMU_RI_PMU_CTRL_STATUS_ABB_CONFIG_SEL ,Currently used ABB configuration. RESET:0x0"
          
         bitfld.long 0x00 10.--16. " PMU_RI_PMU_CTRL_STATUS_FSM_STATE ,ri_pmu_ctrl fsm_state status RESET:0x0" "S_OFF-0,S_SET_ULP_DC_CONST-1,S_REQ_ULP_DC_CONST-2,S_ULP_DC_CONST_DONE-3,S_SEL_CLK_50-4,S_EN_ABB-5,S_SET_ULP_ACT_MODE-6,S_REQ_ULP_ACT_MODE-7,S_ULP_ACT_MODE_DONE-8,S_SET_ABB_ACTIVE-9,S_SET_ABB_ACTIVE_CONFIG-10,S_EN_ABB_ACTIVE-11,S_EN_RBB_SRAMS-12,S_REQ_MEM_STANDBY-13,S_MEM_STANDBY_DONE-14,S_DIS_RBB_RST-15,S_DIS_RBB_ISO-16,S_CHECK_NEW_VDDVAR-17,S_CHECK_NEW_ABB-18,S_CHECK_PD_CONTROL-19,S_EN_RBB_CLOCK-20,S_ACTIVE_LP-21,S_ACTIVE_HP-22,S_DIS_RBB_CLOCK-23,S_SET_ULP_NEW_MODE-24,S_REQ_ULP_NEW_MODE-25,S_ULP_NEW_MODE_DONE-26,S_SET_ABB_NEW-27,S_SET_ABB_NEW_CONFIG-28,S_EN_ABB_NEW-29,S_CHECK_PD_OFF-30,S_CHECK_PD_RET-31,S_CHECK_PD_ACTIVE-32,S_REQ_PD_MODE-33,S_PD_MODE_DONE-34,S_IDLE-35,S_RBB_ISO-36,S_RBB_RST-37,S_RBB_SRAM_MODE-38,S_REQ_MEM_MODE-39,S_MEM_MODE_DONE-40,S_SET_ABB_OPEN_LOOP-41,S_SET_ABB_OL_CONFIG-42,S_EN_ABB_OPEN_LOOP-43,S_SEL_SLEEP_CLK-44,S_SEL_SLEEP_CLK_DELAY-45,S_SET_ULP_SLEEP_RET_MODE-46,S_REQ_ULP_SLEEP_RET_MODE-47,S_ULP_SLEEP_RET_MODE_DONE-48,S_RBB_RETENTION-49,S_SLEEP-50"
          
         bitfld.long 0x00 17.--19. " PMU_RI_PMU_CTRL_STATUS_MODE ,ri_pmu_ctr mode status RESET:0x0" "OFF-0,SLEEP-1,RBB_RETENTION-2,IDLE-3,ACTIVE_LP-4,ACTIVE_HP-5"
          
         bitfld.long 0x00 20. " PMU_RI_PMU_CTRL_STATUS_AWAITING_WAKEUP ,Set '1'  FSM is waiting for wakeup signal i.e. is currently IDLE, RBB_RETENTION or SLEEP. RESET:0x0"
          
         bitfld.long 0x00 21. " PMU_RI_PMU_CTRL_STATUS_BOOT_DONE ,Set '1'  when FSM boots for the first time following reset/rbb_retention/sleep RESET:0x0"
          
         bitfld.long 0x00 31. " PMU_RI_PMU_CTRL_STATUS_BUSY ,indicates when the FSM is busy (active-high) RESET:0x0"
          
group.long  0x2a8++0x3
    line.long 0x00 "PMU_RI_PMU_CTRL_CFG, None RESET:0x4e20f"
         hexmask.long 0x00 0.--5. 1. " PMU_RI_PMU_CTRL_CFG_ISOLATION_CNT ,Isolation counter (TODO add description). RESET:0xf"
          
         hexmask.long 0x00 6.--19. 1. " PMU_RI_PMU_CTRL_CFG_SWITCH_CLK_CNT ,Delay between selecting slow clock and disabling the fast clock. RESET:0x1388"
          
         bitfld.long 0x00 20. " PMU_RI_PMU_CTRL_CFG_NO_ABB_LOCK ,Set '1' to always ignore the ABB locked flagfor purposes of ABB delay counter. RESET:0x0"
          
         bitfld.long 0x00 21. " PMU_RI_PMU_CTRL_CFG_NO_32K ,Sets whether to use 32 kHz clock during SLEEP/RBB_RETENTION. Default:0 = Use 32 kHz. RESET:0x0"
          
         bitfld.long 0x00 22. " PMU_RI_PMU_CTRL_CFG_NO_LDO ,Sets whether to use ULP LDO during SLEEP/RBB_RETENTION. Default:0 = Use LDO. RESET:0x0"
          
group.long  0x2ac++0x3
    line.long 0x00 "PMU_RI_PMU_CTRL_CFG_ABB_CNT, None RESET:0x43238"
         hexmask.long 0x00 0.--19. 1. " PMU_RI_PMU_CTRL_CFG_ABB_CNT_ABB_CNT ,Delay / ABB locked check duration to ensure ABB is settled. RESET:0x43238"
          
group.long  0x2b0++0x3
    line.long 0x00 "PMU_RI_PMU_CTRL_ULP_CFG, Customize the ULP VDDVAR voltage for different PMU modes (votlahe = 400mV + 25mV * register field value). WARNING - RISKS FROM USING NON CUSTOM VALUES! RESET:0x40c0"
         hexmask.long 0x00 0.--4. 1. " PMU_RI_PMU_CTRL_ULP_CFG_VDDVAR_RET ,Set ULP VDDVAR voltage for RBB_RETENTION. RESET:0x0"
          
         hexmask.long 0x00 5.--9. 1. " PMU_RI_PMU_CTRL_ULP_CFG_VDDVAR_LP ,Set ULP VDDVAR voltage for ACTIVE_LP. RESET:0x6"
          
         hexmask.long 0x00 10.--14. 1. " PMU_RI_PMU_CTRL_ULP_CFG_VDDVAR_HP ,Set ULP VDDVAR voltage for ACTIVE_HP. RESET:0x10"
          
group.long  0x2b4++0x3
    line.long 0x00 "PMU_RI_PMU_CTRL_BYPASS_EN, Bypass enable register for ri_pmu_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PMU_CTRL_BYPASS_EN_RBB_RSTN ,Enable bypass of rbb_rstn RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PMU_CTRL_BYPASS_EN_RBB_ISO_N ,Enable bypass of rbb_iso_n RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PMU_CTRL_BYPASS_EN_RBB_CLK_EN ,Enable bypass of rbb_clk_en RESET:0x0"
          
group.long  0x2b8++0x3
    line.long 0x00 "PMU_RI_PMU_CTRL_BYPASS, Bypass register for ri_pmu_ctrl RESET:0x0"
         bitfld.long 0x00 0. " PMU_RI_PMU_CTRL_BYPASS_RBB_RSTN ,Bypass value of rbb_rstn RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_RI_PMU_CTRL_BYPASS_RBB_ISO_N ,Bypass value of rbb_iso_n RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_RI_PMU_CTRL_BYPASS_RBB_CLK_EN ,Bypass value of rbb_clk_en RESET:0x0"
          
group.long  0x2bc++0x3
    line.long 0x00 "PMU_PMU_TOP_CONTROL, Top-level control of the PMU RESET:0x0"
         bitfld.long 0x00 0. " PMU_PMU_TOP_CONTROL_DISABLE_RI_PWR_DOMAIN_CTRL_M85_HW_CONTROL ,Disable hardware control of ri_pwr_domain_ctrl_m85. Control only via manual software requests RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_PMU_TOP_CONTROL_DISABLE_RI_PWR_DOMAIN_CTRL_ETHOS_HW_CONTROL ,Disable hardware control of ri_pwr_domain_ctrl_ethos. Control only via manual software requests RESET:0x0"
          
         bitfld.long 0x00 2. " PMU_PMU_TOP_CONTROL_DISABLE_RI_PWR_DOMAIN_CTRL_DISPLAY_HW_CONTROL ,Disable hardware control of ri_pwr_domain_ctrl_display. Control only via manual software requests RESET:0x0"
          
         bitfld.long 0x00 3. " PMU_PMU_TOP_CONTROL_DISABLE_RI_PWR_DOMAIN_CTRL_LPDDR4_HW_CONTROL ,Disable hardware control of ri_pwr_domain_ctrl_lpddr4. Control only via manual software requests RESET:0x0"
          
         bitfld.long 0x00 4. " PMU_PMU_TOP_CONTROL_DISABLE_RI_PWR_DOMAIN_CTRL_CAMERA_HW_CONTROL ,Disable hardware control of ri_pwr_domain_ctrl_camera. Control only via manual software requests RESET:0x0"
          
         bitfld.long 0x00 5. " PMU_PMU_TOP_CONTROL_DISABLE_RI_PWR_DOMAIN_CTRL_ETHERNET_HW_CONTROL ,Disable hardware control of ri_pwr_domain_ctrl_ethernet. Control only via manual software requests RESET:0x0"
          
         bitfld.long 0x00 6. " PMU_PMU_TOP_CONTROL_DISABLE_RI_PWR_DOMAIN_CTRL_H264_HW_CONTROL ,Disable hardware control of ri_pwr_domain_ctrl_h264. Control only via manual software requests RESET:0x0"
          
         bitfld.long 0x00 7. " PMU_PMU_TOP_CONTROL_DISABLE_RI_PWR_DOMAIN_CTRL_EMMC_HW_CONTROL ,Disable hardware control of ri_pwr_domain_ctrl_emmc. Control only via manual software requests RESET:0x0"
          
         bitfld.long 0x00 8. " PMU_PMU_TOP_CONTROL_DISABLE_RI_PWR_DOMAIN_CTRL_GPU_HW_CONTROL ,Disable hardware control of ri_pwr_domain_ctrl_gpu. Control only via manual software requests RESET:0x0"
          
         bitfld.long 0x00 9. " PMU_PMU_TOP_CONTROL_DISABLE_RI_SRAM_PWRGRP_CTRL_DISPLAY_HW_CONTROL ,Disable hardware control of ri_sram_pwrgrp_ctrl_display. Control only via manual software requests RESET:0x0"
          
         bitfld.long 0x00 10. " PMU_PMU_TOP_CONTROL_DISABLE_RI_SRAM_PWRGRP_CTRL_ETHOS_HW_CONTROL ,Disable hardware control of ri_sram_pwrgrp_ctrl_ethos. Control only via manual software requests RESET:0x0"
          
         bitfld.long 0x00 11. " PMU_PMU_TOP_CONTROL_DISABLE_RI_SRAM_PWRGRP_CTRL_M85_HW_CONTROL ,Disable hardware control of ri_sram_pwrgrp_ctrl_m85. Control only via manual software requests RESET:0x0"
          
         bitfld.long 0x00 12. " PMU_PMU_TOP_CONTROL_DISABLE_RI_SRAM_PWRGRP_CTRL_RBB_HW_CONTROL ,Disable hardware control of ri_sram_pwrgrp_ctrl_rbb. Control only via manual software requests RESET:0x0"
          
rgroup.long 0x2c0++0x3
    line.long 0x00 "PMU_PMU_TOP_STATUS, Top-level status of the PMU RESET:0x0"
         bitfld.long 0x00 0. " PMU_PMU_TOP_STATUS_DFT_PREPARED ,Set '1' whenever outputs of all FSMs are at the DFT mode values. RESET:0x0"
          
         bitfld.long 0x00 1. " PMU_PMU_TOP_STATUS_BUSY ,Set '1' whenever any PMU FSM is busy. RESET:0x0"
          
tree.end

tree "TIMER_PWM1"
base e:0x4100b000
width 80.
group.long  0x0++0x3
    line.long 0x00 "TIMER_PWM1_CTRL, Timer Control Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_PWM1_CTRL_SINGLESHOT ,singleshot mode RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_PWM1_CTRL_CYCLIC ,cyclic mode RESET:0x0"
          
         bitfld.long 0x00 2. " TIMER_PWM1_CTRL_STOP ,stop mode RESET:0x0"
          
         bitfld.long 0x00 3. " TIMER_PWM1_CTRL_FREEZE ,freezes the timer. Counter will stop counting but will retain its value RESET:0x0"
          
         bitfld.long 0x00 4. " TIMER_PWM1_CTRL_FREEZE_IN_DIS ,when set, ignores the freeze_in signal RESET:0x0"
          
         bitfld.long 0x00 5. " TIMER_PWM1_CTRL_PWM ,enable pulse width modulation. timer mode is not affected RESET:0x0"
          
         bitfld.long 0x00 6. " TIMER_PWM1_CTRL_PDM ,enable pulse density modulation -> timer mode is disabled RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "TIMER_PWM1_STATUS, Status Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_PWM1_STATUS_RUNNING ,indicates if timer is running (1) or stopped (0) RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "TIMER_PWM1_PRESCALE, Prescale Value Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " TIMER_PWM1_PRESCALE_VALUE ,Prescales the clock to counter (CLK_COUNT) w.r.t input clock of timer(CLK_TIM). FREQ_CLK_COUNT = FREQ_CLK_TIM / PRESCALE. NOTE: stop the timer before modifying this field RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "TIMER_PWM1_TARGET, Target Value Register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TIMER_PWM1_TARGET_VALUE ,Target value, this write trigger has the highest priority compared to the other registers RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "TIMER_PWM1_DELTA, Defines the duration of the high phase in PWM mode or the pulse density in PDM mode RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TIMER_PWM1_DELTA_VALUE ,PWM mode: if count < delta, pm_out = 1, else 0 // PDM mode: this is the value for the dithering algorithm RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "TIMER_PWM1_COUNT, Captured Timer Value RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TIMER_PWM1_COUNT_VALUE ,Captured timer value. This value is valid only if TIMER_READ is enabled in HW. The value is valid after capture.req _> capture_ack register handshake RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "TIMER_PWM1_COUNT_SET, Set Counter Value RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TIMER_PWM1_COUNT_SET_VALUE ,Set counter value, this write trigger has the highest priority compared to the other registers RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "TIMER_PWM1_IRQ_STATUS_ENABLE, Status Interrupt Enable Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_PWM1_IRQ_STATUS_ENABLE_ALARM ,Count reached target value RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_PWM1_IRQ_STATUS_ENABLE_OVFL ,Count reached target value while alarm is set to one. i.e. The previous alarm was not handled RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "TIMER_PWM1_IRQ_STATUS, Status Interrupt Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_PWM1_IRQ_STATUS_ALARM ,Count reached target value RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_PWM1_IRQ_STATUS_OVFL ,Count reached target value while alarm is set to one. i.e. The previous alarm was not handled RESET:0x0"
          
wgroup.long 0x24++0x3
    line.long 0x00 "TIMER_PWM1_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev). RESET:0x0"
         bitfld.long 0x00 0. " TIMER_PWM1_IRQ_STATUS_SET_ALARM ,Set alarm irq RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_PWM1_IRQ_STATUS_SET_OVFL ,Set ovfl irq RESET:0x0"
          
tree.end

tree "TIMER_PWM2"
base e:0x4100c000
width 80.
group.long  0x0++0x3
    line.long 0x00 "TIMER_PWM2_CTRL, Timer Control Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_PWM2_CTRL_SINGLESHOT ,singleshot mode RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_PWM2_CTRL_CYCLIC ,cyclic mode RESET:0x0"
          
         bitfld.long 0x00 2. " TIMER_PWM2_CTRL_STOP ,stop mode RESET:0x0"
          
         bitfld.long 0x00 3. " TIMER_PWM2_CTRL_FREEZE ,freezes the timer. Counter will stop counting but will retain its value RESET:0x0"
          
         bitfld.long 0x00 4. " TIMER_PWM2_CTRL_FREEZE_IN_DIS ,when set, ignores the freeze_in signal RESET:0x0"
          
         bitfld.long 0x00 5. " TIMER_PWM2_CTRL_PWM ,enable pulse width modulation. timer mode is not affected RESET:0x0"
          
         bitfld.long 0x00 6. " TIMER_PWM2_CTRL_PDM ,enable pulse density modulation -> timer mode is disabled RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "TIMER_PWM2_STATUS, Status Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_PWM2_STATUS_RUNNING ,indicates if timer is running (1) or stopped (0) RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "TIMER_PWM2_PRESCALE, Prescale Value Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " TIMER_PWM2_PRESCALE_VALUE ,Prescales the clock to counter (CLK_COUNT) w.r.t input clock of timer(CLK_TIM). FREQ_CLK_COUNT = FREQ_CLK_TIM / PRESCALE. NOTE: stop the timer before modifying this field RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "TIMER_PWM2_TARGET, Target Value Register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TIMER_PWM2_TARGET_VALUE ,Target value, this write trigger has the highest priority compared to the other registers RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "TIMER_PWM2_DELTA, Defines the duration of the high phase in PWM mode or the pulse density in PDM mode RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TIMER_PWM2_DELTA_VALUE ,PWM mode: if count < delta, pm_out = 1, else 0 // PDM mode: this is the value for the dithering algorithm RESET:0x0"
          
rgroup.long 0x14++0x3
    line.long 0x00 "TIMER_PWM2_COUNT, Captured Timer Value RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TIMER_PWM2_COUNT_VALUE ,Captured timer value. This value is valid only if TIMER_READ is enabled in HW. The value is valid after capture.req _> capture_ack register handshake RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "TIMER_PWM2_COUNT_SET, Set Counter Value RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TIMER_PWM2_COUNT_SET_VALUE ,Set counter value, this write trigger has the highest priority compared to the other registers RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "TIMER_PWM2_IRQ_STATUS_ENABLE, Status Interrupt Enable Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_PWM2_IRQ_STATUS_ENABLE_ALARM ,Count reached target value RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_PWM2_IRQ_STATUS_ENABLE_OVFL ,Count reached target value while alarm is set to one. i.e. The previous alarm was not handled RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "TIMER_PWM2_IRQ_STATUS, Status Interrupt Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_PWM2_IRQ_STATUS_ALARM ,Count reached target value RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_PWM2_IRQ_STATUS_OVFL ,Count reached target value while alarm is set to one. i.e. The previous alarm was not handled RESET:0x0"
          
wgroup.long 0x24++0x3
    line.long 0x00 "TIMER_PWM2_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev). RESET:0x0"
         bitfld.long 0x00 0. " TIMER_PWM2_IRQ_STATUS_SET_ALARM ,Set alarm irq RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_PWM2_IRQ_STATUS_SET_OVFL ,Set ovfl irq RESET:0x0"
          
tree.end

tree "TIMER_WAKEUP"
base e:0x4100d000
width 80.
group.long  0x0++0x3
    line.long 0x00 "TIMER_WAKEUP_CTRL, Timer Control Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_WAKEUP_CTRL_SINGLESHOT ,singleshot mode RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_WAKEUP_CTRL_CYCLIC ,cyclic mode RESET:0x0"
          
         bitfld.long 0x00 2. " TIMER_WAKEUP_CTRL_STOP ,stop mode RESET:0x0"
          
         bitfld.long 0x00 3. " TIMER_WAKEUP_CTRL_FREEZE ,freezes the timer. Counter will stop counting but will retain its value RESET:0x0"
          
         bitfld.long 0x00 4. " TIMER_WAKEUP_CTRL_FREEZE_IN_DIS ,when set, ignores the freeze_in signal RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "TIMER_WAKEUP_STATUS, Status Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_WAKEUP_STATUS_RUNNING ,indicates if timer is running (1) or stopped (0) RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "TIMER_WAKEUP_PRESCALE, Prescale Value Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " TIMER_WAKEUP_PRESCALE_VALUE ,Prescales the clock to counter (CLK_COUNT) w.r.t input clock of timer(CLK_TIM). FREQ_CLK_COUNT = FREQ_CLK_TIM / PRESCALE. NOTE: stop the timer before modifying this field RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "TIMER_WAKEUP_TARGET, Target Value Register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TIMER_WAKEUP_TARGET_VALUE ,Target value, this write trigger has the highest priority compared to the other registers RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "TIMER_WAKEUP_COUNT, Captured Timer Value RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TIMER_WAKEUP_COUNT_VALUE ,Captured timer value. This value is valid only if TIMER_READ is enabled in HW. The value is valid after capture.req _> capture_ack register handshake RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "TIMER_WAKEUP_COUNT_SET, Set Counter Value RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TIMER_WAKEUP_COUNT_SET_VALUE ,Set counter value, this write trigger has the highest priority compared to the other registers RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "TIMER_WAKEUP_IRQ_STATUS_EN, Status Interrupt Enable Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_WAKEUP_IRQ_STATUS_EN_ALARM ,Count reached zero RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_WAKEUP_IRQ_STATUS_EN_OVFL ,Count reached zero while alarm is set to one. i.e. The previous alarm was not handled RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "TIMER_WAKEUP_IRQ_STATUS, Status Interrupt Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_WAKEUP_IRQ_STATUS_ALARM ,Count reached zero RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_WAKEUP_IRQ_STATUS_OVFL ,Count reached zero while alarm is set to one. i.e. The previous alarm was not handled RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "TIMER_WAKEUP_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev). RESET:0x0"
         bitfld.long 0x00 0. " TIMER_WAKEUP_IRQ_STATUS_SET_ALARM ,Set alarm irq RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_WAKEUP_IRQ_STATUS_SET_OVFL ,Set ovfl irq RESET:0x0"
          
tree.end

tree "TIMER_RTC"
base e:0x4100e000
width 80.
group.long  0x0++0x3
    line.long 0x00 "TIMER_RTC_CTRL, Timer Control Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_RTC_CTRL_SINGLESHOT ,singleshot mode RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_RTC_CTRL_CYCLIC ,cyclic mode RESET:0x0"
          
         bitfld.long 0x00 2. " TIMER_RTC_CTRL_STOP ,stop mode RESET:0x0"
          
         bitfld.long 0x00 3. " TIMER_RTC_CTRL_FREEZE ,freezes the timer. Counter will stop counting but will retain its value RESET:0x0"
          
         bitfld.long 0x00 4. " TIMER_RTC_CTRL_FREEZE_IN_DIS ,when set, ignores the freeze_in signal RESET:0x0"
          
rgroup.long 0x4++0x3
    line.long 0x00 "TIMER_RTC_STATUS, Status Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_RTC_STATUS_RUNNING ,indicates if timer is running (1) or stopped (0) RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "TIMER_RTC_PRESCALE, Prescale Value Register RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " TIMER_RTC_PRESCALE_VALUE ,Prescales the clock to counter (CLK_COUNT) w.r.t input clock of timer(CLK_TIM). FREQ_CLK_COUNT = FREQ_CLK_TIM / PRESCALE. NOTE: stop the timer before modifying this field RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "TIMER_RTC_TARGET, Target Value Register RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TIMER_RTC_TARGET_VALUE ,Target value, this write trigger has the highest priority compared to the other registers RESET:0x0"
          
rgroup.long 0x10++0x3
    line.long 0x00 "TIMER_RTC_COUNT, Captured Timer Value RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TIMER_RTC_COUNT_VALUE ,Captured timer value. This value is valid only if TIMER_READ is enabled in HW. The value is valid after capture.req _> capture_ack register handshake RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "TIMER_RTC_COUNT_SET, Set Counter Value RESET:0x0"
         hexmask.long 0x00 0.--31. 1. " TIMER_RTC_COUNT_SET_VALUE ,Set counter value, this write trigger has the highest priority compared to the other registers RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "TIMER_RTC_IRQ_STATUS_EN, Status Interrupt Enable Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_RTC_IRQ_STATUS_EN_ALARM ,Count reached zero RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_RTC_IRQ_STATUS_EN_OVFL ,Count reached zero while alarm is set to one. i.e. The previous alarm was not handled RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "TIMER_RTC_IRQ_STATUS, Status Interrupt Register RESET:0x0"
         bitfld.long 0x00 0. " TIMER_RTC_IRQ_STATUS_ALARM ,Count reached zero RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_RTC_IRQ_STATUS_OVFL ,Count reached zero while alarm is set to one. i.e. The previous alarm was not handled RESET:0x0"
          
wgroup.long 0x20++0x3
    line.long 0x00 "TIMER_RTC_IRQ_STATUS_SET, Set irq_status register bits. Used to the emulate interrupt event (for SW debug or dev). RESET:0x0"
         bitfld.long 0x00 0. " TIMER_RTC_IRQ_STATUS_SET_ALARM ,Set alarm irq RESET:0x0"
          
         bitfld.long 0x00 1. " TIMER_RTC_IRQ_STATUS_SET_OVFL ,Set ovfl irq RESET:0x0"
          
tree.end
    

tree "LPDDR4_PUB"
base e:0x42000000
width 80.
tree.end
    

tree "LPDDR4_PUB__DWC_DDRPHYA_ANIB0_P0"
base e:0x42000000
width 80.
group.long  0x34++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_MTESTMUXSEL, Digital Observation Pin control RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_MTESTMUXSEL_MTESTMUXSEL ,Controls for the 64-1 mux for asynchronous data to the Digital Observation Pin.  - 6'h0 --> Drive 0 from this chiplet (allows flat 'OR' of pass-through information)  - 6'h01:1f --> Select local data from AC/DBYTE/MASTER macro  - 6'h20 --> Reserved (Drive 0 from macro into mux; Drive 0 from PUB synth logic path into mux)  - 6'h21:3f --> Select local data from PUB AC/DBYTE/MASTER synthesized logic Note: See PUB documentation for how, or if, the Digital Observation Pin is mapped to a physical bump in this configuration. RESET:0x0"
          
group.long  0x4e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_AFORCEDRVCONT, Force Address/Command Driven (Lanes A3-A0) RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_AFORCEDRVCONT_AFORCEDRVCONT ,Force continuous drive, per-lane, of the ACX4 instance controlled by this register. Setting this register will cause the PHY to drive the target lane when dfi_init_complete==1  - Bit [0] = controls lane 0 of the target ACX4 block  - Bit [1] = controls lane 1 of the target ACX4 block  - Bit [2] = controls lane 2 of the target ACX4 block  - Bit [3] = controls lane 3 of the target ACX4 block RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_AFORCETRICONT, Force Address/Command Tristate (Lanes A3-A0) RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_AFORCETRICONT_AFORCETRICONT ,Force tristate control, per-lane, of the ACX4 instance controlled by this register. Setting this register will cause the PHY to tristate the target lane when dfi_init_complete==1  - Bit [0] = controls lane 0 of the target ACX4 block  - Bit [1] = controls lane 1 of the target ACX4 block  - Bit [2] = controls lane 2 of the target ACX4 block  - Bit [3] = controls lane 3 of the target ACX4 block RESET:0x0"
          
group.long  0x86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_ATXIMPEDANCE, Tx impedance of Address driver cells. RESET:0x3ff"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_ATXIMPEDANCE_ADRVSTRENP ,The 5-bit bus is used to select the target pull-up output impedance.  Refer to Technology specific PHY DATABOOK for supported options. Connects to the DrvStren pins of the driver thus: Csr_DrvStren120P[5:0] = [csrADrvStrenP[4:0],1'b1]  - 00000 = 120.0 Ohm  - 00001 = 60.0 Ohm  - 00011 = 40.0 Ohm  - 00111 = 30.0 Ohm  - 01111 = 24.0 Ohm  - 11111 = 20.0 Ohm RESET:0x1f"
          
         hexmask.long 0x00 5.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_ATXIMPEDANCE_ADRVSTRENN ,This 5-bit bus is used to select the target pull-down output impedance. Refer to Technology specific PHY DATABOOK for supported options. Connects to the DrvStren pins of the driver thus: Csr_DrvStren120N[5:0] = [csrADrvStrenN[4:0],1'b1]  - 00000 = 120.0 Ohm  - 00001 = 60.0 Ohm  - 00011 = 40.0 Ohm  - 00111 = 30.0 Ohm  - 01111 = 24.0 Ohm  - 11111 = 20.0 Ohm RESET:0x1f"
          
rgroup.long 0xa6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_ATESTPRBSERR, Address Loopback PRBS Error status for an entire ACX4 block RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_ATESTPRBSERR_ATESTPRBSERR ,Overall error indicator for each prbs bump checker. - Bit[0] = Lane0 Error Status [1 = errors found, 0 = no errors] - Bit[1] = Lane1 Error Status - Bit[2] = Lane2 Error Status - Bit[3] = Lane3 Error Status RESET:0x0"
          
group.long  0xaa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_ATXSLEWRATE, controls slew rates of address/command/memclk drivers. Tx predriver cal trims driver timing to account for clock duty cycle variation. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_ATXSLEWRATE_ATXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_ATXSLEWRATE_ATXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_ATXSLEWRATE_ATXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. - Recommended settings if the ANIB drives CK pins: -- DDR3 = 3'b000 -- DDR4 = 3'b000 -- LPDDR3 = 3'b000 -- LPDDR4 = 3'b001 - Recommended settings if the ANIB does not drive CK pins: -- DDR3 = 3'b011 -- DDR4 = 3'b011 -- LPDDR3 = 3'b011 -- LPDDR4 = 3'b001 RESET:0x7"
          
rgroup.long 0xac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_ATESTPRBSERRCNT, Address Loopback Test Result register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_ATESTPRBSERRCNT_ATESTPRBSERRCNT ,Overall error indicator for each prbs bump checker. - Bit [3:0] = Lane0 Error Count - Bit [7:4] = Lane1 Error Count - Bit [11:8] = Lane2 Error Count - Bit [15:12] = Lane3 Error Count RESET:0x0"
          
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_ATXDLY_P0, Address/Command Delay, per pstate. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB0_P0_ATXDLY_P0_ATXDLY_P0 ,Trained for LPDDR3/4 to generate timed address and command signals to the DRAMs, per ACX4. For DDR3/DDR4, it is recommended that address and command ACX4 have it ATxDly=0x00 The four signals generated by an ACX4 will have common timing.  - ATxDly[6] is the coarse delay, ie one unit of delay is 1 UI.  - ATxDly[5] is reserved.  - ATxDly[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32. The target ACX4 used for memory clock generation, must have its ATxDly configured to 0x00. RESET:0x0"
          
tree.end
    

tree "LPDDR4_PUB__DWC_DDRPHYA_ANIB1_P0"
base e:0x42002000
width 80.
group.long  0x34++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_MTESTMUXSEL, Digital Observation Pin control RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_MTESTMUXSEL_MTESTMUXSEL ,Controls for the 64-1 mux for asynchronous data to the Digital Observation Pin.  - 6'h0 --> Drive 0 from this chiplet (allows flat 'OR' of pass-through information)  - 6'h01:1f --> Select local data from AC/DBYTE/MASTER macro  - 6'h20 --> Reserved (Drive 0 from macro into mux; Drive 0 from PUB synth logic path into mux)  - 6'h21:3f --> Select local data from PUB AC/DBYTE/MASTER synthesized logic Note: See PUB documentation for how, or if, the Digital Observation Pin is mapped to a physical bump in this configuration. RESET:0x0"
          
group.long  0x4e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_AFORCEDRVCONT, Force Address/Command Driven (Lanes A3-A0) RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_AFORCEDRVCONT_AFORCEDRVCONT ,Force continuous drive, per-lane, of the ACX4 instance controlled by this register. Setting this register will cause the PHY to drive the target lane when dfi_init_complete==1  - Bit [0] = controls lane 0 of the target ACX4 block  - Bit [1] = controls lane 1 of the target ACX4 block  - Bit [2] = controls lane 2 of the target ACX4 block  - Bit [3] = controls lane 3 of the target ACX4 block RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_AFORCETRICONT, Force Address/Command Tristate (Lanes A3-A0) RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_AFORCETRICONT_AFORCETRICONT ,Force tristate control, per-lane, of the ACX4 instance controlled by this register. Setting this register will cause the PHY to tristate the target lane when dfi_init_complete==1  - Bit [0] = controls lane 0 of the target ACX4 block  - Bit [1] = controls lane 1 of the target ACX4 block  - Bit [2] = controls lane 2 of the target ACX4 block  - Bit [3] = controls lane 3 of the target ACX4 block RESET:0x0"
          
group.long  0x86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_ATXIMPEDANCE, Tx impedance of Address driver cells. RESET:0x3ff"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_ATXIMPEDANCE_ADRVSTRENP ,The 5-bit bus is used to select the target pull-up output impedance.  Refer to Technology specific PHY DATABOOK for supported options. Connects to the DrvStren pins of the driver thus: Csr_DrvStren120P[5:0] = [csrADrvStrenP[4:0],1'b1]  - 00000 = 120.0 Ohm  - 00001 = 60.0 Ohm  - 00011 = 40.0 Ohm  - 00111 = 30.0 Ohm  - 01111 = 24.0 Ohm  - 11111 = 20.0 Ohm RESET:0x1f"
          
         hexmask.long 0x00 5.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_ATXIMPEDANCE_ADRVSTRENN ,This 5-bit bus is used to select the target pull-down output impedance. Refer to Technology specific PHY DATABOOK for supported options. Connects to the DrvStren pins of the driver thus: Csr_DrvStren120N[5:0] = [csrADrvStrenN[4:0],1'b1]  - 00000 = 120.0 Ohm  - 00001 = 60.0 Ohm  - 00011 = 40.0 Ohm  - 00111 = 30.0 Ohm  - 01111 = 24.0 Ohm  - 11111 = 20.0 Ohm RESET:0x1f"
          
rgroup.long 0xa6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_ATESTPRBSERR, Address Loopback PRBS Error status for an entire ACX4 block RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_ATESTPRBSERR_ATESTPRBSERR ,Overall error indicator for each prbs bump checker. - Bit[0] = Lane0 Error Status [1 = errors found, 0 = no errors] - Bit[1] = Lane1 Error Status - Bit[2] = Lane2 Error Status - Bit[3] = Lane3 Error Status RESET:0x0"
          
group.long  0xaa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_ATXSLEWRATE, controls slew rates of address/command/memclk drivers. Tx predriver cal trims driver timing to account for clock duty cycle variation. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_ATXSLEWRATE_ATXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_ATXSLEWRATE_ATXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_ATXSLEWRATE_ATXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. - Recommended settings if the ANIB drives CK pins: -- DDR3 = 3'b000 -- DDR4 = 3'b000 -- LPDDR3 = 3'b000 -- LPDDR4 = 3'b001 - Recommended settings if the ANIB does not drive CK pins: -- DDR3 = 3'b011 -- DDR4 = 3'b011 -- LPDDR3 = 3'b011 -- LPDDR4 = 3'b001 RESET:0x7"
          
rgroup.long 0xac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_ATESTPRBSERRCNT, Address Loopback Test Result register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_ATESTPRBSERRCNT_ATESTPRBSERRCNT ,Overall error indicator for each prbs bump checker. - Bit [3:0] = Lane0 Error Count - Bit [7:4] = Lane1 Error Count - Bit [11:8] = Lane2 Error Count - Bit [15:12] = Lane3 Error Count RESET:0x0"
          
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_ATXDLY_P0, Address/Command Delay, per pstate. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB1_P0_ATXDLY_P0_ATXDLY_P0 ,Trained for LPDDR3/4 to generate timed address and command signals to the DRAMs, per ACX4. For DDR3/DDR4, it is recommended that address and command ACX4 have it ATxDly=0x00 The four signals generated by an ACX4 will have common timing.  - ATxDly[6] is the coarse delay, ie one unit of delay is 1 UI.  - ATxDly[5] is reserved.  - ATxDly[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32. The target ACX4 used for memory clock generation, must have its ATxDly configured to 0x00. RESET:0x0"
          
tree.end
    

tree "LPDDR4_PUB__DWC_DDRPHYA_ANIB2_P0"
base e:0x42004000
width 80.
group.long  0x34++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_MTESTMUXSEL, Digital Observation Pin control RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_MTESTMUXSEL_MTESTMUXSEL ,Controls for the 64-1 mux for asynchronous data to the Digital Observation Pin.  - 6'h0 --> Drive 0 from this chiplet (allows flat 'OR' of pass-through information)  - 6'h01:1f --> Select local data from AC/DBYTE/MASTER macro  - 6'h20 --> Reserved (Drive 0 from macro into mux; Drive 0 from PUB synth logic path into mux)  - 6'h21:3f --> Select local data from PUB AC/DBYTE/MASTER synthesized logic Note: See PUB documentation for how, or if, the Digital Observation Pin is mapped to a physical bump in this configuration. RESET:0x0"
          
group.long  0x4e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_AFORCEDRVCONT, Force Address/Command Driven (Lanes A3-A0) RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_AFORCEDRVCONT_AFORCEDRVCONT ,Force continuous drive, per-lane, of the ACX4 instance controlled by this register. Setting this register will cause the PHY to drive the target lane when dfi_init_complete==1  - Bit [0] = controls lane 0 of the target ACX4 block  - Bit [1] = controls lane 1 of the target ACX4 block  - Bit [2] = controls lane 2 of the target ACX4 block  - Bit [3] = controls lane 3 of the target ACX4 block RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_AFORCETRICONT, Force Address/Command Tristate (Lanes A3-A0) RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_AFORCETRICONT_AFORCETRICONT ,Force tristate control, per-lane, of the ACX4 instance controlled by this register. Setting this register will cause the PHY to tristate the target lane when dfi_init_complete==1  - Bit [0] = controls lane 0 of the target ACX4 block  - Bit [1] = controls lane 1 of the target ACX4 block  - Bit [2] = controls lane 2 of the target ACX4 block  - Bit [3] = controls lane 3 of the target ACX4 block RESET:0x0"
          
group.long  0x86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_ATXIMPEDANCE, Tx impedance of Address driver cells. RESET:0x3ff"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_ATXIMPEDANCE_ADRVSTRENP ,The 5-bit bus is used to select the target pull-up output impedance.  Refer to Technology specific PHY DATABOOK for supported options. Connects to the DrvStren pins of the driver thus: Csr_DrvStren120P[5:0] = [csrADrvStrenP[4:0],1'b1]  - 00000 = 120.0 Ohm  - 00001 = 60.0 Ohm  - 00011 = 40.0 Ohm  - 00111 = 30.0 Ohm  - 01111 = 24.0 Ohm  - 11111 = 20.0 Ohm RESET:0x1f"
          
         hexmask.long 0x00 5.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_ATXIMPEDANCE_ADRVSTRENN ,This 5-bit bus is used to select the target pull-down output impedance. Refer to Technology specific PHY DATABOOK for supported options. Connects to the DrvStren pins of the driver thus: Csr_DrvStren120N[5:0] = [csrADrvStrenN[4:0],1'b1]  - 00000 = 120.0 Ohm  - 00001 = 60.0 Ohm  - 00011 = 40.0 Ohm  - 00111 = 30.0 Ohm  - 01111 = 24.0 Ohm  - 11111 = 20.0 Ohm RESET:0x1f"
          
rgroup.long 0xa6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_ATESTPRBSERR, Address Loopback PRBS Error status for an entire ACX4 block RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_ATESTPRBSERR_ATESTPRBSERR ,Overall error indicator for each prbs bump checker. - Bit[0] = Lane0 Error Status [1 = errors found, 0 = no errors] - Bit[1] = Lane1 Error Status - Bit[2] = Lane2 Error Status - Bit[3] = Lane3 Error Status RESET:0x0"
          
group.long  0xaa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_ATXSLEWRATE, controls slew rates of address/command/memclk drivers. Tx predriver cal trims driver timing to account for clock duty cycle variation. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_ATXSLEWRATE_ATXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_ATXSLEWRATE_ATXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_ATXSLEWRATE_ATXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. - Recommended settings if the ANIB drives CK pins: -- DDR3 = 3'b000 -- DDR4 = 3'b000 -- LPDDR3 = 3'b000 -- LPDDR4 = 3'b001 - Recommended settings if the ANIB does not drive CK pins: -- DDR3 = 3'b011 -- DDR4 = 3'b011 -- LPDDR3 = 3'b011 -- LPDDR4 = 3'b001 RESET:0x7"
          
rgroup.long 0xac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_ATESTPRBSERRCNT, Address Loopback Test Result register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_ATESTPRBSERRCNT_ATESTPRBSERRCNT ,Overall error indicator for each prbs bump checker. - Bit [3:0] = Lane0 Error Count - Bit [7:4] = Lane1 Error Count - Bit [11:8] = Lane2 Error Count - Bit [15:12] = Lane3 Error Count RESET:0x0"
          
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_ATXDLY_P0, Address/Command Delay, per pstate. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_ANIB2_P0_ATXDLY_P0_ATXDLY_P0 ,Trained for LPDDR3/4 to generate timed address and command signals to the DRAMs, per ACX4. For DDR3/DDR4, it is recommended that address and command ACX4 have it ATxDly=0x00 The four signals generated by an ACX4 will have common timing.  - ATxDly[6] is the coarse delay, ie one unit of delay is 1 UI.  - ATxDly[5] is reserved.  - ATxDly[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32. The target ACX4 used for memory clock generation, must have its ATxDly configured to 0x00. RESET:0x0"
          
tree.end
    

tree "LPDDR4_PUB__DWC_DDRPHYA_DBYTE0_P0"
base e:0x42020000
width 80.
group.long  0x0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DBYTEMISCMODE, Controls the enable/disable state of the DBYTE module. RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DBYTEMISCMODE_DBYTEDISABLE ,Controls whether this DBYTE module is disabled. If this DBYTE module is not enabled, it receives no clocks and remains in reset.  - 0 - Enable this DBYTE module  - 1 - Disable this DBYTE module This field should only be changed PHY initialization step C. RESET:0x0"
          
group.long  0x2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSMBYTE0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSMBYTE0_RFU_TSMBYTE0 ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGPARAM, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGPARAM_RFU_TRAININGPARAM ,None RESET:0x0"
          
group.long  0x6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_USEDQSENREPLICA_P0, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_USEDQSENREPLICA_P0_USEDQSENREPLICA_P0 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXTRAINPATTERNENABLE, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXTRAINPATTERNENABLE_RXTRAINPATTERNENABLE ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x22++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSMBYTE1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSMBYTE1_RFU_TSMBYTE1 ,None RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSMBYTE2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSMBYTE2_RFU_TSMBYTE2 ,None RESET:0x0"
          
group.long  0x26++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSMBYTE3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSMBYTE3_RFU_TSMBYTE3 ,None RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSMBYTE4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSMBYTE4_RFU_TSMBYTE4 ,None RESET:0x0"
          
group.long  0x2e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TESTMODECONFIG, Reserved for PHY test firmware use. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TESTMODECONFIG_RFU_TESTMODECONFIG ,None RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSMBYTE5, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSMBYTE5_RFU_TSMBYTE5 ,None RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_MTESTMUXSEL, Digital Observation Pin control RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_MTESTMUXSEL_MTESTMUXSEL ,Controls for the 64-1 mux for asynchronous data to the Digital Observation Pin.  - 6'h0 --> Drive 0 from this chiplet (allows flat 'OR' of pass-through information)  - 6'h01:1f --> Select local data from AC/DBYTE/MASTER macro  - 6'h20 --> Reserved (Drive 0 from macro into mux; Drive 0 from PUB synth logic path into mux)  - 6'h21:3f --> Select local data from PUB AC/DBYTE/MASTER synthesized logic Note: See PUB documentation for how, or if, the Digital Observation Pin is mapped to a physical bump in this configuration. RESET:0x0"
          
group.long  0x3e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DTSMTRAINMODECTRL, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DTSMTRAINMODECTRL_RFU_DTSMTRAINMODECTRL ,None RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DFIMRL_P0, DFI MaxReadLatency RESET:0x6"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DFIMRL_P0_DFIMRL_P0 ,This Max Read Latency CSR is to be trained to ensure the rx-data fifo is not read until after all dbytes have their read data valid. This is the value, in units of two mem clocks, between dfi_rddata_en and dfi_rddata_valid A unit change in the LSB is a change in MRL of two mem clocks. RESET:0x6"
          
group.long  0x48++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_ASYNCDBYTEMODE, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_ASYNCDBYTEMODE_ASYNCDBYTEMODE ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_ASYNCDBYTETXEN, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_ASYNCDBYTETXEN_ASYNCDBYTETXEN ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_ASYNCDBYTETXDATA, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_ASYNCDBYTETXDATA_ASYNCDBYTETXDATA ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x54++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_ASYNCDBYTERXDATA, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_ASYNCDBYTERXDATA_ASYNCDBYTERXDATA ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R0, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R0_VREFDAC1_R0 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R0_RFU_TRAININGCNTR_R0 ,None RESET:0x0"
          
group.long  0x80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R0, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R0_VREFDAC0_R0 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0x82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL0_B0_P0, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL0_B0_P0_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL0_B0_P0_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL_B0_P0, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL_B0_P0_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL_B0_P0_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL_B0_P0_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL_B0_P0_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL_B0_P0_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x90++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXEQUALIZATIONMODE_P0, Tx DQ driver equalization is a technique for improving the write-data eye at the DRAMs. The driver can drive with full strength (configured with DrvStrenFSHiDqP and DrvStrenFSLoDqN0 or with weak strength (configured with DrvStrenEQHiDqP and DrvStrenEQLoDqN) depending on the dq value sequence.  - TxEqMode = 00 Off; drive with full strength only  - TxEqMode = 01 Mode0 drive with full strength.or weak strength depending on  present logical value and the previous logical value.  - TxEqMode = 10 Mode1 drive with full strength.or weak strength depending on  present logical value and the next logical value. Mode1 is a lower power mode.  - TxEqMode = 11 reserved RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXEQUALIZATIONMODE_P0_TXEQMODE ,Tx dq driver equalization mode controls. FFE, de-emphasis DDR43 PHY ONLY RESET:0x0"
          
group.long  0x92++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL1_B0_P0, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL1_B0_P0_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL1_B0_P0_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x94++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL1, Misc control of rxdq cell and rxdqs cell RESET:0x400"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL1_POWERDOWNRCVR ,Active high signal which powers down the receiver.  - 7:0 -> dq[7:0]  - 8 -> dbi After this pin is deasserted the receiver cannot be used for a minimum of 100 ns. RESET:0x0"
          
         bitfld.long 0x00 9. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL1_POWERDOWNRCVRDQS ,Active high signal which powers down the receiver. After this pin is deasserted the receiver cannot be used for a minimum of 100 ns. This control powers down both the upper and lower DQS receivers. If Register X4TG[3:0]=0000, then the upper DQS receiver is powered down. RESET:0x0"
          
         bitfld.long 0x00 10. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL1_RXPADSTANDBYEN ,Enables the rxdq/rxdqs StandBy power savings, per pad-group. RESET:0x1"
          
         bitfld.long 0x00 11. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL1_ENLPREQPDR ,Reserved for future use RESET:0x0"
          
group.long  0x96++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL2_B0_P0, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL2_B0_P0_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL2_B0_P0_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x98++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL2_P0, Control for an aggressive power-saving feature to powerdown dq and dqs receiver cells dynamically. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL2_P0_ENRXAGRESSIVEPDR ,reserved RESET:0x0"
          
group.long  0x9a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXODTDRVSTREN_B0_P0, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXODTDRVSTREN_B0_P0_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXODTDRVSTREN_B0_P0_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
rgroup.long 0xac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOCHECKSTATUS, When a PhyRxFifoCheck interrupt is posted these bits indicate which pair of fifo pointers didn't match as expected. The non-zero pointer values can be read from the RxFifoCheckStatusValues register. Setting the PhyRxFifoCheckClr in the PhyInterruptClear register clears these bits. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOCHECKSTATUS_RXFIFOLOCERR ,If set, the read pointer (DFI side) on the read FIFO associated with data bits [3:0] didn't match the write pointer (DQS side) on the read FIFO associated with data bits [3:0]; RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOCHECKSTATUS_RXFIFOLOCUERR ,If set, the read pointer (DFI side) on the read FIFO associated with data bits [7:4] didn't match the write pointer (DQS side) on the read FIFO associated with data bits [7:4]; RESET:0x0"
          
rgroup.long 0xae++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOCHECKERRVALUES, Contains the value of the fifo pointer for the first mismatch captured in the RxFifoCheckStatus register. Setting the PhyRxFifoCheckClr in the PhyInterruptClear register clears these bits. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOCHECKERRVALUES_RXFIFORDLOCERRVALUE ,The first error value captured for the read pointer (DFI side) on the read FIFO associated with data bits [3:0]; RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOCHECKERRVALUES_RXFIFOWRLOCERRVALUE ,The first error value captured for the write pointer (DQS side) on the read FIFO associated with data bits [3:0]; RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOCHECKERRVALUES_RXFIFORDLOCUERRVALUE ,The first error value captured for the read pointer (DFI side) on the read FIFO associated with data bits [7:4]; RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOCHECKERRVALUES_RXFIFOWRLOCUERRVALUE ,The first error value captured for the write pointer (DQS side) on the read FIFO associated with data bits [7:4]; RESET:0x0"
          
rgroup.long 0xb0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOINFO, Provides visibility of the read and write pointers of the RxFifos for debug purposes. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOINFO_RXFIFORDLOC ,The Mission mode read pointer of the lower-nibble Rx fifo. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOINFO_RXFIFOWRLOC ,The Mission mode write pointer of the lower-nibble Rx fifo. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOINFO_RXFIFORDLOCU ,The Mission mode read pointer of the upper-nibble Rx fifo. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOINFO_RXFIFOWRLOCU ,The Mission mode write pointer of the upper-nibble Rx fifo. RESET:0x0"
          
group.long  0xb2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOVISIBILITY, Allows the contents of the data rx fifo to be read via CSRs RxFifoContentsDBI,RxFifoContentsDQ7654,RxFifoContentsDQ3210. The fifo must be quiescent, i.e. no actual operations in progress, while reading the fifo. That is, the read from the RxFifo must be after the max-read-latency (DFIMRL) time.  Procedure to read the contents of the entire RxFifo:  - wait for any outstanding reads to complete (min 2*DFIMRL MemClks)  - read and store RxFifoWrLoc[3:0] and RxFifoWrLocU[3:0] (they should be equal).  - perform four BL8 memory reads  - wait at least 2*DFIMRL MemClks.  - for (iNib=0, iNib<8, iNib++)  - [  - 1. myRdPtr[2:0] = (stored RxFifoWrLoc[3:0]>>1) + iNib (may wrap 7 to 0)  - 2. write addr=RxFifoVisibility, data=[csrRxFifoRdEn=0,csrFifoRdPtrOvr=1,csrRxFifoRdPtr=myRdPtr]  - 3. write addr=RxFifoVisibility, data=[csrRxFifoRdEn=1,csrFifoRdPtrOvr=1,csrRxFifoRdPtr=myRdPtr]  - 4. write addr=RxFifoVisibility, data=[csrRxFifoRdEn=0,csrFifoRdPtrOvr=1,csrRxFifoRdPtr=myRdPtr]  - 5. wait for 8 DfiClk.  - 6. read addr=RxFifoContentsDBI  - 7. read addr=RxFifoContentsDQ7654  - 8. read addr=RxFifoContentsDQ3210  - 9. unpack/align resulting data as described in descriptions of RxFifoContents registers, and map according to the configuration of the csr Dq<7..0>LnSel[2:0].  - ]  - evaluate/compare with data that travels through normal read path (dfi_read_data_dbi,dfi_read_data).  - write [csrRxFifoRdEn=0,csrFifoRdPtrOvr=0,csrRxFifoRdPtr = 0]  - PHY is now available for normal mission-mode operation.  end of Procedure RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOVISIBILITY_RXFIFORDPTR ,If CSR RxFifoRdPtrOVr is set, then this CSR selects the rxfifo entry is visible in CSR. This 3b field addresses 4b units of the 8x4b (32entry) fifo; that is, rdfifo_nibble_address[2:0]=csrRxFifoRdPtr[2:0]  For example, Register RxFifoRdPtr[2:0]=2 will enable reading bit-entries 11..8. The exact location of read data will depend on the prior history of reads and PHY initialization. RESET:0x0"
          
         bitfld.long 0x00 3. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOVISIBILITY_RXFIFORDPTROVR ,This field is programmable as follows: - 0 : Normal operation - mission mode read pointer is enabled - 1 : Override - Control of the rx fifo read pointer is ceded to CSR RxFifoRdPtr. RESET:0x0"
          
         bitfld.long 0x00 4. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOVISIBILITY_RXFIFORDEN ,Pulse [set 0-->1-->0] this bit to capture the Fifo Contents. RESET:0x0"
          
rgroup.long 0xb4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOCONTENTSDQ3210, RX FIFO contents, lane[3:0] RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOCONTENTSDQ3210_RXFIFOCONTENTSDQ3210 ,A window into the contents of the RxFifo, as controlled by CSR RxFifoVisibility. This register reads 4b at a time from lane0..3 from the four fifo entries addressed by rdfifo_nibble_address[2:0]=RxFifoRdPtr[2:0] Register  - [15:12] = [lane3_ui3,lane3_ui2,lane3_ui1,lane3_ui0] where ui0 is the first occurring bit  - [11: 8] = [lane2_ui3,lane2_ui2,lane2_ui1,lane2_ui0]  - [ 7: 4] = [lane1_ui3,lane1_ui2,lane1_ui1,lane1_ui0]  - [ 3: 0] = [lane0_ui3,lane0_ui2,lane0_ui1,lane0_ui0]  Note: The DBYTE lane of a given index is not the same as a memory DQ of the same index unless the csr Dq<7..0>LnSel[2:0] have their default/reset value. RESET:0x0"
          
rgroup.long 0xb6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOCONTENTSDQ7654, RX FIFO contents, lane[7:4] RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOCONTENTSDQ7654_RXFIFOCONTENTSDQ7654 ,A window into the contents of the RxFifo, as controlled by CSR RxFifoVisibility. This register reads 4b at a time from lane4..7 from the four fifo entries addressed by rdfifo_nibble_address[2:0]=RxFifoRdPtr[2:0] Register  - [15:12] = [lane7_ui3,lane7_ui2,lane7_ui1,lane7_ui0]  - [11: 8] = [lane6_ui3,lane6_ui2,lane6_ui1,lane6_ui0]  - [ 7: 4] = [lane5_ui3,lane5_ui2,lane5_ui1,lane5_ui0]  - [ 3: 0] = [lane4_ui3,lane4_ui2,lane4_ui1,lane4_ui0]  Note that the DBYTE lane of a given index is not the same as a memory DQ of the same index unless the csr Dq<7..0>LnSel[2:0] have their default/reset value. RESET:0x0"
          
rgroup.long 0xb8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOCONTENTSDBI, RX FIFO contents, dbi RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXFIFOCONTENTSDBI_RXFIFOCONTENTSDBI ,A window into the contents of the RxFifo, as controlled by CSR RxFifoVisibility. This register reads 4b at a time from DBI from the four fifo entries addressed by rdfifo_nibble_address[2:0]=RxFifoRdPtr[2:0] Register [ 3: 0] = [dbi_ui3,dbi_ui2,dbi_ui1,dbi_ui0]  Note that the DBYTE DBI lane is the same as the memory DBI; it is not subject to mapping using csr Dq<7..0>LnSel[2:0] as the DQ are. RESET:0x0"
          
group.long  0xbe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXSLEWRATE_B0_P0, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXSLEWRATE_B0_P0_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXSLEWRATE_B0_P0_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXSLEWRATE_B0_P0_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0xc4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R0_TRAININGINCDECDTSMEN_R0 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xd0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R0, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R0_RXPBDLYTG0_R0 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0xd2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R0, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R0_RXPBDLYTG1_R0 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0xd4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R0, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R0_RXPBDLYTG2_R0 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0xd6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R0, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R0_RXPBDLYTG3_R0 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG0_U0_P0, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG0_U0_P0_RXENDLYTG0_U0_P0 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG1_U0_P0, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG1_U0_P0_RXENDLYTG1_U0_P0 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x104++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG2_U0_P0, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG2_U0_P0_RXENDLYTG2_U0_P0 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x106++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG3_U0_P0, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG3_U0_P0_RXENDLYTG3_U0_P0 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x118++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG0_U0_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG0_U0_P0_RXCLKDLYTG0_U0_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x11a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG1_U0_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG1_U0_P0_RXCLKDLYTG1_U0_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x11c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG2_U0_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG2_U0_P0_RXCLKDLYTG2_U0_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x11e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG3_U0_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG3_U0_P0_RXCLKDLYTG3_U0_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x120++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG0_U0_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG0_U0_P0_RXCLKCDLYTG0_U0_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x122++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG1_U0_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG1_U0_P0_RXCLKCDLYTG1_U0_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x124++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG2_U0_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG2_U0_P0_RXCLKCDLYTG2_U0_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x126++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG3_U0_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG3_U0_P0_RXCLKCDLYTG3_U0_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x140++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ0LNSEL, Maps Phy DQ lane to memory DQ0 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ0LNSEL_DQ0LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq0 (on this dbyte), then Register Dq0LnSel for this dbyte should be 3. RESET:0x0"
          
group.long  0x142++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ1LNSEL, Maps Phy DQ lane to memory DQ1 RESET:0x1"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ1LNSEL_DQ1LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq1 (on this dbyte), then Register Dq1LnSel for this dbyte should be 3. RESET:0x1"
          
group.long  0x144++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ2LNSEL, Maps Phy DQ lane to memory DQ2 RESET:0x2"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ2LNSEL_DQ2LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq2 (on this dbyte), then Register Dq2LnSel for this dbyte should be 3. RESET:0x2"
          
group.long  0x146++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ3LNSEL, Maps Phy DQ lane to memory DQ3 RESET:0x3"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ3LNSEL_DQ3LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq3 (on this dbyte), then Register Dq3LnSel for this dbyte should be 3. RESET:0x3"
          
group.long  0x148++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ4LNSEL, Maps Phy DQ lane to memory DQ4 RESET:0x4"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ4LNSEL_DQ4LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq4 (on this dbyte), then Register Dq4LnSel for this dbyte should be 3. RESET:0x4"
          
group.long  0x14a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ5LNSEL, Maps Phy DQ lane to memory DQ5 RESET:0x5"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ5LNSEL_DQ5LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq5 (on this dbyte), then Register Dq5LnSel for this dbyte should be 3. RESET:0x5"
          
group.long  0x14c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ6LNSEL, Maps Phy DQ lane to memory DQ6 RESET:0x6"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ6LNSEL_DQ6LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq6 (on this dbyte), then Register Dq6LnSel for this dbyte should be 3. RESET:0x6"
          
group.long  0x14e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ7LNSEL, Maps Phy DQ lane to memory DQ7 RESET:0x7"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQ7LNSEL_DQ7LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq7 (on this dbyte), then Register Dq7LnSel for this dbyte should be 3. RESET:0x7"
          
group.long  0x154++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_PPTCTLSTATIC, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_PPTCTLSTATIC_RFU_PPTCTLSTATIC ,None RESET:0x0"
          
group.long  0x156++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_PPTCTLDYN, This register is dynamically written by PHY Initialization Engine during frequency changes and should not be written by the user. RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_PPTCTLDYN_RFU_PPTCTLDYN ,None RESET:0x0"
          
rgroup.long 0x158++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_PPTINFO, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_PPTINFO_PPTINFO ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x15a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_PPTRXENEVNT, This register is dynamically written by PHY Initialization Engine during frequency changes and should not be written by the user. RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_PPTRXENEVNT_RFU_PPTRXENEVNT ,None RESET:0x0"
          
group.long  0x15c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_PPTDQSCNTINVTRNTG0_P0, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_PPTDQSCNTINVTRNTG0_P0_PPTDQSCNTINVTRNTG0_P0 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x15e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_PPTDQSCNTINVTRNTG1_P0, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_PPTDQSCNTINVTRNTG1_P0_PPTDQSCNTINVTRNTG1_P0 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x162++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DTSMBLANKINGCTRL, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DTSMBLANKINGCTRL_RFU_DTSMBLANKINGCTRL ,None RESET:0x0"
          
group.long  0x164++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I0_RFU_TSM0_I0 ,None RESET:0x0"
          
rgroup.long 0x166++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I0_RFU_TSM1_I0 ,None RESET:0x0"
          
group.long  0x168++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I0_RFU_TSM2_I0 ,None RESET:0x0"
          
group.long  0x16a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM3_RFU_TSM3 ,None RESET:0x0"
          
group.long  0x16c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXCHKDATASELECTS, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXCHKDATASELECTS_RFU_TXCHKDATASELECTS ,None RESET:0x0"
          
rgroup.long 0x16e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DTSMUPTHLDXINGIND, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DTSMUPTHLDXINGIND_DTSMUPTHLDXINGIND ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x170++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DTSMLOTHLDXINGIND, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DTSMLOTHLDXINGIND_DTSMLOTHLDXINGIND ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x172++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DBYTEALLDTSMCTRL0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DBYTEALLDTSMCTRL0_RFU_DBYTEALLDTSMCTRL0 ,None RESET:0x0"
          
group.long  0x174++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DBYTEALLDTSMCTRL1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DBYTEALLDTSMCTRL1_RFU_DBYTEALLDTSMCTRL1 ,None RESET:0x0"
          
group.long  0x176++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DBYTEALLDTSMCTRL2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DBYTEALLDTSMCTRL2_RFU_DBYTEALLDTSMCTRL2 ,None RESET:0x0"
          
group.long  0x180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R0_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R0_P0_TXDQDLYTG0_R0_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R0_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R0_P0_TXDQDLYTG1_R0_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R0_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R0_P0_TXDQDLYTG2_R0_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R0_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R0_P0_TXDQDLYTG3_R0_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG0_U0_P0, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG0_U0_P0_TXDQSDLYTG0_U0_P0 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x1a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG1_U0_P0, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG1_U0_P0_TXDQSDLYTG1_U0_P0 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x1a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG2_U0_P0, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG2_U0_P0_TXDQSDLYTG2_U0_P0 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x1a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG3_U0_P0, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG3_U0_P0_TXDQSDLYTG3_U0_P0 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
rgroup.long 0x1c8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DXLCDLSTATUS, Status of dbyte macro LCDL selected by Register LcdlStatusSel  Note, this register is per dbyte. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DXLCDLSTATUS_DXLCDLFINESNAPVAL ,Value of the LCDL 1UI estimate code, latched by pulse on csr LcdlFineSnap while csr LcdlTstEnable=1. Index 9 is reserved for growth. RESET:0x0"
          
         bitfld.long 0x00 10. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DXLCDLSTATUS_DXLCDLPHDSNAPVAL ,Value of the LCDL phase-detector output, latched by pulse on csr LcdlFineSnap. while csr LcdlTstEnable=1. RESET:0x0"
          
         bitfld.long 0x00 11. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DXLCDLSTATUS_DXLCDLSTICKYLOCK ,Latched value of whether the LCDL ever achieved lock after the assertion of LcdlTstEnable. RESET:0x0"
          
         bitfld.long 0x00 12. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DXLCDLSTATUS_DXLCDLSTICKYUNLOCK ,Latched value of whether the LCDL ever lost lock after the assertion of LcdlTstEnable. RESET:0x0"
          
         bitfld.long 0x00 13. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DXLCDLSTATUS_DXLCDLLIVELOCK ,Present value of whether the LCDL is locked. Valid when LcdlTstEnable=1. RESET:0x0"
          
group.long  0x260++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R1, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R1_VREFDAC1_R1 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0x264++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R1_RFU_TRAININGCNTR_R1 ,None RESET:0x0"
          
group.long  0x280++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R1, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R1_VREFDAC0_R1 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0x282++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL0_B1_P0, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL0_B1_P0_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL0_B1_P0_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x286++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL_B1_P0, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL_B1_P0_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL_B1_P0_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL_B1_P0_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL_B1_P0_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_DQDQSRCVCNTRL_B1_P0_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x292++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL1_B1_P0, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL1_B1_P0_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL1_B1_P0_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x296++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL2_B1_P0, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL2_B1_P0_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXIMPEDANCECTRL2_B1_P0_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x29a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXODTDRVSTREN_B1_P0, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXODTDRVSTREN_B1_P0_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXODTDRVSTREN_B1_P0_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
group.long  0x2be++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXSLEWRATE_B1_P0, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXSLEWRATE_B1_P0_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXSLEWRATE_B1_P0_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXSLEWRATE_B1_P0_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0x2c4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R1_TRAININGINCDECDTSMEN_R1 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x2d0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R1, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R1_RXPBDLYTG0_R1 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0x2d2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R1, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R1_RXPBDLYTG1_R1 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0x2d4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R1, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R1_RXPBDLYTG2_R1 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0x2d6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R1, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R1_RXPBDLYTG3_R1 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0x300++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG0_U1_P0, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG0_U1_P0_RXENDLYTG0_U1_P0 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x302++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG1_U1_P0, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG1_U1_P0_RXENDLYTG1_U1_P0 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x304++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG2_U1_P0, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG2_U1_P0_RXENDLYTG2_U1_P0 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x306++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG3_U1_P0, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXENDLYTG3_U1_P0_RXENDLYTG3_U1_P0 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x318++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG0_U1_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG0_U1_P0_RXCLKDLYTG0_U1_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x31a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG1_U1_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG1_U1_P0_RXCLKDLYTG1_U1_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x31c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG2_U1_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG2_U1_P0_RXCLKDLYTG2_U1_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x31e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG3_U1_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKDLYTG3_U1_P0_RXCLKDLYTG3_U1_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x320++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG0_U1_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG0_U1_P0_RXCLKCDLYTG0_U1_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x322++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG1_U1_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG1_U1_P0_RXCLKCDLYTG1_U1_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x324++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG2_U1_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG2_U1_P0_RXCLKCDLYTG2_U1_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x326++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG3_U1_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXCLKCDLYTG3_U1_P0_RXCLKCDLYTG3_U1_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x364++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I1_RFU_TSM0_I1 ,None RESET:0x0"
          
rgroup.long 0x366++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I1_RFU_TSM1_I1 ,None RESET:0x0"
          
group.long  0x368++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I1_RFU_TSM2_I1 ,None RESET:0x0"
          
group.long  0x380++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R1_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R1_P0_TXDQDLYTG0_R1_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x382++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R1_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R1_P0_TXDQDLYTG1_R1_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x384++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R1_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R1_P0_TXDQDLYTG2_R1_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x386++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R1_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R1_P0_TXDQDLYTG3_R1_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x3a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG0_U1_P0, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG0_U1_P0_TXDQSDLYTG0_U1_P0 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x3a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG1_U1_P0, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG1_U1_P0_TXDQSDLYTG1_U1_P0 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x3a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG2_U1_P0, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG2_U1_P0_TXDQSDLYTG2_U1_P0 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x3a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG3_U1_P0, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQSDLYTG3_U1_P0_TXDQSDLYTG3_U1_P0 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x460++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R2, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R2_VREFDAC1_R2 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0x464++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R2_RFU_TRAININGCNTR_R2 ,None RESET:0x0"
          
group.long  0x480++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R2, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R2_VREFDAC0_R2 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0x4c4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R2_TRAININGINCDECDTSMEN_R2 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x4d0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R2, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R2_RXPBDLYTG0_R2 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0x4d2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R2, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R2_RXPBDLYTG1_R2 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0x4d4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R2, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R2_RXPBDLYTG2_R2 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0x4d6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R2, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R2_RXPBDLYTG3_R2 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0x564++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I2_RFU_TSM0_I2 ,None RESET:0x0"
          
rgroup.long 0x566++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I2_RFU_TSM1_I2 ,None RESET:0x0"
          
group.long  0x568++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I2_RFU_TSM2_I2 ,None RESET:0x0"
          
group.long  0x580++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R2_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R2_P0_TXDQDLYTG0_R2_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x582++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R2_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R2_P0_TXDQDLYTG1_R2_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x584++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R2_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R2_P0_TXDQDLYTG2_R2_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x586++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R2_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R2_P0_TXDQDLYTG3_R2_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x660++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R3, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R3_VREFDAC1_R3 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0x664++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R3_RFU_TRAININGCNTR_R3 ,None RESET:0x0"
          
group.long  0x680++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R3, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R3_VREFDAC0_R3 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0x6c4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R3_TRAININGINCDECDTSMEN_R3 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x6d0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R3, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R3_RXPBDLYTG0_R3 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0x6d2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R3, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R3_RXPBDLYTG1_R3 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0x6d4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R3, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R3_RXPBDLYTG2_R3 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0x6d6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R3, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R3_RXPBDLYTG3_R3 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0x764++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I3_RFU_TSM0_I3 ,None RESET:0x0"
          
rgroup.long 0x766++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I3_RFU_TSM1_I3 ,None RESET:0x0"
          
group.long  0x768++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I3_RFU_TSM2_I3 ,None RESET:0x0"
          
group.long  0x780++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R3_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R3_P0_TXDQDLYTG0_R3_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x782++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R3_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R3_P0_TXDQDLYTG1_R3_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x784++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R3_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R3_P0_TXDQDLYTG2_R3_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x786++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R3_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R3_P0_TXDQDLYTG3_R3_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x860++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R4, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R4_VREFDAC1_R4 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0x864++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R4_RFU_TRAININGCNTR_R4 ,None RESET:0x0"
          
group.long  0x880++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R4, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R4_VREFDAC0_R4 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0x8c4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R4_TRAININGINCDECDTSMEN_R4 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x8d0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R4, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R4_RXPBDLYTG0_R4 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0x8d2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R4, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R4_RXPBDLYTG1_R4 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0x8d4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R4, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R4_RXPBDLYTG2_R4 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0x8d6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R4, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R4_RXPBDLYTG3_R4 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0x964++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I4, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I4_RFU_TSM0_I4 ,None RESET:0x0"
          
rgroup.long 0x966++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I4_RFU_TSM1_I4 ,None RESET:0x0"
          
group.long  0x968++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I4, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I4_RFU_TSM2_I4 ,None RESET:0x0"
          
group.long  0x980++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R4_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R4_P0_TXDQDLYTG0_R4_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x982++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R4_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R4_P0_TXDQDLYTG1_R4_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x984++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R4_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R4_P0_TXDQDLYTG2_R4_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x986++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R4_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R4_P0_TXDQDLYTG3_R4_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xa60++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R5, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R5_VREFDAC1_R5 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0xa64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R5_RFU_TRAININGCNTR_R5 ,None RESET:0x0"
          
group.long  0xa80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R5, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R5_VREFDAC0_R5 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0xac4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R5_TRAININGINCDECDTSMEN_R5 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xad0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R5, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R5_RXPBDLYTG0_R5 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0xad2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R5, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R5_RXPBDLYTG1_R5 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0xad4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R5, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R5_RXPBDLYTG2_R5 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0xad6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R5, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R5_RXPBDLYTG3_R5 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0xb64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I5, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I5_RFU_TSM0_I5 ,None RESET:0x0"
          
rgroup.long 0xb66++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I5_RFU_TSM1_I5 ,None RESET:0x0"
          
group.long  0xb68++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I5, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I5_RFU_TSM2_I5 ,None RESET:0x0"
          
group.long  0xb80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R5_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R5_P0_TXDQDLYTG0_R5_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xb82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R5_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R5_P0_TXDQDLYTG1_R5_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xb84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R5_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R5_P0_TXDQDLYTG2_R5_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xb86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R5_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R5_P0_TXDQDLYTG3_R5_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xc60++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R6, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R6_VREFDAC1_R6 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0xc64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R6_RFU_TRAININGCNTR_R6 ,None RESET:0x0"
          
group.long  0xc80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R6, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R6_VREFDAC0_R6 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0xcc4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R6_TRAININGINCDECDTSMEN_R6 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xcd0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R6, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R6_RXPBDLYTG0_R6 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0xcd2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R6, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R6_RXPBDLYTG1_R6 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0xcd4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R6, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R6_RXPBDLYTG2_R6 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0xcd6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R6, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R6_RXPBDLYTG3_R6 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0xd64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I6, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I6_RFU_TSM0_I6 ,None RESET:0x0"
          
rgroup.long 0xd66++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I6_RFU_TSM1_I6 ,None RESET:0x0"
          
group.long  0xd68++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I6, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I6_RFU_TSM2_I6 ,None RESET:0x0"
          
group.long  0xd80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R6_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R6_P0_TXDQDLYTG0_R6_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xd82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R6_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R6_P0_TXDQDLYTG1_R6_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xd84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R6_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R6_P0_TXDQDLYTG2_R6_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xd86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R6_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R6_P0_TXDQDLYTG3_R6_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xe60++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R7, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R7_VREFDAC1_R7 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0xe64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R7_RFU_TRAININGCNTR_R7 ,None RESET:0x0"
          
group.long  0xe80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R7, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R7_VREFDAC0_R7 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0xec4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R7_TRAININGINCDECDTSMEN_R7 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xed0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R7, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R7_RXPBDLYTG0_R7 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0xed2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R7, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R7_RXPBDLYTG1_R7 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0xed4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R7, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R7_RXPBDLYTG2_R7 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0xed6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R7, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R7_RXPBDLYTG3_R7 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0xf64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I7, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I7_RFU_TSM0_I7 ,None RESET:0x0"
          
rgroup.long 0xf66++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I7_RFU_TSM1_I7 ,None RESET:0x0"
          
group.long  0xf68++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I7, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I7_RFU_TSM2_I7 ,None RESET:0x0"
          
group.long  0xf80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R7_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R7_P0_TXDQDLYTG0_R7_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xf82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R7_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R7_P0_TXDQDLYTG1_R7_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xf84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R7_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R7_P0_TXDQDLYTG2_R7_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xf86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R7_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R7_P0_TXDQDLYTG3_R7_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1060++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R8, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC1_R8_VREFDAC1_R8 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0x1064++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGCNTR_R8_RFU_TRAININGCNTR_R8 ,None RESET:0x0"
          
group.long  0x1080++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R8, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_VREFDAC0_R8_VREFDAC0_R8 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0x10c4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TRAININGINCDECDTSMEN_R8_TRAININGINCDECDTSMEN_R8 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x10d0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R8, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG0_R8_RXPBDLYTG0_R8 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0x10d2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R8, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG1_R8_RXPBDLYTG1_R8 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0x10d4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R8, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG2_R8_RXPBDLYTG2_R8 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0x10d6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R8, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_RXPBDLYTG3_R8_RXPBDLYTG3_R8 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0x1164++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I8, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM0_I8_RFU_TSM0_I8 ,None RESET:0x0"
          
rgroup.long 0x1166++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM1_I8_RFU_TSM1_I8 ,None RESET:0x0"
          
group.long  0x1168++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I8, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TSM2_I8_RFU_TSM2_I8 ,None RESET:0x0"
          
group.long  0x1180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R8_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG0_R8_P0_TXDQDLYTG0_R8_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x1182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R8_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG1_R8_P0_TXDQDLYTG1_R8_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x1184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R8_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG2_R8_P0_TXDQDLYTG2_R8_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x1186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R8_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE0_P0_TXDQDLYTG3_R8_P0_TXDQDLYTG3_R8_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
tree.end
    

tree "LPDDR4_PUB__DWC_DDRPHYA_DBYTE1_P0"
base e:0x42022000
width 80.
group.long  0x0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DBYTEMISCMODE, Controls the enable/disable state of the DBYTE module. RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DBYTEMISCMODE_DBYTEDISABLE ,Controls whether this DBYTE module is disabled. If this DBYTE module is not enabled, it receives no clocks and remains in reset.  - 0 - Enable this DBYTE module  - 1 - Disable this DBYTE module This field should only be changed PHY initialization step C. RESET:0x0"
          
group.long  0x2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSMBYTE0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSMBYTE0_RFU_TSMBYTE0 ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGPARAM, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGPARAM_RFU_TRAININGPARAM ,None RESET:0x0"
          
group.long  0x6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_USEDQSENREPLICA_P0, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_USEDQSENREPLICA_P0_USEDQSENREPLICA_P0 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXTRAINPATTERNENABLE, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXTRAINPATTERNENABLE_RXTRAINPATTERNENABLE ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x22++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSMBYTE1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSMBYTE1_RFU_TSMBYTE1 ,None RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSMBYTE2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSMBYTE2_RFU_TSMBYTE2 ,None RESET:0x0"
          
group.long  0x26++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSMBYTE3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSMBYTE3_RFU_TSMBYTE3 ,None RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSMBYTE4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSMBYTE4_RFU_TSMBYTE4 ,None RESET:0x0"
          
group.long  0x2e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TESTMODECONFIG, Reserved for PHY test firmware use. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TESTMODECONFIG_RFU_TESTMODECONFIG ,None RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSMBYTE5, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSMBYTE5_RFU_TSMBYTE5 ,None RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_MTESTMUXSEL, Digital Observation Pin control RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_MTESTMUXSEL_MTESTMUXSEL ,Controls for the 64-1 mux for asynchronous data to the Digital Observation Pin.  - 6'h0 --> Drive 0 from this chiplet (allows flat 'OR' of pass-through information)  - 6'h01:1f --> Select local data from AC/DBYTE/MASTER macro  - 6'h20 --> Reserved (Drive 0 from macro into mux; Drive 0 from PUB synth logic path into mux)  - 6'h21:3f --> Select local data from PUB AC/DBYTE/MASTER synthesized logic Note: See PUB documentation for how, or if, the Digital Observation Pin is mapped to a physical bump in this configuration. RESET:0x0"
          
group.long  0x3e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DTSMTRAINMODECTRL, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DTSMTRAINMODECTRL_RFU_DTSMTRAINMODECTRL ,None RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DFIMRL_P0, DFI MaxReadLatency RESET:0x6"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DFIMRL_P0_DFIMRL_P0 ,This Max Read Latency CSR is to be trained to ensure the rx-data fifo is not read until after all dbytes have their read data valid. This is the value, in units of two mem clocks, between dfi_rddata_en and dfi_rddata_valid A unit change in the LSB is a change in MRL of two mem clocks. RESET:0x6"
          
group.long  0x48++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_ASYNCDBYTEMODE, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_ASYNCDBYTEMODE_ASYNCDBYTEMODE ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_ASYNCDBYTETXEN, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_ASYNCDBYTETXEN_ASYNCDBYTETXEN ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_ASYNCDBYTETXDATA, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_ASYNCDBYTETXDATA_ASYNCDBYTETXDATA ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x54++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_ASYNCDBYTERXDATA, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_ASYNCDBYTERXDATA_ASYNCDBYTERXDATA ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R0, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R0_VREFDAC1_R0 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R0_RFU_TRAININGCNTR_R0 ,None RESET:0x0"
          
group.long  0x80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R0, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R0_VREFDAC0_R0 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0x82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL0_B0_P0, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL0_B0_P0_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL0_B0_P0_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL_B0_P0, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL_B0_P0_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL_B0_P0_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL_B0_P0_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL_B0_P0_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL_B0_P0_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x90++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXEQUALIZATIONMODE_P0, Tx DQ driver equalization is a technique for improving the write-data eye at the DRAMs. The driver can drive with full strength (configured with DrvStrenFSHiDqP and DrvStrenFSLoDqN0 or with weak strength (configured with DrvStrenEQHiDqP and DrvStrenEQLoDqN) depending on the dq value sequence.  - TxEqMode = 00 Off; drive with full strength only  - TxEqMode = 01 Mode0 drive with full strength.or weak strength depending on  present logical value and the previous logical value.  - TxEqMode = 10 Mode1 drive with full strength.or weak strength depending on  present logical value and the next logical value. Mode1 is a lower power mode.  - TxEqMode = 11 reserved RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXEQUALIZATIONMODE_P0_TXEQMODE ,Tx dq driver equalization mode controls. FFE, de-emphasis DDR43 PHY ONLY RESET:0x0"
          
group.long  0x92++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL1_B0_P0, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL1_B0_P0_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL1_B0_P0_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x94++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL1, Misc control of rxdq cell and rxdqs cell RESET:0x400"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL1_POWERDOWNRCVR ,Active high signal which powers down the receiver.  - 7:0 -> dq[7:0]  - 8 -> dbi After this pin is deasserted the receiver cannot be used for a minimum of 100 ns. RESET:0x0"
          
         bitfld.long 0x00 9. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL1_POWERDOWNRCVRDQS ,Active high signal which powers down the receiver. After this pin is deasserted the receiver cannot be used for a minimum of 100 ns. This control powers down both the upper and lower DQS receivers. If Register X4TG[3:0]=0000, then the upper DQS receiver is powered down. RESET:0x0"
          
         bitfld.long 0x00 10. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL1_RXPADSTANDBYEN ,Enables the rxdq/rxdqs StandBy power savings, per pad-group. RESET:0x1"
          
         bitfld.long 0x00 11. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL1_ENLPREQPDR ,Reserved for future use RESET:0x0"
          
group.long  0x96++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL2_B0_P0, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL2_B0_P0_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL2_B0_P0_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x98++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL2_P0, Control for an aggressive power-saving feature to powerdown dq and dqs receiver cells dynamically. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL2_P0_ENRXAGRESSIVEPDR ,reserved RESET:0x0"
          
group.long  0x9a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXODTDRVSTREN_B0_P0, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXODTDRVSTREN_B0_P0_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXODTDRVSTREN_B0_P0_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
rgroup.long 0xac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOCHECKSTATUS, When a PhyRxFifoCheck interrupt is posted these bits indicate which pair of fifo pointers didn't match as expected. The non-zero pointer values can be read from the RxFifoCheckStatusValues register. Setting the PhyRxFifoCheckClr in the PhyInterruptClear register clears these bits. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOCHECKSTATUS_RXFIFOLOCERR ,If set, the read pointer (DFI side) on the read FIFO associated with data bits [3:0] didn't match the write pointer (DQS side) on the read FIFO associated with data bits [3:0]; RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOCHECKSTATUS_RXFIFOLOCUERR ,If set, the read pointer (DFI side) on the read FIFO associated with data bits [7:4] didn't match the write pointer (DQS side) on the read FIFO associated with data bits [7:4]; RESET:0x0"
          
rgroup.long 0xae++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOCHECKERRVALUES, Contains the value of the fifo pointer for the first mismatch captured in the RxFifoCheckStatus register. Setting the PhyRxFifoCheckClr in the PhyInterruptClear register clears these bits. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOCHECKERRVALUES_RXFIFORDLOCERRVALUE ,The first error value captured for the read pointer (DFI side) on the read FIFO associated with data bits [3:0]; RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOCHECKERRVALUES_RXFIFOWRLOCERRVALUE ,The first error value captured for the write pointer (DQS side) on the read FIFO associated with data bits [3:0]; RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOCHECKERRVALUES_RXFIFORDLOCUERRVALUE ,The first error value captured for the read pointer (DFI side) on the read FIFO associated with data bits [7:4]; RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOCHECKERRVALUES_RXFIFOWRLOCUERRVALUE ,The first error value captured for the write pointer (DQS side) on the read FIFO associated with data bits [7:4]; RESET:0x0"
          
rgroup.long 0xb0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOINFO, Provides visibility of the read and write pointers of the RxFifos for debug purposes. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOINFO_RXFIFORDLOC ,The Mission mode read pointer of the lower-nibble Rx fifo. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOINFO_RXFIFOWRLOC ,The Mission mode write pointer of the lower-nibble Rx fifo. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOINFO_RXFIFORDLOCU ,The Mission mode read pointer of the upper-nibble Rx fifo. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOINFO_RXFIFOWRLOCU ,The Mission mode write pointer of the upper-nibble Rx fifo. RESET:0x0"
          
group.long  0xb2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOVISIBILITY, Allows the contents of the data rx fifo to be read via CSRs RxFifoContentsDBI,RxFifoContentsDQ7654,RxFifoContentsDQ3210. The fifo must be quiescent, i.e. no actual operations in progress, while reading the fifo. That is, the read from the RxFifo must be after the max-read-latency (DFIMRL) time.  Procedure to read the contents of the entire RxFifo:  - wait for any outstanding reads to complete (min 2*DFIMRL MemClks)  - read and store RxFifoWrLoc[3:0] and RxFifoWrLocU[3:0] (they should be equal).  - perform four BL8 memory reads  - wait at least 2*DFIMRL MemClks.  - for (iNib=0, iNib<8, iNib++)  - [  - 1. myRdPtr[2:0] = (stored RxFifoWrLoc[3:0]>>1) + iNib (may wrap 7 to 0)  - 2. write addr=RxFifoVisibility, data=[csrRxFifoRdEn=0,csrFifoRdPtrOvr=1,csrRxFifoRdPtr=myRdPtr]  - 3. write addr=RxFifoVisibility, data=[csrRxFifoRdEn=1,csrFifoRdPtrOvr=1,csrRxFifoRdPtr=myRdPtr]  - 4. write addr=RxFifoVisibility, data=[csrRxFifoRdEn=0,csrFifoRdPtrOvr=1,csrRxFifoRdPtr=myRdPtr]  - 5. wait for 8 DfiClk.  - 6. read addr=RxFifoContentsDBI  - 7. read addr=RxFifoContentsDQ7654  - 8. read addr=RxFifoContentsDQ3210  - 9. unpack/align resulting data as described in descriptions of RxFifoContents registers, and map according to the configuration of the csr Dq<7..0>LnSel[2:0].  - ]  - evaluate/compare with data that travels through normal read path (dfi_read_data_dbi,dfi_read_data).  - write [csrRxFifoRdEn=0,csrFifoRdPtrOvr=0,csrRxFifoRdPtr = 0]  - PHY is now available for normal mission-mode operation.  end of Procedure RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOVISIBILITY_RXFIFORDPTR ,If CSR RxFifoRdPtrOVr is set, then this CSR selects the rxfifo entry is visible in CSR. This 3b field addresses 4b units of the 8x4b (32entry) fifo; that is, rdfifo_nibble_address[2:0]=csrRxFifoRdPtr[2:0]  For example, Register RxFifoRdPtr[2:0]=2 will enable reading bit-entries 11..8. The exact location of read data will depend on the prior history of reads and PHY initialization. RESET:0x0"
          
         bitfld.long 0x00 3. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOVISIBILITY_RXFIFORDPTROVR ,This field is programmable as follows: - 0 : Normal operation - mission mode read pointer is enabled - 1 : Override - Control of the rx fifo read pointer is ceded to CSR RxFifoRdPtr. RESET:0x0"
          
         bitfld.long 0x00 4. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOVISIBILITY_RXFIFORDEN ,Pulse [set 0-->1-->0] this bit to capture the Fifo Contents. RESET:0x0"
          
rgroup.long 0xb4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOCONTENTSDQ3210, RX FIFO contents, lane[3:0] RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOCONTENTSDQ3210_RXFIFOCONTENTSDQ3210 ,A window into the contents of the RxFifo, as controlled by CSR RxFifoVisibility. This register reads 4b at a time from lane0..3 from the four fifo entries addressed by rdfifo_nibble_address[2:0]=RxFifoRdPtr[2:0] Register  - [15:12] = [lane3_ui3,lane3_ui2,lane3_ui1,lane3_ui0] where ui0 is the first occurring bit  - [11: 8] = [lane2_ui3,lane2_ui2,lane2_ui1,lane2_ui0]  - [ 7: 4] = [lane1_ui3,lane1_ui2,lane1_ui1,lane1_ui0]  - [ 3: 0] = [lane0_ui3,lane0_ui2,lane0_ui1,lane0_ui0]  Note: The DBYTE lane of a given index is not the same as a memory DQ of the same index unless the csr Dq<7..0>LnSel[2:0] have their default/reset value. RESET:0x0"
          
rgroup.long 0xb6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOCONTENTSDQ7654, RX FIFO contents, lane[7:4] RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOCONTENTSDQ7654_RXFIFOCONTENTSDQ7654 ,A window into the contents of the RxFifo, as controlled by CSR RxFifoVisibility. This register reads 4b at a time from lane4..7 from the four fifo entries addressed by rdfifo_nibble_address[2:0]=RxFifoRdPtr[2:0] Register  - [15:12] = [lane7_ui3,lane7_ui2,lane7_ui1,lane7_ui0]  - [11: 8] = [lane6_ui3,lane6_ui2,lane6_ui1,lane6_ui0]  - [ 7: 4] = [lane5_ui3,lane5_ui2,lane5_ui1,lane5_ui0]  - [ 3: 0] = [lane4_ui3,lane4_ui2,lane4_ui1,lane4_ui0]  Note that the DBYTE lane of a given index is not the same as a memory DQ of the same index unless the csr Dq<7..0>LnSel[2:0] have their default/reset value. RESET:0x0"
          
rgroup.long 0xb8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOCONTENTSDBI, RX FIFO contents, dbi RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXFIFOCONTENTSDBI_RXFIFOCONTENTSDBI ,A window into the contents of the RxFifo, as controlled by CSR RxFifoVisibility. This register reads 4b at a time from DBI from the four fifo entries addressed by rdfifo_nibble_address[2:0]=RxFifoRdPtr[2:0] Register [ 3: 0] = [dbi_ui3,dbi_ui2,dbi_ui1,dbi_ui0]  Note that the DBYTE DBI lane is the same as the memory DBI; it is not subject to mapping using csr Dq<7..0>LnSel[2:0] as the DQ are. RESET:0x0"
          
group.long  0xbe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXSLEWRATE_B0_P0, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXSLEWRATE_B0_P0_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXSLEWRATE_B0_P0_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXSLEWRATE_B0_P0_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0xc4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R0_TRAININGINCDECDTSMEN_R0 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xd0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R0, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R0_RXPBDLYTG0_R0 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0xd2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R0, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R0_RXPBDLYTG1_R0 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0xd4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R0, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R0_RXPBDLYTG2_R0 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0xd6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R0, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R0_RXPBDLYTG3_R0 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG0_U0_P0, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG0_U0_P0_RXENDLYTG0_U0_P0 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG1_U0_P0, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG1_U0_P0_RXENDLYTG1_U0_P0 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x104++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG2_U0_P0, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG2_U0_P0_RXENDLYTG2_U0_P0 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x106++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG3_U0_P0, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG3_U0_P0_RXENDLYTG3_U0_P0 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x118++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG0_U0_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG0_U0_P0_RXCLKDLYTG0_U0_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x11a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG1_U0_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG1_U0_P0_RXCLKDLYTG1_U0_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x11c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG2_U0_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG2_U0_P0_RXCLKDLYTG2_U0_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x11e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG3_U0_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG3_U0_P0_RXCLKDLYTG3_U0_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x120++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG0_U0_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG0_U0_P0_RXCLKCDLYTG0_U0_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x122++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG1_U0_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG1_U0_P0_RXCLKCDLYTG1_U0_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x124++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG2_U0_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG2_U0_P0_RXCLKCDLYTG2_U0_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x126++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG3_U0_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG3_U0_P0_RXCLKCDLYTG3_U0_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x140++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ0LNSEL, Maps Phy DQ lane to memory DQ0 RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ0LNSEL_DQ0LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq0 (on this dbyte), then Register Dq0LnSel for this dbyte should be 3. RESET:0x0"
          
group.long  0x142++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ1LNSEL, Maps Phy DQ lane to memory DQ1 RESET:0x1"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ1LNSEL_DQ1LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq1 (on this dbyte), then Register Dq1LnSel for this dbyte should be 3. RESET:0x1"
          
group.long  0x144++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ2LNSEL, Maps Phy DQ lane to memory DQ2 RESET:0x2"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ2LNSEL_DQ2LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq2 (on this dbyte), then Register Dq2LnSel for this dbyte should be 3. RESET:0x2"
          
group.long  0x146++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ3LNSEL, Maps Phy DQ lane to memory DQ3 RESET:0x3"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ3LNSEL_DQ3LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq3 (on this dbyte), then Register Dq3LnSel for this dbyte should be 3. RESET:0x3"
          
group.long  0x148++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ4LNSEL, Maps Phy DQ lane to memory DQ4 RESET:0x4"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ4LNSEL_DQ4LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq4 (on this dbyte), then Register Dq4LnSel for this dbyte should be 3. RESET:0x4"
          
group.long  0x14a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ5LNSEL, Maps Phy DQ lane to memory DQ5 RESET:0x5"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ5LNSEL_DQ5LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq5 (on this dbyte), then Register Dq5LnSel for this dbyte should be 3. RESET:0x5"
          
group.long  0x14c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ6LNSEL, Maps Phy DQ lane to memory DQ6 RESET:0x6"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ6LNSEL_DQ6LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq6 (on this dbyte), then Register Dq6LnSel for this dbyte should be 3. RESET:0x6"
          
group.long  0x14e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ7LNSEL, Maps Phy DQ lane to memory DQ7 RESET:0x7"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQ7LNSEL_DQ7LNSEL ,Supports mapping of PHY dq to dram dq within a byte (swizzle). Intended to undo the swizzle of board-level phy-to-dram connections such that MRR operations of binary counters may be return correct values.  Note that this register is per-dbyte such that the swizzle may be different per dbyte. Each register in a byte's set of DqLnSel must have a unique value within the set.  For example, if, on this dbyte, PHY lane 3 is connected to memory dq7 (on this dbyte), then Register Dq7LnSel for this dbyte should be 3. RESET:0x7"
          
group.long  0x154++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_PPTCTLSTATIC, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_PPTCTLSTATIC_RFU_PPTCTLSTATIC ,None RESET:0x0"
          
group.long  0x156++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_PPTCTLDYN, This register is dynamically written by PHY Initialization Engine during frequency changes and should not be written by the user. RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_PPTCTLDYN_RFU_PPTCTLDYN ,None RESET:0x0"
          
rgroup.long 0x158++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_PPTINFO, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_PPTINFO_PPTINFO ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x15a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_PPTRXENEVNT, This register is dynamically written by PHY Initialization Engine during frequency changes and should not be written by the user. RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_PPTRXENEVNT_RFU_PPTRXENEVNT ,None RESET:0x0"
          
group.long  0x15c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_PPTDQSCNTINVTRNTG0_P0, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_PPTDQSCNTINVTRNTG0_P0_PPTDQSCNTINVTRNTG0_P0 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x15e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_PPTDQSCNTINVTRNTG1_P0, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_PPTDQSCNTINVTRNTG1_P0_PPTDQSCNTINVTRNTG1_P0 ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
          
group.long  0x162++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DTSMBLANKINGCTRL, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DTSMBLANKINGCTRL_RFU_DTSMBLANKINGCTRL ,None RESET:0x0"
          
group.long  0x164++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I0_RFU_TSM0_I0 ,None RESET:0x0"
          
rgroup.long 0x166++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I0_RFU_TSM1_I0 ,None RESET:0x0"
          
group.long  0x168++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I0_RFU_TSM2_I0 ,None RESET:0x0"
          
group.long  0x16a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM3_RFU_TSM3 ,None RESET:0x0"
          
group.long  0x16c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXCHKDATASELECTS, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXCHKDATASELECTS_RFU_TXCHKDATASELECTS ,None RESET:0x0"
          
rgroup.long 0x16e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DTSMUPTHLDXINGIND, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DTSMUPTHLDXINGIND_DTSMUPTHLDXINGIND ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x170++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DTSMLOTHLDXINGIND, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DTSMLOTHLDXINGIND_DTSMLOTHLDXINGIND ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x172++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DBYTEALLDTSMCTRL0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DBYTEALLDTSMCTRL0_RFU_DBYTEALLDTSMCTRL0 ,None RESET:0x0"
          
group.long  0x174++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DBYTEALLDTSMCTRL1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DBYTEALLDTSMCTRL1_RFU_DBYTEALLDTSMCTRL1 ,None RESET:0x0"
          
group.long  0x176++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DBYTEALLDTSMCTRL2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DBYTEALLDTSMCTRL2_RFU_DBYTEALLDTSMCTRL2 ,None RESET:0x0"
          
group.long  0x180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R0_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R0_P0_TXDQDLYTG0_R0_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R0_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R0_P0_TXDQDLYTG1_R0_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R0_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R0_P0_TXDQDLYTG2_R0_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R0_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R0_P0_TXDQDLYTG3_R0_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG0_U0_P0, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG0_U0_P0_TXDQSDLYTG0_U0_P0 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x1a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG1_U0_P0, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG1_U0_P0_TXDQSDLYTG1_U0_P0 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x1a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG2_U0_P0, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG2_U0_P0_TXDQSDLYTG2_U0_P0 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x1a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG3_U0_P0, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG3_U0_P0_TXDQSDLYTG3_U0_P0 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
rgroup.long 0x1c8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DXLCDLSTATUS, Status of dbyte macro LCDL selected by Register LcdlStatusSel  Note, this register is per dbyte. RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DXLCDLSTATUS_DXLCDLFINESNAPVAL ,Value of the LCDL 1UI estimate code, latched by pulse on csr LcdlFineSnap while csr LcdlTstEnable=1. Index 9 is reserved for growth. RESET:0x0"
          
         bitfld.long 0x00 10. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DXLCDLSTATUS_DXLCDLPHDSNAPVAL ,Value of the LCDL phase-detector output, latched by pulse on csr LcdlFineSnap. while csr LcdlTstEnable=1. RESET:0x0"
          
         bitfld.long 0x00 11. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DXLCDLSTATUS_DXLCDLSTICKYLOCK ,Latched value of whether the LCDL ever achieved lock after the assertion of LcdlTstEnable. RESET:0x0"
          
         bitfld.long 0x00 12. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DXLCDLSTATUS_DXLCDLSTICKYUNLOCK ,Latched value of whether the LCDL ever lost lock after the assertion of LcdlTstEnable. RESET:0x0"
          
         bitfld.long 0x00 13. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DXLCDLSTATUS_DXLCDLLIVELOCK ,Present value of whether the LCDL is locked. Valid when LcdlTstEnable=1. RESET:0x0"
          
group.long  0x260++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R1, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R1_VREFDAC1_R1 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0x264++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R1_RFU_TRAININGCNTR_R1 ,None RESET:0x0"
          
group.long  0x280++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R1, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R1_VREFDAC0_R1 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0x282++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL0_B1_P0, - Tx DQ driver impedance when equalization is enabled per nibble. - Register Block Offset Address 0x041 controls the lower DQ nibble - Register Block Offset Address 0x141 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL0_B1_P0_DRVSTRENDQP ,Refer to Technology specific PHY DATABOOK for supported options. The 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStren120P[2:0], Csr_DrvStren240P[1:0],Csr_DrvStren480P[0:0]] = [csrDrvStrenDqP]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL0_B1_P0_DRVSTRENDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStren120N[2:0],Csr_DrvStren240N[1:0],Csr_DrvStren480N[0:0]] = [csrDrvStrenDqN]  Note:See table of csr DrvStrenDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x286++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL_B1_P0, Connected to the rxdqs and rxdq Mode selects and trim controls, per nibble.  - Register Block Offset Address 0x043 controls the lower DQ nibble  - Register Block Offset Address 0x143 controls the upper DQ nibble This DFE feature may be used with MajorModeDbyte=011 only. RESET:0x5b0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL_B1_P0_SELANALOGVREF ,Setting this signal high will force the local per-bit VREF generator to pass the global VREFA to the samplers. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL_B1_P0_EXTVREFRANGE ,Extends the range available in the local per-bit VREF generator. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL_B1_P0_DFECTRL ,This field is programmable as follows  - 00 - DFE off  - 01 - DFE on  - 10 - Train DFE0 Amplifier  - 11 - Train DFE1 Amplifier These settings are determined by PHY Training FW and should not be overridden. RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL_B1_P0_MAJORMODEDBYTE ,Selects the major mode of operation for the receiver. These settings are determined by PHY Configuration based on DRAM protocol  - 000 - Input signal is terminated/referenced to VDDQ/2 (or unterminated)  - 001 - reserved  - 010 - Input signal is terminated/referenced to VSSQ  - 011 - Input signal is terminated/referenced to VDDQ  - 100 - reserved  - 101 - reserved  - 110 - reserved  - 111 - reserved RESET:0x3"
          
         hexmask.long 0x00 7.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_DQDQSRCVCNTRL_B1_P0_GAINCURRADJ ,Adjust gain current of RX amplifier stage. It is recommended to use default values for this CSR. RESET:0xb"
          
          
group.long  0x292++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL1_B1_P0, Tx impedance of DQ driver cells when equalization is disabled. - Register Block Offset Address 0x049 controls the lower DQ nibble - Register Block Offset Address 0x149 controls the upper DQ nibble RESET:0xfff"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL1_B1_P0_DRVSTRENFSDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenFS120P[2:0], Csr_DrvStrenFS240P[1:0], Csr_DrvStrenFS480P[0]] = [csrFSDrvStrenDq]  - 000000 - HiZ.  - 000001 - 480.0  - 000010 - 240.0  - 000011 - 160.0  - 001000 - 120.0  - 001001 - 96.0  - 001010 - 80.0  - 001011 - 68.6  - 011000 - 60.0  - 011001 - 53.3  - 011010 - 48.0  - 011011 - 43.6  - 111000 - 40.0  - 111001 - 36.9  - 111010 - 34.3  - 111011 - 32.0  - 111110 - 30.0  - 111111 - 28.2 RESET:0x3f"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL1_B1_P0_DRVSTRENFSDQN ,Refer to Technology specific PHY DATABOOK for supported options. This 6-bit bus is used to select the target pull-down output impedance. Connects to the DrvStren pins of the driver thus:  [Csr_DrvStrenFS120N[2:0], Csr_DrvStrenFS240N[1:0], Csr_DrvStrenFS480N[0:0]] = [csrDrvStrenDqN]  Note: See table of csr DrvStrenFSDqP for list of possible impedances. RESET:0x3f"
          
group.long  0x296++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL2_B1_P0, Tx DQ driver opposition impedance when equalization is enabled. - Register Block Offset Address 0x04b controls the lower DQ nibble - Register Block Offset Address 0x14b controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL2_B1_P0_DRVSTRENEQHIDQP ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-up output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQHi120P[2:0], Csr_DrvStrenEQHi240P[1:0], Csr_DrvStrenEQHi480P[0]] = [csrDrvStrenEQHiDq] RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXIMPEDANCECTRL2_B1_P0_DRVSTRENEQLODQN ,Refer to Technology specific PHY DATABOOK for supported options This 6-bit bus is used to select the target pull-down output impedance used in equalization. Connects to the DrvStren pins of the driver thus:  - [Csr_DrvStrenEQLo120N[2:0], Csr_DrvStrenEQLo240N[1:0], Csr_DrvStrenEQLo480P[0]] = [csrDrvStrenEQLoDq] RESET:0x0"
          
group.long  0x29a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXODTDRVSTREN_B1_P0, Selects desired impedance value for Host ODT. Must be set by user before PHY initialization. Setting for each protocol: DDR3:  - OdtStrenP - non-zero value  - OdtStrenN - same as OdtStrenP LPDDR3:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance DDR4:  - OdtStrenP - non-zero value  - OdtStrenN - high-impedance LPDDR4:  - OdtStrenP - high-impedance  - OdtStrenN - non-zero value  - Register Block Offset Address 0x04d controls the lower DQ nibble  - Register Block Offset Address 0x14d controls the upper DQ nibble RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXODTDRVSTREN_B1_P0_ODTSTRENP ,Selects the ODT pull-up impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120P[2:0], ODTStren240P[1:0],ODTStren480P[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
         hexmask.long 0x00 6.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXODTDRVSTREN_B1_P0_ODTSTRENN ,Selects the ODT pull-down impedance.  Refer to Technology specific PHY DATABOOK for supported options  - [ODTStren120N[2:0], ODTStren240N[1:0],ODTStren480N[0:0]]  - 000_00_0 = High Impedance  - 000_00_1 = 480 ohms  - 000_01_0 = 240 ohms  - 000_01_1 = 160 ohms  - 001_00_0 = 120 ohms  - 001_00_1 = 96.0 ohms  - 001_01_0 = 80.0 ohms  - 001_01_1 = 68.6 ohms  - 011_00_0 = 60.0 ohms  - 011_00_1 = 53.3 ohms  - 011_01_0 = 48.0 ohms  - 011_01_1 = 43.6 ohms  - 111_00_0 = 40.0 ohms  - 111_00_1 = 36.9 ohms  - 111_01_0 = 34.3 ohms  - 111_01_1 = 32.0 ohms  - 111_11_0 = 30.0 ohms  - 111_11_1 = 28.2 ohms RESET:0x0"
          
group.long  0x2be++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXSLEWRATE_B1_P0, Controls slew rates of the DQ/DQS drivers per nibble. - Tx predriver cal trims driver timing to account for clock duty cycle variation. - Register Block Offset Address 0x05f is the TxSlewRate for the lower nibble. - Register Block Offset Address 0x15f is the TxSlewRate for the upper nibble. RESET:0x7ff"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXSLEWRATE_B1_P0_TXPREP ,This is the 4-bit binary trim for the driver pull-up slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXSLEWRATE_B1_P0_TXPREN ,4 bit binary trim for the driver pull-down slew rate. 4'b0000 has a slower slew rate than 4'b1111 RESET:0xf"
          
         hexmask.long 0x00 8.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXSLEWRATE_B1_P0_TXPREDRVMODE ,Controls predrivers to adjust timing of turn-on and turn-off of pull-up and pull-down segments. Recommended settings:  - DDR3 = 3'b011.  - DDR4 = 3'b010.  - LPDDR3 = 3'b010.  - LPDDR4 = 3'b001 RESET:0x7"
          
group.long  0x2c4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R1_TRAININGINCDECDTSMEN_R1 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x2d0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R1, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R1_RXPBDLYTG0_R1 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0x2d2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R1, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R1_RXPBDLYTG1_R1 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0x2d4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R1, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R1_RXPBDLYTG2_R1 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0x2d6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R1, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R1_RXPBDLYTG3_R1 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0x300++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG0_U1_P0, Trained Receive Enable Delay. (For Timing Group 0) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG0_U1_P0_RXENDLYTG0_U1_P0 ,Trained Receive Enable Delay. (For Timing Group 0) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg0[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg0[5] is reserved.  - Register Block Offset Address 0x080 controls the lower DQ nibble DqsEn. (For Timing Group 0)  - Register Block Offset Address 0x180 controls the upper DQ nibble DqsEn. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x302++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG1_U1_P0, Trained Receive Enable Delay. (For Timing Group 1) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG1_U1_P0_RXENDLYTG1_U1_P0 ,Trained Receive Enable Delay. (For Timing Group 1) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg1[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg1[5] is reserved.  - Register Block Offset Address 0x081 controls the lower DQ nibble DqsEn. (For Timing Group 1)  - Register Block Offset Address 0x181 controls the upper DQ nibble DqsEn. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x304++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG2_U1_P0, Trained Receive Enable Delay. (For Timing Group 2) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG2_U1_P0_RXENDLYTG2_U1_P0 ,Trained Receive Enable Delay. (For Timing Group 2) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg2[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg2[5] is reserved.  - Register Block Offset Address 0x082 controls the lower DQ nibble DqsEn. (For Timing Group 2)  - Register Block Offset Address 0x182 controls the upper DQ nibble DqsEn. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x306++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG3_U1_P0, Trained Receive Enable Delay. (For Timing Group 3) RESET:0x100"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXENDLYTG3_U1_P0_RXENDLYTG3_U1_P0 ,Trained Receive Enable Delay. (For Timing Group 3) Trained to set the delay from the memory-read command to the signal enabling the read DQS to generate read-data strobes. The trained read DQS enable asserts during the read DQS preamble and deasserts at the end of the read burst.  - RxEnDlyTg3[10:6] is the coarse delay, ie one unit of delay is 1 UI.  - RxEnDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxEnDlyTg3[5] is reserved.  - Register Block Offset Address 0x083 controls the lower DQ nibble DqsEn. (For Timing Group 3)  - Register Block Offset Address 0x183 controls the upper DQ nibble DqsEn. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x318++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG0_U1_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG0_U1_P0_RXCLKDLYTG0_U1_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08c controls the lower DQ nibble RxClk timing. (For Timing Group 0)  - Register Block Offset Address 0x18c controls the upper DQ nibble RxClk timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x31a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG1_U1_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG1_U1_P0_RXCLKDLYTG1_U1_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08d controls the lower DQ nibble RxClk timing. (For Timing Group 1)  - Register Block Offset Address 0x18d controls the upper DQ nibble RxClk timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x31c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG2_U1_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG2_U1_P0_RXCLKDLYTG2_U1_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08e controls the lower DQ nibble RxClk timing. (For Timing Group 2)  - Register Block Offset Address 0x18e controls the upper DQ nibble RxClk timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x31e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG3_U1_P0, Trained Read DQS to RxClk Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKDLYTG3_U1_P0_RXCLKDLYTG3_U1_P0 ,Trained Read DQS to RxClk Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS.  - RxClk Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x08f controls the lower DQ nibble RxClk timing. (For Timing Group 3)  - Register Block Offset Address 0x18f controls the upper DQ nibble RxClk timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x320++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG0_U1_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG0_U1_P0_RXCLKCDLYTG0_U1_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=0). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 0)  - RxClkcDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg0[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x090 controls the lower DQ nibble RxClkc timing. (For Timing Group 0)  - Register Block Offset Address 0x190 controls the upper DQ nibble RxClkc timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x322++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG1_U1_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG1_U1_P0_RXCLKCDLYTG1_U1_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=1). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 1)  - RxClkcDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg1[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x091 controls the lower DQ nibble RxClkc timing. (For Timing Group 1)  - Register Block Offset Address 0x191 controls the upper DQ nibble RxClkc timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x324++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG2_U1_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG2_U1_P0_RXCLKCDLYTG2_U1_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=2). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 2)  - RxClkcDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg2[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x092 controls the lower DQ nibble RxClkc timing. (For Timing Group 2)  - Register Block Offset Address 0x192 controls the upper DQ nibble RxClkc timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x326++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG3_U1_P0, Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). RESET:0x10"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXCLKCDLYTG3_U1_P0_RXCLKCDLYTG3_U1_P0 ,Trained Read DQS_c to RxClkc Delay (Timing Group DEST=3). Trained to generate read DQ receive clock from the received read DQS_c.  - RxClkc Delay (6 bits, fine delay only); (For Timing Group 3)  - RxClkcDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - RxClkcDlyTg3[5] is reserved. There is no coarse delay field, ie the max configurable delay is 31/32 UI.  - Register Block Offset Address 0x093 controls the lower DQ nibble RxClkc timing. (For Timing Group 3)  - Register Block Offset Address 0x193 controls the upper DQ nibble RxClkc timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x364++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I1_RFU_TSM0_I1 ,None RESET:0x0"
          
rgroup.long 0x366++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I1_RFU_TSM1_I1 ,None RESET:0x0"
          
group.long  0x368++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I1, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I1_RFU_TSM2_I1 ,None RESET:0x0"
          
group.long  0x380++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R1_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R1_P0_TXDQDLYTG0_R1_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x382++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R1_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R1_P0_TXDQDLYTG1_R1_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x384++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R1_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R1_P0_TXDQDLYTG2_R1_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x386++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R1_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R1_P0_TXDQDLYTG3_R1_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x3a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG0_U1_P0, Write DQS Delay (Timing Group DEST=0). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG0_U1_P0_TXDQSDLYTG0_U1_P0 ,Write DQS Delay (Timing Group DEST=0). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 0)  - TxDqsDlyTg0[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg0[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg0[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D0 controls the lower DQ nibble write DQS timing. (For Timing Group 0)  - Register Block Offset Address 0x1D0 controls the upper DQ nibble write DQS timing. (For Timing Group 0)  Note: Timing Group 0 = RANK0. RESET:0x100"
          
group.long  0x3a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG1_U1_P0, Write DQS Delay (Timing Group DEST=1). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG1_U1_P0_TXDQSDLYTG1_U1_P0 ,Write DQS Delay (Timing Group DEST=1). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 1)  - TxDqsDlyTg1[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg1[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg1[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D1 controls the lower DQ nibble write DQS timing. (For Timing Group 1)  - Register Block Offset Address 0x1D1 controls the upper DQ nibble write DQS timing. (For Timing Group 1)  Note: Timing Group 1 = RANK1. RESET:0x100"
          
group.long  0x3a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG2_U1_P0, Write DQS Delay (Timing Group DEST=2). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG2_U1_P0_TXDQSDLYTG2_U1_P0 ,Write DQS Delay (Timing Group DEST=2). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 2)  - TxDqsDlyTg2[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg2[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg2[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D2 controls the lower DQ nibble write DQS timing. (For Timing Group 2)  - Register Block Offset Address 0x1D2 controls the upper DQ nibble write DQS timing. (For Timing Group 2)  Note: Timing Group 2 = RANK2. RESET:0x100"
          
group.long  0x3a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG3_U1_P0, Write DQS Delay (Timing Group DEST=3). RESET:0x100"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQSDLYTG3_U1_P0_TXDQSDLYTG3_U1_P0 ,Write DQS Delay (Timing Group DEST=3). Trained to set the delay from the memory-write command to the signal driving the write DQS  - Tx DQS Delay ( 10 bits, includes coarse and fine delays); (For Timing Group 3)  - TxDqsDlyTg3[9:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqsDlyTg3[4:0] is the fine delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqsDlyTg3[5] is reserved. Note: This register is per nibble, per timing-group, per pstate.  - Register Block Offset Address 0x0D3 controls the lower DQ nibble write DQS timing. (For Timing Group 3)  - Register Block Offset Address 0x1D3 controls the upper DQ nibble write DQS timing. (For Timing Group 3)  Note: Timing Group 3 = RANK3. RESET:0x100"
          
group.long  0x460++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R2, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R2_VREFDAC1_R2 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0x464++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R2_RFU_TRAININGCNTR_R2 ,None RESET:0x0"
          
group.long  0x480++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R2, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R2_VREFDAC0_R2 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0x4c4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R2_TRAININGINCDECDTSMEN_R2 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x4d0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R2, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R2_RXPBDLYTG0_R2 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0x4d2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R2, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R2_RXPBDLYTG1_R2 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0x4d4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R2, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R2_RXPBDLYTG2_R2 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0x4d6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R2, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R2_RXPBDLYTG3_R2 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0x564++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I2_RFU_TSM0_I2 ,None RESET:0x0"
          
rgroup.long 0x566++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I2_RFU_TSM1_I2 ,None RESET:0x0"
          
group.long  0x568++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I2, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I2_RFU_TSM2_I2 ,None RESET:0x0"
          
group.long  0x580++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R2_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R2_P0_TXDQDLYTG0_R2_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x582++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R2_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R2_P0_TXDQDLYTG1_R2_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x584++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R2_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R2_P0_TXDQDLYTG2_R2_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x586++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R2_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R2_P0_TXDQDLYTG3_R2_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x660++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R3, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R3_VREFDAC1_R3 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0x664++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R3_RFU_TRAININGCNTR_R3 ,None RESET:0x0"
          
group.long  0x680++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R3, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R3_VREFDAC0_R3 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0x6c4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R3_TRAININGINCDECDTSMEN_R3 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x6d0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R3, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R3_RXPBDLYTG0_R3 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0x6d2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R3, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R3_RXPBDLYTG1_R3 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0x6d4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R3, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R3_RXPBDLYTG2_R3 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0x6d6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R3, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R3_RXPBDLYTG3_R3 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0x764++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I3_RFU_TSM0_I3 ,None RESET:0x0"
          
rgroup.long 0x766++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I3_RFU_TSM1_I3 ,None RESET:0x0"
          
group.long  0x768++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I3, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I3_RFU_TSM2_I3 ,None RESET:0x0"
          
group.long  0x780++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R3_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R3_P0_TXDQDLYTG0_R3_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x782++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R3_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R3_P0_TXDQDLYTG1_R3_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x784++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R3_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R3_P0_TXDQDLYTG2_R3_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x786++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R3_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R3_P0_TXDQDLYTG3_R3_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x860++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R4, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R4_VREFDAC1_R4 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0x864++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R4_RFU_TRAININGCNTR_R4 ,None RESET:0x0"
          
group.long  0x880++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R4, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R4_VREFDAC0_R4 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0x8c4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R4_TRAININGINCDECDTSMEN_R4 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x8d0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R4, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R4_RXPBDLYTG0_R4 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0x8d2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R4, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R4_RXPBDLYTG1_R4 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0x8d4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R4, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R4_RXPBDLYTG2_R4 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0x8d6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R4, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R4_RXPBDLYTG3_R4 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0x964++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I4, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I4_RFU_TSM0_I4 ,None RESET:0x0"
          
rgroup.long 0x966++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I4_RFU_TSM1_I4 ,None RESET:0x0"
          
group.long  0x968++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I4, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I4_RFU_TSM2_I4 ,None RESET:0x0"
          
group.long  0x980++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R4_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R4_P0_TXDQDLYTG0_R4_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x982++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R4_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R4_P0_TXDQDLYTG1_R4_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x984++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R4_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R4_P0_TXDQDLYTG2_R4_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x986++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R4_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R4_P0_TXDQDLYTG3_R4_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xa60++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R5, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R5_VREFDAC1_R5 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0xa64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R5_RFU_TRAININGCNTR_R5 ,None RESET:0x0"
          
group.long  0xa80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R5, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R5_VREFDAC0_R5 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0xac4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R5_TRAININGINCDECDTSMEN_R5 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xad0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R5, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R5_RXPBDLYTG0_R5 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0xad2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R5, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R5_RXPBDLYTG1_R5 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0xad4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R5, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R5_RXPBDLYTG2_R5 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0xad6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R5, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R5_RXPBDLYTG3_R5 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0xb64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I5, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I5_RFU_TSM0_I5 ,None RESET:0x0"
          
rgroup.long 0xb66++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I5_RFU_TSM1_I5 ,None RESET:0x0"
          
group.long  0xb68++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I5, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I5_RFU_TSM2_I5 ,None RESET:0x0"
          
group.long  0xb80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R5_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R5_P0_TXDQDLYTG0_R5_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xb82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R5_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R5_P0_TXDQDLYTG1_R5_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xb84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R5_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R5_P0_TXDQDLYTG2_R5_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xb86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R5_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R5_P0_TXDQDLYTG3_R5_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xc60++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R6, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R6_VREFDAC1_R6 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0xc64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R6_RFU_TRAININGCNTR_R6 ,None RESET:0x0"
          
group.long  0xc80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R6, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R6_VREFDAC0_R6 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0xcc4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R6_TRAININGINCDECDTSMEN_R6 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xcd0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R6, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R6_RXPBDLYTG0_R6 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0xcd2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R6, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R6_RXPBDLYTG1_R6 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0xcd4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R6, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R6_RXPBDLYTG2_R6 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0xcd6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R6, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R6_RXPBDLYTG3_R6 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0xd64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I6, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I6_RFU_TSM0_I6 ,None RESET:0x0"
          
rgroup.long 0xd66++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I6_RFU_TSM1_I6 ,None RESET:0x0"
          
group.long  0xd68++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I6, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I6_RFU_TSM2_I6 ,None RESET:0x0"
          
group.long  0xd80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R6_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R6_P0_TXDQDLYTG0_R6_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xd82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R6_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R6_P0_TXDQDLYTG1_R6_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xd84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R6_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R6_P0_TXDQDLYTG2_R6_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xd86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R6_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R6_P0_TXDQDLYTG3_R6_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0xe60++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R7, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R7_VREFDAC1_R7 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0xe64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R7_RFU_TRAININGCNTR_R7 ,None RESET:0x0"
          
group.long  0xe80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R7, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R7_VREFDAC0_R7 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0xec4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R7_TRAININGINCDECDTSMEN_R7 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xed0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R7, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R7_RXPBDLYTG0_R7 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0xed2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R7, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R7_RXPBDLYTG1_R7 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0xed4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R7, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R7_RXPBDLYTG2_R7 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0xed6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R7, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R7_RXPBDLYTG3_R7 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0xf64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I7, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I7_RFU_TSM0_I7 ,None RESET:0x0"
          
rgroup.long 0xf66++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I7_RFU_TSM1_I7 ,None RESET:0x0"
          
group.long  0xf68++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I7, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I7_RFU_TSM2_I7 ,None RESET:0x0"
          
group.long  0xf80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R7_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R7_P0_TXDQDLYTG0_R7_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0xf82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R7_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R7_P0_TXDQDLYTG1_R7_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0xf84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R7_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R7_P0_TXDQDLYTG2_R7_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0xf86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R7_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R7_P0_TXDQDLYTG3_R7_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
group.long  0x1060++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R8, VrefDAC1 control for DQ Receiver (used only when DFE is enabled in DDR4) RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC1_R8_VREFDAC1_R8 ,VrefDAC1 controls the alternate VREF setting for DFE (used only when DFE is enabled in DDR4) DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC1[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC1[6:0]*0.00385)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x030 is the VrefDAC1 for lane0.  - Register Block Offset Address 0x130 is the VrefDAC1 for lane1.  - Register Block Offset Address 0x230 is the VrefDAC1 for lane2.  - Register Block Offset Address 0x330 is the VrefDAC1 for lane3.  - Register Block Offset Address 0x430 is the VrefDAC1 for lane4.  - Register Block Offset Address 0x530 is the VrefDAC1 for lane5.  - Register Block Offset Address 0x630 is the VrefDAC1 for lane6.  - Register Block Offset Address 0x730 is the VrefDAC1 for lane7.  - Register Block Offset Address 0x830 is the VrefDAC1 for lane[DBI]. RESET:0x0"
          
group.long  0x1064++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGCNTR_R8_RFU_TRAININGCNTR_R8 ,None RESET:0x0"
          
group.long  0x1080++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R8, VrefDAC0 control for DQ Receiver RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_VREFDAC0_R8_VREFDAC0_R8 ,PHY RX VREF DAC control for rxdq cell internal VREF, (used only when 2D training is enabled in LPDDR4,DDR4 DAC control for rxdq cell internal VREF, trained by Firmware. The VREF generators have different ranges, depending on the Mission Mode settings for  - [DqDqsRcvCntrl::MajorModeDbyte,DqDqsRcvCntrl::ExtVrefRange]  - [000,0] :: VREF = VDDQ*(0.287 + VrefDAC0[6:0]*0.00330)  - [000,1] :: VREF = VDDQ*(0.250 + VrefDAC0[6:0]*0.00385)  - [011,0] :: VREF = VDDQ*(0.510 + VrefDAC0[6:0]*0.00345)  - [011,1] :: VREF = VDDQ*(0.453 + VrefDAC0[6:0]*0.00385)  - [010,0] :: VREF = VDDQ*(0.047 + VrefDAC0[6:0]*0.00367)  - [non-enumerated encodings are reserved]  - Register Block Offset Address 0x040 is the VrefDAC0 for lane0.  - Register Block Offset Address 0x140 is the VrefDAC0 for lane1.  - Register Block Offset Address 0x240 is the VrefDAC0 for lane2.  - Register Block Offset Address 0x340 is the VrefDAC0 for lane3.  - Register Block Offset Address 0x440 is the VrefDAC0 for lane4.  - Register Block Offset Address 0x540 is the VrefDAC0 for lane5.  - Register Block Offset Address 0x640 is the VrefDAC0 for lane6.  - Register Block Offset Address 0x740 is the VrefDAC0 for lane7.  - Register Block Offset Address 0x840 is the VrefDAC0 for lane[DBI]. RESET:0x0"
          
group.long  0x10c4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TRAININGINCDECDTSMEN_R8_TRAININGINCDECDTSMEN_R8 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x10d0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R8, Read DQ per-bit BDL delay (Timing Group 0). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG0_R8_RXPBDLYTG0_R8 ,Read DQ per-bit BDL delay (Timing Group 0). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x068 controls the lane0 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x168 controls the lane1 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x268 controls the lane2 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x368 controls the lane3 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x468 controls the lane4 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x568 controls the lane5 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x668 controls the lane6 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x768 controls the lane7 read deskew timing. (For Timing Group 0)  - Register Block Offset Address 0x868 controls the lane[DBI] read deskew timing. (For Timing Group 0)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 0 = RANK0. RESET:0x0"
          
group.long  0x10d2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R8, Read DQ per-bit BDL delay (Timing Group 1). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG1_R8_RXPBDLYTG1_R8 ,Read DQ per-bit BDL delay (Timing Group 1). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x069 controls the lane0 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x169 controls the lane1 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x269 controls the lane2 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x369 controls the lane3 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x469 controls the lane4 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x569 controls the lane5 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x669 controls the lane6 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x769 controls the lane7 read deskew timing. (For Timing Group 1)  - Register Block Offset Address 0x869 controls the lane[DBI] read deskew timing. (For Timing Group 1)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 1 = RANK1. RESET:0x0"
          
group.long  0x10d4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R8, Read DQ per-bit BDL delay (Timing Group 2). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG2_R8_RXPBDLYTG2_R8 ,Read DQ per-bit BDL delay (Timing Group 2). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06a controls the lane0 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x16a controls the lane1 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x26a controls the lane2 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x36a controls the lane3 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x46a controls the lane4 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x56a controls the lane5 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x66a controls the lane6 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x76a controls the lane7 read deskew timing. (For Timing Group 2)  - Register Block Offset Address 0x86a controls the lane[DBI] read deskew timing. (For Timing Group 2)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 2 = RANK2. RESET:0x0"
          
group.long  0x10d6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R8, Read DQ per-bit BDL delay (Timing Group 3). RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_RXPBDLYTG3_R8_RXPBDLYTG3_R8 ,Read DQ per-bit BDL delay (Timing Group 3). Trained to deskew the read DQ data that will be sampled by the incoming per-nibble read DQS, to improve the composite eye.  Bits 5-0 convey the BDL delay value. Bit 6 is Reserved.  The unit of change is a LSB in the control of the delay circuit, and is not denoninated in units of UI.  - Register Block Offset Address 0x06b controls the lane0 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x16b controls the lane1 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x26b controls the lane2 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x36b controls the lane3 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x46b controls the lane4 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x56b controls the lane5 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x66b controls the lane6 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x76b controls the lane7 read deskew timing. (For Timing Group 3)  - Register Block Offset Address 0x86b controls the lane[DBI] read deskew timing. (For Timing Group 3)  Note: This register is not per-pstate. The same deskew (for channel-routing differences) is used for all pstates.  Note: Timing Group 3 = RANK3. RESET:0x0"
          
group.long  0x1164++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I8, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM0_I8_RFU_TSM0_I8 ,None RESET:0x0"
          
rgroup.long 0x1166++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM1_I8_RFU_TSM1_I8 ,None RESET:0x0"
          
group.long  0x1168++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I8, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TSM2_I8_RFU_TSM2_I8 ,None RESET:0x0"
          
group.long  0x1180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R8_P0, Write DQ Delay (Timing Group 0). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG0_R8_P0_TXDQDLYTG0_R8_P0 ,Write DQ Delay (Timing Group 0). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 0)  - TxDqDlyTg0[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg0[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg0[5] is reserved.  - Register Block Offset Address 0x0C0 controls the lane0 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x1C0 controls the lane1 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x2C0 controls the lane2 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x3C0 controls the lane3 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x4C0 controls the lane4 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x5C0 controls the lane5 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x6C0 controls the lane6 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x7C0 controls the lane7 write DQ timing. (For Timing Group 0)  - Register Block Offset Address 0x8C0 controls the lane[DMDBI] write DQ timing. (For Timing Group 0) Note: These Registers are replicated per pstate.  Note: Timing Group 0 = RANK0. RESET:0x10"
          
group.long  0x1182++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R8_P0, Write DQ Delay (Timing Group 1). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG1_R8_P0_TXDQDLYTG1_R8_P0 ,Write DQ Delay (Timing Group 1). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 1)  - TxDqDlyTg1[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg1[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg1[5] is reserved.  - Register Block Offset Address 0x0C1 controls the lane0 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x1C1 controls the lane1 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x2C1 controls the lane2 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x3C1 controls the lane3 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x4C1 controls the lane4 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x5C1 controls the lane5 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x6C1 controls the lane6 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x7C1 controls the lane7 write DQ timing. (For Timing Group 1)  - Register Block Offset Address 0x8C1 controls the lane[DMDBI] write DQ timing. (For Timing Group 1) Note: These Registers are replicated per pstate.  Note: Timing Group 1 = RANK1. RESET:0x10"
          
group.long  0x1184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R8_P0, Write DQ Delay (Timing Group 2). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG2_R8_P0_TXDQDLYTG2_R8_P0 ,Write DQ Delay (Timing Group 2). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 2)  - TxDqDlyTg2[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg2[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg2[5] is reserved.  - Register Block Offset Address 0x0C2 controls the lane0 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x1C2 controls the lane1 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x2C2 controls the lane2 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x3C2 controls the lane3 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x4C2 controls the lane4 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x5C2 controls the lane5 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x6C2 controls the lane6 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x7C2 controls the lane7 write DQ timing. (For Timing Group 2)  - Register Block Offset Address 0x8C2 controls the lane[DMDBI] write DQ timing. (For Timing Group 2) Note: These Registers are replicated per pstate.  Note: Timing Group 2 = RANK2. RESET:0x10"
          
group.long  0x1186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R8_P0, Write DQ Delay (Timing Group 3). RESET:0x10"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_DBYTE1_P0_TXDQDLYTG3_R8_P0_TXDQDLYTG3_R8_P0 ,Write DQ Delay (Timing Group 3). Trained to center the delay between the write DQ to the write DQS.  - Tx DQ Delay ( 9 bits, includes 3b coarse and 6b fine delays); (For Timing Group 3)  - TxDqDlyTg3[8:6] is the coarse delay, ie one unit of delay is 1 UI.  - TxDqDlyTg3[4:0] is the fine (fractional UI) delay, ie one unit of delay is one-thirtysecond of a UI = UI/32.  - TxDqDlyTg3[5] is reserved.  - Register Block Offset Address 0x0C3 controls the lane0 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x1C3 controls the lane1 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x2C3 controls the lane2 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x3C3 controls the lane3 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x4C3 controls the lane4 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x5C3 controls the lane5 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x6C3 controls the lane6 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x7C3 controls the lane7 write DQ timing. (For Timing Group 3)  - Register Block Offset Address 0x8C3 controls the lane[DMDBI] write DQ timing. (For Timing Group 3) Note: These Registers are replicated per pstate.  Note: Timing Group 3 = RANK3. RESET:0x10"
          
tree.end
    

tree "LPDDR4_PUB__DWC_DDRPHYA_MASTER0_P0"
base e:0x42040000
width 80.
group.long  0x0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_RXFIFOINIT, This Register enables overrides of the PHY RXDATAFIFO pointers. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_RXFIFOINIT_RXFIFOINITPTR ,Setting this bit will reset the PHY RXDATAFIFO read and write pointers. This bit must be Cleared to return to normal operation. This is not required in normal operation, but can be used instead of a dfi_ctrlupdate (for controllers that don't support ctrlupdate) RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_RXFIFOINIT_INHIBITRXFIFORD ,This field is reserved for training FW use. Setting this inhibits reads of the PHYRXDATAFIFO. RESET:0x0"
          
group.long  0x2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_FORCECLKDISABLE, Clock gating control RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_FORCECLKDISABLE_FORCECLKDISABLE ,This CSR forces the gating of MEMCLKs driven from the PHY - ForceClkDisable[0] - controls CLK_[H/L]0 - ForceClkDisable[1] - controls CLK_[H/L]1 (if present) - ForceClkDisable[2] - controls CLK_[H/L]2 (if present) - ForceClkDisable[3] - controls CLK_[H/L]3 (if present) RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CLOCKINGCTRL, This register is dynamically written by PHY Initialization Engine during frequency changes and should not be written by the user. RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CLOCKINGCTRL_RFU_CLOCKINGCTRL ,None RESET:0x0"
          
group.long  0x6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_FORCEINTERNALUPDATE, This Register used by Training Firmware to force an internal PHY Update Event. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_FORCEINTERNALUPDATE_FORCEINTERNALUPDATE ,This Register is used by Training Firmware to force an internal PHY Update Event. Optionally can be used by System Software to issue a PHY update Event. The register may be written to 1'b1 only when all of the following are true:  - The DFI interface is offline.  - The Training Hardware is sending only DES and all transactions have retired. Additionally, this Register must stay asserted for at least 32 DFICLKs before clearing. Prematurely clearing this register may result in an incomplete update. RESET:0x0"
          
rgroup.long 0x8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYCONFIG, Displays PHY Configuration RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYCONFIG_PHYCONFIGANIBS ,Returns the following value depending on the chosen define: - 0x3 if DWC_DDRPHY_NUM_ANIBS_3 - 0x6 if DWC_DDRPHY_NUM_ANIBS_6 - 0x8 if DWC_DDRPHY_NUM_ANIBS_8 - 0xA if DWC_DDRPHY_NUM_ANIBS_10 - 0xC if DWC_DDRPHY_NUM_ANIBS_12 RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYCONFIG_PHYCONFIGDBYTES ,Returns the following value depending on the chosen define: - 0x1 if DWC_DDRPHY_NUM_DBYTES_1 - 0x2 if DWC_DDRPHY_NUM_DBYTES_2 - 0x3 if DWC_DDRPHY_NUM_DBYTES_3 - 0x4 if DWC_DDRPHY_NUM_DBYTES_4 - 0x5 if DWC_DDRPHY_NUM_DBYTES_5 - 0x6 if DWC_DDRPHY_NUM_DBYTES_6 - 0x7 if DWC_DDRPHY_NUM_DBYTES_7 - 0x8 if DWC_DDRPHY_NUM_DBYTES_8 - 0x9 if DWC_DDRPHY_NUM_DBYTES_9 - 0xA if DWC_DDRPHY_NUM_DBYTES_10 RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYCONFIG_PHYCONFIGDFI ,Returns the following value depending on the define: - 0x1 if DWC_DDRPHY_DFI1_EXISTS is not defined - 0x2 if DWC_DDRPHY_DFI1_EXISTS is defined RESET:0x0"
          
group.long  0xa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PGCR, PHY General Configuration Register(PGCR) RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PGCR_RXCLKRISEFALLMODE ,This register field controls independent training for RxClk_c and RxClk_t.  - 0: Independent training for RxClk_c and RxClk_t is disabled.  - 1: Independent training for RxClk_c and RxClk_t is enabled. Default Value is 0. RESET:0x0"
          
group.long  0xe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TESTBUMPCNTRL1, Control for Test Bumps RESET:0xb03"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TESTBUMPCNTRL1_TESTMAJORMODE ,Selects the major mode of operation for the receiver. These modes are mutually exclusive. - 000 - reserved - 001 - reserved - 010 - reserved - 011 - setting for DDR4 systems to receive Alert_n - 100 - reserved for debug - 101 - reserved - 110 - reserved - 111 - reserved for debug RESET:0x3"
          
         bitfld.long 0x00 3. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TESTBUMPCNTRL1_TESTBIASBYPASSEN ,Do not use, for debug only RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TESTBUMPCNTRL1_TESTANALOGOUTCTRL ,Reserved and returns zero on reads. RESET:0x0"
          
         hexmask.long 0x00 8.--12. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TESTBUMPCNTRL1_TESTGAINCURRADJ ,Adjust gain and current of analog observe RX amplifier stage at analog test point. Recommended mission mode default = 5'b01011 RESET:0xb"
          
         bitfld.long 0x00 13. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TESTBUMPCNTRL1_TESTSELEXTERNALVREF ,Do not use, for debug only RESET:0x0"
          
         bitfld.long 0x00 14. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TESTBUMPCNTRL1_TESTEXTVREFRANGE ,Setting this bit will extend the VREF DAC range for debug. MUST BE SET TO ZERO in mission mode when MemAlert is enabled RESET:0x0"
          
         bitfld.long 0x00 15. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TESTBUMPCNTRL1_TESTPOWERGATEEN ,Do not use, for debug only RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALUCLKINFO_P0, Informs the impedance calibration engine about frequency of DfiClk RESET:0x320"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALUCLKINFO_P0_CALUCLKTICKSPER1US ,Must be programmed to the number of DfiClks in 1us (rounded up), with minimum value of 24. - if (DfiClk < 24MHz) CalUclkInfo = 24 - else CalUclkInfo = (number of DfiClks in 1us) RESET:0x320"
          
group.long  0x14++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TESTBUMPCNTRL, Control for Test Bumps RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TESTBUMPCNTRL_TESTBUMPEN ,Field TestBumpEn[1:0] controls the output function of the signal BP_ALERT_N.  TestBumpEn Value on [BP_ALERT_N] | output  - 2'b00 high-z,  - 2'b01 Pllout-divided-by-2, works up to full data rate  - 2'b10 PllDigTst[1], works up to 400MHz  - 2'b11 PllDigTst[1], works up to 400MHz RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TESTBUMPCNTRL_TESTBUMPTOGGLE ,This field controls the output function of the signal. Digital Observation Pin, if available in the configuration of the PHY.  - When set to 1'b0 -- the output will be tristated  - When set to 1'b1 -- the output will be selected by MtestMuxSel RESET:0x0"
          
         hexmask.long 0x00 3.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TESTBUMPCNTRL_TESTBUMPDATASEL ,RVSD. RESET:0x0"
          
         bitfld.long 0x00 9. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TESTBUMPCNTRL_FORCEMTESTONALERT ,When set, causes the Digital Observation output pin to be driven onto BP_ALERT_N RESET:0x0"
          
group.long  0x16++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_SEQ0BDLY0_P0, PHY Initialization Engine (PIE) Delay Register 0 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_SEQ0BDLY0_P0_SEQ0BDLY0_P0 ,PHY Initialization Engine (PIE) Delay Register 0. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_SEQ0BDLY1_P0, PHY Initialization Engine (PIE) Delay Register 1 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_SEQ0BDLY1_P0_SEQ0BDLY1_P0 ,PHY Initialization Engine (PIE) Delay Register 1. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x1a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_SEQ0BDLY2_P0, PHY Initialization Engine (PIE) Delay Register 2 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_SEQ0BDLY2_P0_SEQ0BDLY2_P0 ,PHY Initialization Engine (PIE) Delay Register 2. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_SEQ0BDLY3_P0, PHY Initialization Engine (PIE) Delay Register 3 RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_SEQ0BDLY3_P0_SEQ0BDLY3_P0 ,PHY Initialization Engine (PIE) Delay Register 3. This register is available for selection by the NOP and WAIT instructions in the PIE for the delay value. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes.  Programming Seq0BDLY[3,2,1,0] Registers:  - These registers are used to control various delays during PLL, DLL initialization.  - These registers should be programmed with the corresponding number of MEMCLK cycles representing a fixed amount of delay irrespective of DfiClk Frequency.  - When calculating the number of cycles to be programmed for each PState, it should be noted that the sequencer multiplies programmed values by a factor of 8 and values are round down to the closest integer.  Register | Required Delay | Programmed Value   - Seq0BDLY0 | 0.5us | ( 0.5us / MEMCLK period) / 8)  - Seq0BDLY1 | 1.0us | ( 1.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | (10.0us / MEMCLK period) / 8)  - Seq0BDLY2 | 10.0us | 64/4 if (MEMCLK Freq <= 400MHz)  - Seq0BDLY3 | - | 132/4 if (400MHz Freq < MEMCLK Freq <= 533MHz)  - Seq0BDLY3 | - | 176/4 if (MEMCLK Freq > 533MHz) RESET:0x0"
          
rgroup.long 0x1e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYALERTSTATUS, This Read Only CSR represents the status of the ALERT_N pin to the PHY RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYALERTSTATUS_PHYALERT ,Current state of ALERT_N. RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PPTTRAINSETUP_P0, For LPDDR3/4 some tracking is required periodically using the DFI PHY MASTER interface. This register control the interval. Setting the register to 0 completely disables the PHY Master Interface. Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PPTTRAINSETUP_P0_PHYMSTRTRAININTERVAL ,Bits 3:0 of this register specifies the time between the end of one training and the start of the next. Note that, to account for the delay to receive the acknowledge from the MC, the dfi_phymstr_req signal is asserted in advance so that the effective update (after acknowledge from the MC) occurs inside the interval defined by PhyMstrTrainInterval.  - 4'b0000 Disable PHY Master Interface  - 4'b0001 PHY MASTER Request Interval = 524288 MEMCLKs  - 4'b0010 PHY MASTER Request Interval = 1048576 MEMCLKs  - 4'b0011 PHY MASTER Request Interval = 2097152 MEMCLKs  - 4'b0100 PHY MASTER Request Interval = 4194304 MEMCLKs  - 4'b0101 PHY MASTER Request Interval = 8388608 MEMCLKs  - 4'b0110 PHY MASTER Request Interval = 16777216 MEMCLKs  - 4'b0111 PHY MASTER Request Interval = 33554432 MEMCLKs  - 4'b1000 PHY MASTER Request Interval = 67108864 MEMCLKs  - 4'b1001 PHY MASTER Request Interval = 134217728 MEMCLKs  - 4'b1010 PHY MASTER Request Interval = 268435456 MEMCLKs  - 4'b1011 - 4'b1111 PHY MASTER Request Interval = undefined RESET:0x0"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PPTTRAINSETUP_P0_PHYMSTRMAXREQTOACK ,The value in bits 6:4 of this register specify the max time from tdfi_phymstr_req asserted to tdfi_phymstr_ack asserted. If the request is not acknowledged by this time, dfi_error will be asserted.  - 3'b000 Disable PHY Master Interface  - 3'b001 set tPHYMSTR_resp. = 512 MEMCLKs  - 3'b010 set tPHYMSTR_resp. = 1024 MEMCLKs  - 3'b011 set tPHYMSTR_resp. = 2048 MEMCLKs  - 3'b100 set tPHYMSTR_resp. = 4096 MEMCLKs  - 3'b101 set tPHYMSTR_resp. = 8192 MEMCLKs  - 3'b110 set tPHYMSTR_resp. = 32768 MEMCLKs  - 3'b111 set tPHYMSTR_resp. = undefined  Note: The above are nominal values. The actual values are reduced by (2 + (DWC_DDRPHY_PIPE_DFI_MISC * MEMCLK/DfiCtlClk)) * 2  Note: This signal interacts with dfi_phyupd_req. See Section Collisions Between PHY Update and DFI LP of the PUB Databook. RESET:0x0"
          
group.long  0x22++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PPTTRAINSETUP2_P0, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x2"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PPTTRAINSETUP2_P0_RFU_PPTTRAINSETUP2_P0 ,None RESET:0x2"
          
group.long  0x24++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ATESTMODE, Controls for Address Command Loopback. This CSR is written by ATE firmware. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ATESTMODE_ATESTPRBSEN ,Enables loopback PRBS7 testing of all the. DDR output pins in this chiplet. The asserting edge resets all the individual. TestPrbsErrCnt & consequently TestPrbsErr; there is no other reset for the TestPrbsErrCnt. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ATESTMODE_ATESTCLKEN ,Obsolete. Unused. RESET:0x0"
          
         hexmask.long 0x00 2.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ATESTMODE_ATESTMODESEL ,Master Mode select for ATest (Loopback) - 000 - Mission mode, all ATest disabled, loopback receivers powered down - 001 - External Loopback mode [Single data rate pattern - dfi_cas sent to all lanes] - 010 - Internal Loopback mode [Single data rate pattern] - 011 - Internal Loopback mode [Double data rate pattern] - 100 - External Loopback mode [Single data rate pattern - corresponding DFI signal sent to each lane] RESET:0x0"
          
rgroup.long 0x28++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TXCALBINP, TX P Impedance Calibration observation RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TXCALBINP_TXCALBINP ,This csr holds the binary result of the 31 bit thermometer pull-up code. RESET:0x0"
          
rgroup.long 0x2a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TXCALBINN, TX N Impedance Calibration observation RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TXCALBINN_TXCALBINN ,This csr holds the binary result of the 31 bit thermometer pull-down code. RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TXCALPOVR, Override values for Register TxCalBinP. RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TXCALPOVR_TXCALBINPOVRVAL ,The binary value which can override the Register TxCalBinP calibrator results if Register TxCalBinPOvrEn is set. RESET:0x0"
          
         bitfld.long 0x00 5. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TXCALPOVR_TXCALBINPOVREN ,This field is programmable as follows: - 1: use the override value present in Register TxCalBinPOvrVal - 0: don't. RESET:0x0"
          
group.long  0x2e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TXCALNOVR, Override values for Register TxCalBinN. RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TXCALNOVR_TXCALBINNOVRVAL ,The binary value which can override the Register TxCalBinN calibrator results if Register TxCalBinPOvrEn is set. RESET:0x0"
          
         bitfld.long 0x00 5. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TXCALNOVR_TXCALBINNOVREN ,This field is programmable as follows: - 1: use the override value present in Register TxCalBinNOvrVal - 0: don't. RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIMODE, Each bit enables the Phy Update, Phy Master Update, and low power logic for the respective interfaces. There are 3 valid configurations:  - 'b101: DFI0 is enabled and controls the entire PHY  - 'b001: DFI0 controls 1/2 the PHY, external logic ties off inputs to DFI1  - 'b011: DFI0 and DFI1 are active and are separately controlled. This field interacts with the DWC_DDRPHY_DFI1_EXISTS define as follows:  - DfiMode=001, DWC_DDRPHY_DFI1_EXISTS defined: ANIBs/DBYTEs assigned to DFI1 are idle  - DfiMode=011, DWC_DDRPHY_DFI1_EXISTS defined: DFI0 controls 1/2 PHY (CH. A), DFI1 controls 1/2 PHY (CH. B)  - DfiMode=101, DWC_DDRPHY_DFI1_EXISTS defined: ANIBs/DBYTEs assigned to DFI1 are controlled by DFI0. Only DFI0 sideband signals are active.  - DfiMode=001, DWC_DDRPHY_DFI1_EXISTS undefined: DFI0 controls entire PHY  - DfiMode=011, DWC_DDRPHY_DFI1_EXISTS undefined: illegal  - DfiMode=101, DWC_DDRPHY_DFI1_EXISTS undefined: not applicable RESET:0x5"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIMODE_DFI0ENABLE ,Enables operation for the PHY logic associated with DFI0 RESET:0x1"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIMODE_DFI1ENABLE ,Enables operation for the PHY logic associated with DFI1 RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIMODE_DFI1OVERRIDE ,DFI0 is used to control the PHY logic associated with both DFI0 and DFI1 RESET:0x1"
          
group.long  0x32++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TRISTATEMODECA_P0, This register is used to control the PHY Dynamic Address/Command Tristate Feature, and the stopped MEMCLK state. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TRISTATEMODECA_P0_DISDYNADRTRI ,When DisDynAdrTri=1, Dynamic Tristating is disabled. Dynamic Tristating is on by default. Dynamic Tristating should be disabled (DisDynAdrTri=1) for these modes:  - DR3/2T if the controller cannot follow the 2T PHY tristate protocol.  - DDR4/2T/2N if the controller cannot follow the 2T PHY tristate protocol.  - LPDDR4 When DisDynAdrTri=0 (default),  - In DDR4 mode, The following SDRAM pins can be dynamically tristated: A,BA,BG,ACT_n  - In LPDDR3 mode, The following SDRAM pins can be dynamically tristated: CA[*]  - In 1T mode, the PHY will tristate the relevant pins when all ranks are DESelected  - In 2T mode (or geardown), the PHY will tristate the relevant pins when:  -- DDR3 -- All ranks DESelected (all CS_L==1) AND [RAS_n,CAS_n,WE_n,BA0] = [1,1,1,0]  -- DDR4 -- All ranks DESelected (all CS_L==1) AND [RAS_n,CAS_n,WE_n,BA0,ACT_n] = [1,1,1,0,1]  - When in this mode, the controller should avoid sending the above patterns with any rank selected. [e.g. NOPs sent by the controller should have BA0 set to a non-zero value] RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TRISTATEMODECA_P0_DDR2TMODE ,Must be set to 1 for Dynamic Tristate to work when CA bus is 2T or Geardown mode. This CSR bit has no effect when DisDynAdrTri==1 RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TRISTATEMODECA_P0_CKDISVAL ,The PHY provides 4 memory clocks, n=0..3.  - When the toggling of memory clock CK_t[n] is disabled with dfi_clk_disable[n]=1, the memory clock CK_t[n] is driven with Register CkDisVal[1].  - When the toggling of memory clock CK_c[n] is disabled with dfi_clk_disable[n]=1, the memory clock CK_c[n] is driven with ~(Register CkDisVal[0]) (ie inverted).  Note that the non-toggling differential memory clock [CK_t[n],CK_c[n]] may be driven with any combination, LL,LH,HL,HH; the default [CK_t[n],CK_c[n]]=LH. RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MTESTMUXSEL, Digital Observation Pin control RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MTESTMUXSEL_MTESTMUXSEL ,Controls for the 64-1 mux for asynchronous data to the Digital Observation Pin.  - 6'h0 --> Drive 0 from this chiplet (allows flat 'OR' of pass-through information)  - 6'h01:1f --> Select local data from AC/DBYTE/MASTER macro  - 6'h20 --> Reserved (Drive 0 from macro into mux; Drive 0 from PUB synth logic path into mux)  - 6'h21:3f --> Select local data from PUB AC/DBYTE/MASTER synthesized logic Note: See PUB documentation for how, or if, the Digital Observation Pin is mapped to a physical bump in this configuration. RESET:0x0"
          
group.long  0x36++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MTESTPGMINFO, Digital Observation Pin program info for debug RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MTESTPGMINFO_MTESTPGMINFO ,The value of this csr may be driven onto the Digital Observation Pin. It has no other hardware effect. RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DYNPWRDNUP, Note : This CSR is written by PHY Initialization Engine (PIE) and the data in here will be overwritten. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DYNPWRDNUP_DYNPOWERDOWN ,This field is programmable as follows: - 1: analog circuitry (voltage dacs, bias gen) is turned off. - 0: normal operation. RESET:0x0"
          
group.long  0x3a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PMIENABLE, This register is dynamically written by PHY Initialization Engine during frequency changes and should not be written by the user. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PMIENABLE_PMIENABLE ,This register is dynamically written by PHY Initialization Engine during frequency changes and should not be written by the user. RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYTID, PHY Technology ID Register RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYTID_PHYTID ,This register is a placeholder to store technology-specific information RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTMRL_P0, HWT MaxReadLatency. RESET:0x6"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTMRL_P0_HWTMRL_P0 ,This MASTER copy of MRL is used by the PHY training firmware only. RESET:0x6"
          
group.long  0x42++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIPHYUPD, This Register is used to determine the DFI Update request interval and the maximum update response time.  Note: DFIPHYUPDCNT and DFIPHYUPDRESP must be chosen such that DFIPHYUPDCNT > DFIPHYUPDRESP RESET:0xff07"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIPHYUPD_DFIPHYUPDCNT ,This controls the interval between the end of a phyupdate transaction and a subsequent request.  - 4'b0000 - Disable timer-based Phy Update when DFIPHYUPDMODE==1'b0  - 4'b0001 - 16K MEMCLKs minus nMEMCLKs_phyupd_resp  - 4'b0011 - 32K MEMCLKs minus nMEMCLKs_phyupd_resp  - 4'b0111 - 64K MEMCLKs minus nMEMCLKs_phyupd_resp  - 4'b1111 - 128K MEMCLKs minus nMEMCLKs_phyupd_resp Any code not enumerated above is RSVD and should not be set. RESET:0x7"
          
         hexmask.long 0x00 4.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIPHYUPD_DFIPHYUPDRESP ,Enforces the t_phyupd_resp time, the maximum time that is allowed to controller to respond to the request for a PHY update. A dfi_error will be signaled if there is no acknowledgement of the update request within nMEMCLKs_phyupd_resp.  - 3'b000: nMEMCLKs_phyupd_resp= 1024 MEMCLKs, default value  - 3'b001: nMEMCLKs_phyupd_resp= 2048 MEMCLKs  - 3'b010: nMEMCLKs_phyupd_resp= 4096 MEMCLKs  - 3'b011: nMEMCLKs_phyupd_resp= 8192 MEMCLKs, [not allowed in LPDDR3, LPDDR4 modes] Note: The above are nominal values. The actual values are reduced by (2 + (DWC_DDRPHY_PIPE_DFI_MISC * MEMCLK/DfiCtlClk)) * 2  Note: Any code not enumerated above is RSVD and should not be set.  Note: This signal interacts with dfi_phymstr_req. See Section Collisions Between PHY Update and DFI LP of the PUB Databook. RESET:0x0"
          
         bitfld.long 0x00 7. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIPHYUPD_DFIPHYUPDMODE ,This field is programmable as follows: - 1'b0: [Recommended/Default] deterministic timer-based Phy Update Requests; enables multi-channel/multi-phy lockstep operation. - 1'b1: Reserved RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIPHYUPD_DFIPHYUPDTHRESHOLD ,Reserved RESET:0xf"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIPHYUPD_DFIPHYUPDINTTHRESHOLD ,Reserved RESET:0xf"
          
group.long  0x44++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PDAMRSWRITEMODE, Controls the write DQ generation for Per-Dram-Addressing of MRS RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PDAMRSWRITEMODE_PDAMRSWRITEMODE ,Controls the write DQ generation per the timing requirements on the DQ signals used for Per-Dram-Addressing mode of MRS commands. When asserted, the DQ are driven for an additional UI before the logical burst and for an additional UI after the logical burst. The early UI has the value of first logical UI, and the late UI has the value of the last logical UI. The timing of the logical burst is unchanged; no modification to csr TxDqDly is required or performed. Strongly recommended to be cleared after completing the MRS that clears MR3 A4 and for mission-mode writes, else required bubbles will be larger and the power consumed will be greater. See JEDEC MR3 A4, Per DRAM Addresssability. RESET:0x0"
          
group.long  0x46++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIGEARDOWNCTL, Controls whether dfi_geardown_en will cause CS and CKE timing to change. RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIGEARDOWNCTL_DFIGEARDOWNCTL ,DFIGEARDOWNCTL[0] controls whether dfi_geardown_en will cause chip-select (CS) timing to change.  - 0 - CS timing will not be dynamically modified wtih dfi_geardown_en  - 1 - CS will be delayed by an additional 1UI dynamically when dfi_geardown_en==1  Note, this CSR must be set to zero if the PHY is not in DDR4 Mode. DFIGEARDOWNCTL[1] controls whether dfi_geardown_en will cause clock-enable (CKE) timing to change.  - 0 - CKE timing will not be dynamically modified with dfi_geardown_en  - 1 - CKE will be delayed by an additional 1UI dynamically when dfi_geardown_en==1  Note, this CSR must be set to zero if the PHY is not in DDR4 Mode RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DQSPREAMBLECONTROL_P0, For improved robustness in operating with DRAM timing drift, this register provides controls for the width of the write DQS preamble and postamble, and controls for the anticipated width of DQS preamble for reads. RESET:0x8"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DQSPREAMBLECONTROL_P0_TWOTCKRXDQSPRE ,Widens the RxDqsEn window to allow larger drift in the incoming read DQS to take advantage of the larger/wider preamble generated by the DRAMSs when the D4 DRAMS are configured with DDR4 MR4 A11 Read Preamble=1 for causing a 2nCK read preamble. For LPDDR4, set to 1 for static read preamble, set to 0 for toggling read preamble.  Note the nominal trained-to-center point will be earlier relative to the first strobing edge of DQS than when not in this mode. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DQSPREAMBLECONTROL_P0_TWOTCKTXDQSPRE ,For LPDDR4, all write operations are 2nCK such that this control must be set to 1. RESET:0x0"
          
         hexmask.long 0x00 2.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DQSPREAMBLECONTROL_P0_POSITIONDFEINIT ,For DDR4 phy only when receive DFE is enabled.  - PositionDfeInit[2] is reserved  - PositionDfeInit[1]=1 causes DfeInit to be asserted at the nominal time  - PositionDfeInit[0] is reserved PositionDfeInit=3'b010 is the nominal, recommended value for leading edge used by receiver, other values are reserved. RESET:0x2"
          
         bitfld.long 0x00 5. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DQSPREAMBLECONTROL_P0_LP4TGLTWOTCKTXDQSPRE ,Used in LPDDR4 mode to modify the early preamble when Register TwoTckTxDqsPre=1 - 0: level first-memclk preamble - 1: toggling first-memclk preamble RESET:0x0"
          
         bitfld.long 0x00 6. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DQSPREAMBLECONTROL_P0_LP4POSTAMBLEEXT ,In LPDDR4 mode must be set to extend the write postamble. - 0: half-memclk postamble, as in D4 - 1: one-and-one-half-memclk postamble; see LPDDR4 Spec MR3, OP[1] WR PST, vendor-specific function. RESET:0x0"
          
         bitfld.long 0x00 7. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DQSPREAMBLECONTROL_P0_LP4STTCPREBRIDGERXEN ,Used in LPDDR4 static-preamble mode to bridge the RxEn between two reads to the same timing group when the bubble is 1 memclk. LPDDR4 static-preamble mode is set in the DRAMs with MR1, OP[3]=0. RESET:0x0"
          
         bitfld.long 0x00 8. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DQSPREAMBLECONTROL_P0_WDQSEXTENSION ,When set, DQS_T and DQS_C will be driven differentially to 0 and 1, respectively, before and after a write burst, except during a memory read transaction. See DesignWare Cores LPDDR4 MultiPHY: WDQS Extension Application Note. Use of WDQSEXTENSION requires POdtTailWidth=3 and POdtStartDelay=00 RESET:0x0"
          
group.long  0x4a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MASTERX4CONFIG, DBYTE module controls to select X4 Dram device mode RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MASTERX4CONFIG_X4TG ,Set to 1 if this Timing Group/Rank is x4 (as opposed to x8) memory.  - XXX[1|0] : TxReqDest/RxReqDest 0 X4/X8.  - XX[1|0]X : TxReqDest/RxReqDest 1 X4/X8.  - X[1|0]XX : TxReqDest/RxReqDest 2 X4/X8.  - [1|0]XXX : TxReqDest/RxReqDest 3 X4/X8.  This CSR must be written before dfi_init_start is asserted. RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_WRLEVBITS, Write level feedback DQ observability selection RESET:0x98"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_WRLEVBITS_WRLEVFORDQSL ,Indicates which DQ bit is used for Write Levelization. - 0000 - use DQ0 -  .. - 0111 - use DQ7 - 1000 - use |DQ[3:0] - 1001 - use |DQ[7:4] - 1010 - use |DQ[7:0] RESET:0x8"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_WRLEVBITS_WRLEVFORDQSU ,Indicates which DQ bit is used for Write Levelization. - 0000 - use DQ0 -  .. - 0111 - use DQ7 - 1000 - use |DQ[3:0] - 1001 - use |DQ[7:4] - 1010 - use |DQ[7:0] RESET:0x9"
          
group.long  0x4e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ENABLECSMULTICAST, In DDR4 Mode , this controls whether CS_N[3:2] should be multicast on CID[1:0] RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ENABLECSMULTICAST_ENABLECSMULTICAST ,In DDR4 Mode , this controls whether CS_N[3:2] should be multicast on CID[1:0] - 0 - Do not override pins corresponding to cid[1:0] (dfi_cid[1:0] will connect to the pads) - 1 - Override pins corresponding to cid[1:0] with dfi_cs[3:2]. (cs[3:2] will be multicast on cs[3:2] and cid[1:0]) RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTLPCSMULTICAST, Reserved. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTLPCSMULTICAST_HWTLPCSMULTICAST ,Reserved. RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ACX4ANIBDIS, Disable for unused ACX Nibbles RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ACX4ANIBDIS_ACX4ANIBDIS ,When a bit is set, the corresponding ACX nibble is disabled (specifically, the I/O OE is disabled, as is the Dfi-side FIFO clock RESET:0x0"
          
group.long  0x5a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DMIPINPRESENT_P0, This Register is used to instruct the PHY whether to enable the Read-DBI function on Lane8 of each DBYTE. Only the LPDDR4 and DDR4 Protocols support the Read-DBI feature. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DMIPINPRESENT_P0_RDDBIENABLED ,This bit must be set to 1'b1 if Read-DBI is enabled in a connected DDR4 or LPDDR4 device. If set, the following DRAM MR should also be set [DDR4.MR5.A12=1 or LPDDR4.MR3.OP[7]=1] RESET:0x0"
          
group.long  0x5c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ARDPTRINITVAL_P0, Address/Command FIFO ReadPointer Initial Value RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ARDPTRINITVAL_P0_ARDPTRINITVAL_P0 ,This is the initial Pointer Offset for the free-running FIFOs in the DBYTE and ACX4 hardips. The units of this register are in UI. The pointer separation should be chosen to compensate for all sources of skew and drift of the PHY DFICLK and PCLK networks. See 'ARdPtrInitVal Impacts From Construction Skews' of the PUB databook. This CSR must be programmed in Step C of the PHY Initialization sequence RESET:0x0"
          
rgroup.long 0x60++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB0LCDLCALPHDETOUT, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB0LCDLCALPHDETOUT_DB0LCDLCALPHDETOUT ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x62++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB1LCDLCALPHDETOUT, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB1LCDLCALPHDETOUT_DB1LCDLCALPHDETOUT ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB2LCDLCALPHDETOUT, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB2LCDLCALPHDETOUT_DB2LCDLCALPHDETOUT ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x66++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB3LCDLCALPHDETOUT, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB3LCDLCALPHDETOUT_DB3LCDLCALPHDETOUT ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x68++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB4LCDLCALPHDETOUT, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB4LCDLCALPHDETOUT_DB4LCDLCALPHDETOUT ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x6a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB5LCDLCALPHDETOUT, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB5LCDLCALPHDETOUT_DB5LCDLCALPHDETOUT ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x6c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB6LCDLCALPHDETOUT, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB6LCDLCALPHDETOUT_DB6LCDLCALPHDETOUT ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x6e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB7LCDLCALPHDETOUT, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB7LCDLCALPHDETOUT_DB7LCDLCALPHDETOUT ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x70++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB8LCDLCALPHDETOUT, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB8LCDLCALPHDETOUT_DB8LCDLCALPHDETOUT ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x72++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB9LCDLCALPHDETOUT, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DB9LCDLCALPHDETOUT_DB9LCDLCALPHDETOUT ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x74++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DBYTEDLLMODECNTRL, DLL Mode control Register in DBYTE modules RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DBYTEDLLMODECNTRL_DLLRXPREAMBLEMODE ,Must be set to 1 if read DQS preamble contains a toggle, for example DDR4 or LPDDR4 read toggling preamble mode. In LPDDR4, the PHY Initialization Engine will always set this bit field to 0x1 for correct operation of the retraining algorithm. RESET:0x0"
          
group.long  0x76++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DBYTERXENTRAIN, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DBYTERXENTRAIN_RFU_DBYTERXENTRAIN ,None RESET:0x0"
          
rgroup.long 0x7e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ANLCDLCALPHDETOUT, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ANLCDLCALPHDETOUT_ANLCDLCALPHDETOUT ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x8a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALOFFSETS, A safety register that can be used to correct systematic offsets from each calibration stage. It is not recommended to change these values from the default zero value. RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALOFFSETS_CALCMPR5OFFSET ,This value adjusts the offset-compensated DAC code for the cmpana circuit at VRef == 0.5 * VDDQ. RESET:0x0"
          
         hexmask.long 0x00 6.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALOFFSETS_CALDRVPDTHOFFSET ,This value adjusts the driver pull-down calibration code RESET:0x0"
          
         hexmask.long 0x00 10.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALOFFSETS_CALDRVPUTHOFFSET ,This value adjusts the driver pull-up calibration code RESET:0x0"
          
group.long  0x8e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_SARINITVALS, This register specifies the initial value for the compensation engine. It is not recommended to change the default value. RESET:0x127"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_SARINITVALS_SARINITOFFSET05 ,Specify the SAR starting value for OFFSET05 calibration. This is an 8 bit wide target. RESET:0x7"
          
         hexmask.long 0x00 3.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_SARINITVALS_SARINITNINT ,Specify the SAR starting value for NINT calibration. This is a 5 bit wide target. RESET:0x4"
          
         hexmask.long 0x00 6.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_SARINITVALS_SARINITPEXT ,Specify the SAR starting value for PEXT calibration. This is a 5 bit wide target. RESET:0x4"
          
group.long  0x92++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALPEXTOVR, Impedance Calibration PExt Override control RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALPEXTOVR_CALPEXTOVR ,If the CSR CalPExtDis is set then the value provided here by software will be used instead of the automatically generated value which is visible via CSR CalPExt. This CSR may only be written when the calibrator is not running. RESET:0x0"
          
group.long  0x94++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALCMPR5OVR, Impedance Calibration Cmpr 50 control RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALCMPR5OVR_CALCMPR5OVR ,If the CSR CalCmpr5Dis is set then the value provided here by software will be used instead of the automatically generated value which is visible via CSR CalCmpr5. This CSR may only be written when the calibrator is not running. RESET:0x0"
          
group.long  0x96++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALNINTOVR, Impedance Calibration NInt Override control RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALNINTOVR_CALNINTOVR ,If the CSR CalNIntDis is set then the value provided here by software will be used instead of the automatically generated value which is visible via CSR CalNInt. This CSR may only be written when the calibrator is not running. RESET:0x0"
          
group.long  0xa0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALDRVSTR0, For a given calibration target these CSRs specify the drive strength(s) to be used. There is no encoding.  Note: The strength selected should match the external resistor value used for calibration. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALDRVSTR0_CALDRVSTRPD50 ,This field is programmable as follows: - 3..15 = Reserved for future. - 2 - 40.0R - 1 - 120.0R - 0 - 240.0R (Default) RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALDRVSTR0_CALDRVSTRPU50 ,This field is programmable as follows: - 3..15 = Reserved for future. - 2 - 40.0R - 1 - 120.0R - 0 - 240.0R (Default) RESET:0x0"
          
group.long  0xaa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PROCODTCTL, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PROCODTCTL_RFU_PROCODTCTL ,None RESET:0x0"
          
group.long  0xac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PROCODTTIMECTL_P0, Controls timing of ProcOdt for DQ and DQS termination during reads. The enabling and disabling of ProcOdt can be shifted with a granularity of 1UI.  If WDQSEXTENSION is enabled, this register should be set to 0x03. Otherwise, use the recommended settings based on MEMCLK frequency and TwoTckRxDqsPre. This will ensure that ProcOdt is enabled before the DQS preamble begins and is not disabled until after the DQS postamble ends.  Recommended configuration if Register TwoTckRxDqsPre==1:  - 0000MHz < memclk-freq <= 0933 ; Register POdtStartDelay= 2 ; Register POdtTailWidth=2  - 0933MHz < memclk-freq <= 1200 ; Register POdtStartDelay= 0 ; Register POdtTailWidth=2  - 1200MHz < memclk-freq <= NA ; Register POdtStartDelay= 0 ; Register POdtTailWidth=3  Recommended configuration if TwoTckRxDqsPre==0:  - 0000MHz < memclk-freq <= 933 ; Register POdtStartDelay= 2 ; Register POdtTailWidth=2  - 0933MHz < memclk-freq <= 1200 ; Register POdtStartDelay= 1 ; Register POdtTailWidth=2  - 1200MHz < memclk-freq <= NA ; Register POdtStartDelay= 1 ; Register POdtTailWidth=3 See related CSR TxOdtDrvStren. RESET:0x1f"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PROCODTTIMECTL_P0_PODTTAILWIDTH ,controls the length of the tail of ProcOdt, units of UI - POdtTailWidth controls the time from closing the window to receive DQS to ProcODT deassertion, and can be set with values ranging from 0 to 3. - The aforementioned timing is defined as (3 + POdtTailWidth + POdtTailWidthExt - csrTwiTckDqsPre) UIs. - It is recommended to use this csr as the main timing configuration unit, with default value of 3. Note that this might not be the optimal value, since it is technology dependent. Refer to the PHY Databook for optimal settings. RESET:0x3"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PROCODTTIMECTL_P0_PODTSTARTDELAY ,controls the start of ProcOdt, units of UI  - 3 delay start 2 UI, maximum delay of start of ProcOdt  - 2 delay start 1 UI,  - 1 delay start 0 UI, default  - 0 early by 1 UI, The time from ProcODT assertion to opening the window to receive DQS is than (10 - POdtStartDelay) UI. It may be up to 4 pclk smaller if small 	  coarse delays are used (used only at the lowest clock frequencies) RESET:0x3"
          
         hexmask.long 0x00 4.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PROCODTTIMECTL_P0_PODTTAILWIDTHEXT ,controls the length of the tail of ProcOdt, units of UI - POdtTailWidthExt controls the time from closing the window to receive DQS to ProcODT deassertion, and can be set with values ranging from 0 to 3. - The aforementioned timing is defines as (3 + POdtTailWidth + POdtTailWidthExt - csrTwiTckDqsPre) UIs. - It is recommended to use this csr as an extension to POdtTailWidth, and has a default value of 1. Note that this might not be the optimal value, since it is technology dependent. Refer to the PHY Databook for optimal settings. RESET:0x1"
          
group.long  0xb6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MEMALERTCONTROL, Controls for the receiver for MemAlert (D4 Parity or WCRC Error) or, alternately, for ERR_n (D3 registered DIMM). RESET:0x4000"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MEMALERTCONTROL_MALERTVREFLEVEL ,Sets the vref level of internal VREF DAC assuming the following Mission mode settings:  [TestExtVrefRange,TestMajorMode] = [0011 or 0000)  The VREF level chosen by the receiver follows the equation::  VREF = VDDQ*(0.51 + MALERTVrefLevel[6:0]*0.00345)  The min/max values possible are:  - VREF_min = VDDQ*(0.51)  - VREF_max = VDDQ*(0.948) RESET:0x0"
          
         bitfld.long 0x00 7. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MEMALERTCONTROL_MALERTVREFEXTEN ,When set for test/debug, selects external Vref source. This should not be set in mission mode. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MEMALERTCONTROL_MALERTPUSTREN ,Controls the Pull-up termination on MALERT  - bit[8] - controls a 240 Ohm Pull-up leg  - bit[9] - controls a 240 Ohm Pull-up leg  - bit[10] - controls a 120 Ohm Pull-up leg  - bit[11] - controls a 120 Ohm Pull-up leg This field is programmable as follows:  - 0000 - No Pull-up Strength  - 0001 - 240 Ohm Pull-up Strength  - 0010 - 240 Ohm Pull-up Strength  - 0011 - 120 Ohm Pull-up Strength  - 0100 - 120 Ohm Pull-up Strength  - 0101 - 80 Ohm Pull-up Strength  - 0110 - 80 Ohm Pull-up Strength  - 0111 - 60 Ohm Pull-up Strength  - 1000 - 120 Ohm Pull-up Strength  - 1001 - 80 Ohm Pull-up Strength  - 1010 - 80 Ohm Pull-up Strength  - 1011 - 60 Ohm Pull-up Strength  - 1100 - 60 Ohm Pull-up Strength  - 1101 - 48 Ohm Pull-up Strength  - 1110 - 48 Ohm Pull-up Strength  - 1111 - 40 Ohm Pull-up Strength RESET:0x0"
          
         bitfld.long 0x00 12. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MEMALERTCONTROL_MALERTPUEN ,When set, enables the Pull-up termination on MALERT RESET:0x0"
          
         bitfld.long 0x00 13. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MEMALERTCONTROL_MALERTRXEN ,This field is programmable as follows: - 1 - Enables receiver and received data is forwarded to dfi_alert_n. - 0 - Disable the receiver and send MALERTDisableVal to dfi_alert_n RESET:0x0"
          
         bitfld.long 0x00 14. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MEMALERTCONTROL_MALERTDISABLEVAL ,When MALERTRxEn is not set, this CSR state is used to drive dfi_alert_n. RESET:0x1"
          
         bitfld.long 0x00 15. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MEMALERTCONTROL_MALERTFORCEERROR ,When MALERTForceError is set, this CSR state is used to force parity error to memory. RESET:0x0"
          
group.long  0xb8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MEMALERTCONTROL2, Controls for the MemAlert output (dfi_alert_n) The DFI interface defines that the signal dfi_alert_n as a synchronous output on DFICLK. For some memory systems, this signal is synchronized again elsewhere in the SOC, so the synchronizer in the PHY is useless (and simply adds to the latency of observing an ALERT transition. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MEMALERTCONTROL2_MALERTSYNCBYPASS ,This field is programmed as follows: - MALERTSyncBypass==[0], the phy will drive dfi_alert_n with a synchronized value of the ALERT_N receiver. - MALERTSyncBypass==[1], the phy will drive dfi_alert_n with the asynchronous value of the ALERT_N receiver. RESET:0x0"
          
group.long  0xc0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MEMRESETL, Control the MemResetL output of the PHY. Intended to be used to protect/force the BP_MemReset_L output. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MEMRESETL_MEMRESETLVALUE ,Control the MemResetL output of the PHY. The state of this field is transfered to the PHY BP_MemReset_L output when ProtectMemReset is set. BP_MemReset_L cannot reset LPDDR3. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MEMRESETL_PROTECTMEMRESET ,Control the MemResetL output of the PHY. The state of the MemResetL field is transfered to the PHY BP_MemReset_L output when ProtectMemReset is set. RESET:0x0"
          
group.long  0xdc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PUBMODE, Selects between HWT and DCT as the source of memory transactions. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PUBMODE_HWTMEMSRC ,When this is set to a 1, the mux that switches between DCT and HWT for the source of memory transactions is switched to HWT.  - Setting this bit relinquishes control to the HWT.  - Clearing this bit relinquishes control to the DCT. The transition can only be made when the. FIFOs are all in PtrInit (i.e. all PtrInit signals are high). RESET:0x0"
          
rgroup.long 0xde++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MISCPHYSTATUS, This Read Only CSR represent misc status of the PHY RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MISCPHYSTATUS_DCTSANE ,Returns the status of the custom circuit which protects the MemResetL output of the PHY on initial power-on or reset. This circuit resets to 0 meaning that hardware has control of the MemResetL output. If set to 1, memory RESET is being controlled by Registers MemResetLVaue and ProtectMemReset or dfi_reset_n. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MISCPHYSTATUS_PORMEMRESET ,Returns the active-high value used by the custom circuit which drives the memory RESET signal. To comply with JEDEC specifications for memory reset, this signal powers on 1'b1. This signal is reset during the PHY Initialization sequence. RESET:0x0"
          
group.long  0xe0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CORELOOPBACKSEL, Controls whether the loopback path bypasses the final PAD node. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CORELOOPBACKSEL_CORELOOPBACKSEL ,This register is controlled by the PHY test firmware This register enables Core-Side loopback operation of the PHY.  - When set, the PHY PAD node will be bypassed, and pre-pad node will be selected for sampling by the PHY RX.  - Setting this register enables full-speed loopback operation of the PHY regardless of the loading of the pad.  - This register must be set to 1'b0 for mission mode operation (or pad-side loopback). RESET:0x0"
          
group.long  0xe2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLLTRAINPARAM, DLL Training Parameters RESET:0x2"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLLTRAINPARAM_EXTENDPHDTIME ,Used by the PHY firmware locking the LCDL delay cells. The number of extra DfiClk periods (= 4*UI) for the DLL phase-detector outputs to become not-metastable RESET:0x2"
          
group.long  0xe4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTLPCSENA, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x3"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTLPCSENA_HWTLPCSENA ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x3"
          
group.long  0xe6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTLPCSENB, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x3"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTLPCSENB_HWTLPCSENB ,Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x3"
          
group.long  0xe8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTLPCSENBYPASS, CSn Disable Bypass for LPDDR3/4 RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTLPCSENBYPASS_HWTLPCSENBYPASS ,When set, these bits disable LpCsEn function for LPDDR3/4 RESET:0x0"
          
group.long  0xea++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFICAMODE, This CSR controls the PHY signal-to-bump-mapping mode.  - The default state is all bits 0.  - Setting bits fields to 1 changes the arch mode and are required to be 1-hot. While all fields of this csr are present in all products, some will not always be relevant as a particular dram type may not be supported. Irrelevant bits must be set to 0, always.  Programmed by dwc_ddrphy_phyinit_C_initPhyConfig() according to PHY configuration and DRAM type. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFICAMODE_DFILP3CAMODE ,Controls the output data-rate of the AC module Command/Address pins Enable LPDDR3 Mode  - 0: LPDDR3 Dual Data Rate address mode disabled  - 1: LPDDR3 Dual Data Rate address mode enabled RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFICAMODE_DFID4CAMODE ,Enable DDR4 Mode - 0: D4 mode disabled - 1: D4 mode enabled RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFICAMODE_DFILP4CAMODE ,Enable LP4 Mode - 0: LP4 mode disabled - 1: LP4 mode enabled RESET:0x0"
          
         bitfld.long 0x00 3. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFICAMODE_DFID4ALTCAMODE ,Enable DDR4-Alt Mode (only available in certain configurations) - 0: D4-Altmode disabled - 1: D4-Altmode enabled RESET:0x0"
          
group.long  0xec++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTCACTL, Reserved for PHY training firmware use. RESET:0x1"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTCACTL_RFU_HWTCACTL ,None RESET:0x1"
          
group.long  0xee++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTCAMODE, Programmed by PHY training firmware to support LPDDR3/LPDDR4 DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTCAMODE_RFU_HWTCAMODE ,None RESET:0x0"
          
group.long  0xf0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLLCONTROL, This CSR is written by PHY Initialization Engine (PIE) and the data in here will be overwritten. RESET:0x3"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLLCONTROL_DLLRESETRELOCK ,Used to reset the DDL/LCDL lock state machine. Deasserting starts locking sequence. This must be done anytime the DLLs are to be relocked (e.g. frequency change). RESET:0x1"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLLCONTROL_DLLRESETSLAVE ,Reserved. RESET:0x1"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLLCONTROL_DLLRESETRSVD ,RSVD for future use RESET:0x0"
          
group.long  0xf2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PULSEDLLUPDATEPHASE, This register is used only for test and for training. It is not used in PIE frequency change or power-state change. The CfgWE for this register causes a UpdatePhase, aka ClkPhase, for the DLL associated with the subfield enables.  - Writing a 1 to one of the PulseXDllUpdatePhase will cause a pulse, ie it will assert ClkPhase=1 then clear ClkPhase=0.  - There is no need to write a 0 after writing a 1 to one of the PulseXDllUpdatePhase.  - A written 1 will read back a 1, but that does not mean that ClkPhase to the corresponding DLL is being held high.  - Writing this CSR must be in a traffic bubble.  - Writing all-0s to this register is a nop for the DLLs. It will clear any readback values if they were set.  - This function requires Register AlwaysEnCfgClk=1. Example to update the active Phases of the DBYTE module DLLs (nop for AC module DLLs):  - io_write16(c0 | tMASTER | csr_CalAndPllConfig_ADDR, csr_AlwaysEnCfgClk_MASK);  - io_write16(cbrd | tANIB | csr_PulseDllUpdatePhase_ADDR, csr_PulseDbyteDllUpdatePhase_MASK);  - io_write16(cbrd | tANIB | csr_PulseDllUpdatePhase_ADDR, 0x0); RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PULSEDLLUPDATEPHASE_PULSEDBYTEDLLUPDATEPHASE ,Causes a LongBubble to the DBYTE modules, which causes a update of the DBYTE module DLLs (tx,rxen,rxclk). RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PULSEDLLUPDATEPHASE_PULSEACKDLLUPDATEPHASE ,Causes an AC module CK (memck) DLL phase update. This should be written with 1 only when the memory CKE=0 or memory RST=0, or when there is no memory, as in tester mode. RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PULSEDLLUPDATEPHASE_PULSEACADLLUPDATEPHASE ,Causes an AC module CA (command/address/cke/odt) DLL phase update. RESET:0x0"
          
         hexmask.long 0x00 3.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PULSEDLLUPDATEPHASE_UPDATEPHASEDESTRESERVED ,reserved, not used RESET:0x0"
          
         bitfld.long 0x00 6. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PULSEDLLUPDATEPHASE_TRAINUPDATEPHASEONLONGBUBBLE ,Causes LongBubble to update the dbyte & anib LDCL Phase. May be used for training, but not to be used for mission mode. RESET:0x0"
          
         bitfld.long 0x00 7. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PULSEDLLUPDATEPHASE_ALWAYSUPDATELCDLPHASE ,Causes each new operation to reload the LcdlPhase; will increase bubbles. RESET:0x0"
          
group.long  0xf4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTCONTROLOVR0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTCONTROLOVR0_RFU_HWTCONTROLOVR0 ,None RESET:0x0"
          
group.long  0xf6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTCONTROLOVR1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTCONTROLOVR1_RFU_HWTCONTROLOVR1 ,None RESET:0x0"
          
group.long  0xf8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLLGAINCTL_P0, Controls for the DllGain sequencing for locking and maintaining lock of the LCDL delay cells. - The DllGain sequencer will start locking with the DllGainIV. - As the end of locking approaches, the DllGain will be incremented in stages until, at the end of locking, the DllGain is the terminal values DllGainTV. - 2^(5-DllGain) is fractional change in the DAC code MstPhase1UI[8:0] of Dll per pclk. - Firmware uses values for DllGainIV, DllGainTV, and LcdlSeed0 that are optimized for minimum locking time. These controls are not to be configured by the user. RESET:0xa1"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLLGAINCTL_P0_DLLGAINIV ,Initial value of DllGain. RESET:0x1"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLLGAINCTL_P0_DLLGAINTV ,Terminal value of DllGain, ie the value in effect when locking is done and the value used for maintaining lock, ie tracking pclk variation. DllGainTV must be greater than or equal to DllGainIV. The maximum value is 10. RESET:0xa"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLLGAINCTL_P0_DLLSEEDSEL ,Reserved, must be configured to be 0. RESET:0x0"
          
group.long  0xfa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLLLOCKPARAM_P0, Reserved for PHY training firmware use. RESET:0x17c1"
         hexmask.long 0x00 0.--12. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLLLOCKPARAM_P0_RFU_DLLLOCKPARAM_P0 ,None RESET:0x17c1"
          
group.long  0xfc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTCONTROLVAL0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTCONTROLVAL0_RFU_HWTCONTROLVAL0 ,None RESET:0x0"
          
group.long  0xfe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTCONTROLVAL1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTCONTROLVAL1_RFU_HWTCONTROLVAL1 ,None RESET:0x0"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ACSMGLBLSTART, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ACSMGLBLSTART_ACSMGLBLSTART ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x104++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ACSMGLBLSGLSTPCTRL, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ACSMGLBLSGLSTPCTRL_RFU_ACSMGLBLSGLSTPCTRL ,None RESET:0x0"
          
group.long  0x108++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_LCDLCALPHASE, Reserved for PHY test firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_LCDLCALPHASE_LCDLCALPHASE ,Reserved for PHY test firmware use. RESET:0x0"
          
group.long  0x10a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_LCDLCALCTRL, Reserved for PHY test firmware use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_LCDLCALCTRL_RFU_LCDLCALCTRL ,None RESET:0x0"
          
group.long  0x110++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALRATE, This CSR controls the impedance calibration engine in the PHY. RESET:0x9"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALRATE_CALINTERVAL ,This CSR specifies the interval between successive calibrations, in mS. csrValue : Interval (mS)  - 0 : 0 (continuous)  - 1 : 0.010  - 2 : 0.10  - 3 : 1  - 4 : 2  - 5 : 3  - 6 : 4  - 7 : 8  - 8 : 10  - 9 : 20  - 10-15 : Reserved. This field should only be changed while the calibrator is idle. ie before csr CalRun is set. The calibration intervals are valid only at DFICLK frequency >=24MHz. If the DFICLK frequency is less than 24MHz, the interval may be up to 2.4x larger than the value programmed in the register. RESET:0x9"
          
         bitfld.long 0x00 4. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALRATE_CALRUN ,This field is programmed as follows:  - 1: A calibration sequence will be triggered by the 0->1 transition of this bit, as determined by CSR CalOnce.  - 0: Calibrator will not run. If already active then it will complete the current sequence before quiescing. The default value of this field is 0 because the calibrator needs to know the correct operating mode before it starts up. This csr won't do anything while CalZap is asserted. RESET:0x0"
          
         bitfld.long 0x00 5. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALRATE_CALONCE ,The setting of this CSR changes the behavior of CSR CalRun.  - 1: The 0->1 transition of CSR CalRun causes a single iteration of the calibration sequence to occur. Once the calibration is complete, the calibration engine will remain IDLE until another CalRun Trigger.  - 0: Calibration will proceed at the rate determined by Register CalInterval. This field should only be changed while the calibrator is idle. ie before csr CalRun is set. RESET:0x0"
          
         bitfld.long 0x00 6. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALRATE_DISABLEBACKGROUNDZQUPDATES ,Reserved for debug only. When this bit is set, ZQ compensation code updates will occur only during a DFI sideband [PHYUPDATE,CTRLUPDATE,PHYMSTR] handshake. This debug feature must be disabled if DFI1 is active. RESET:0x0"
          
group.long  0x112++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALZAP, Impedance Calibration Zap/Reset RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALZAP_CALZAP ,This CSR is written by PHY Initialization Engine (PIE) and the data in here will be overwritten.  Setting this csr resets the calibrator to its idle state. Must be cleared in order for the calibration engine to run again. RESET:0x0"
          
group.long  0x116++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PSTATE, PSTATE Selection RESET:0xc"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PSTATE_PSTATE ,This CSR is written by PHY Initialization Engine (PIE) and the data in here will be overwritten. The current PState inferred by the PIE from handshake requests on DFI status interface.  - 0000 - PState P0  - 0001 - PState P1  - 0010 - PState P2  - 0011 - PState P3  - 0100 - Reserved  - 0101 - Reserved  - 0110 - Reserved  - 0111 - Reserved  - 1000 - Reserved  - 1001 - Reserved  - 1010 - Reserved  - 1011 - Reserved  - 1100 - LP2  - 1101 - Reserved  - 1110 - Reserved  - 1111 - LP3 The lower two bits of this CSR are used to select the PHY's current Pstate for all Pstateable registers.  Note: It is a don't care what value is selected in either LP2 or LP3 because no transactions will be taking place when in those states. RESET:0xc"
          
group.long  0x118++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALPREDRIVEROVERRIDE, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALPREDRIVEROVERRIDE_RFU_CALPREDRIVEROVERRIDE ,None RESET:0x0"
          
group.long  0x11a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLOUTGATECONTROL, Note : This CSR is written by PHY Initialization Engine (PIE) and the data in here will be overwritten. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLOUTGATECONTROL_PCLKGATEEN ,Reserved. RESET:0x0"
          
          
group.long  0x11e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_UCMEMRESETCONTROL, This register is dynamically written by PHY Initialization Engine during frequency changes and should not be written by the user. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_UCMEMRESETCONTROL_RFU_UCMEMRESETCONTROL ,None RESET:0x0"
          
group.long  0x120++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PORCONTROL, Power On Reset Control. Register is written PIE during PHY operation. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PORCONTROL_PLLDLLLOCKDONE ,Set by the PIE to 1 during execution, Cleared on PHY Reset or on power cycle. When Set, releases control of PHY I/O's from power on defaults.  Note: This is a legacy register name and no longer represents when PHY internal PLL or DLL is locked. RESET:0x0"
          
rgroup.long 0x12e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALBUSY, Impedance Calibration Busy Status RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALBUSY_CALBUSY ,Read 1 if the calibrator is actively calibrating. Any changes to calibrator-related CSRs may only be made if the calibrator is disabled (via CSR CalRun) and this CSR reads 0. RESET:0x0"
          
group.long  0x130++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALMISC2, Second set of miscellaneous impedance calibrator controls. RESET:0x4"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALMISC2_CALNUMVOTES ,This CSR controls the number of consecutive comparator output bits over which majority voting is done. It effectively works as a sampling window, since each sample serves as a single vote. The result of the voting is fed into the Successive Approximation Register (SAR). The voting is initiated after the time configured via csrs CalSlowCmpana has elapsed. CSR Value : number of Votes  - 0 : 1  - 1 : 9  - 2 : 17  - 3 : 33  - 4 : 65 (defaults)  - 5 : 129  - 6 : 193  - 7 : 255 RESET:0x4"
          
          
          
         bitfld.long 0x00 12. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALMISC2_CALCMPTRRESTRIM ,Reserved for future use. RESET:0x0"
          
         bitfld.long 0x00 13. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALMISC2_CALCANCELROUNDERRDIS ,The PEXT calibration result and NINT calibration results naturally include a rounding error which manifests as a change of impedance at the pad. Where both of these errors are in the same direction the. PEXT calibration result will be adjusted by 1 to offset. NINT error. Setting this csr to 1 prevents this adjustment. RESET:0x0"
          
         bitfld.long 0x00 14. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALMISC2_CALSLOWCMPANA ,When set, this CSR doubles the time allowed for the analog comparator cell to settle before sampling begins. RESET:0x0"
          
          
group.long  0x134++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALMISC, Table of impedance calibration CSR relatedness:  Target: OFFSET05  - Aka: CalCmpr5  - Working state: resCalCmpr5  - R_W viewing CSR: CalCmpr5  - Override CSR: CalCmpr5Ovr  - Offset CSR: CalCmpr5Offset  - Destination CSR: -- Target: NINT  - Aka: CalDrvPd5  - Working state: resCalNInt  - R_W viewing CSR: CalNInt  - Override CSR: CalNIntOvr  - Offset CSR: [CalDrvPdOffset, CalDrvPdThOffset]  - Destination CSR: -- Target: PEXT  - Aka: CalDrvPu5  - Working state: resCalPExt  - R_W viewing CSR: CalPExt  - Override CSR: CalPExtOvr  - Offset CSR: [CalDrvPuOffset, CalDrvPuThOffset]  - Destination CSR: -- Miscellaneous calibration control knobs. These values may only be changed when the calibrator is not running. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALMISC_CALCMPR5DIS ,Setting this CSR prevents the calibration engine from using the result from the CalCmpr5 stage of calibration. Software must supply a replacement value via CSR CalCmpr5Ovr. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALMISC_CALNINTDIS ,Setting this CSR prevents the calibration engine from overwriting the CSRs TxCalBinN and TxCalThN with an automatically generated value, in which case a value must be supplied by software. RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALMISC_CALPEXTDIS ,Setting this CSR prevents the calibration engine from overwriting the CSRs TxCalBinP and TxCalThP with an automatically generated value, in which case a value must be supplied by software. RESET:0x0"
          
group.long  0x136++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALVREFS, VREF code for Comparator offset compensation. RESET:0x2"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALVREFS_CALVREFS ,This CSR drives the Cmpdig_CalRef pin of the cmpana cell at various stages of calibration. Following are the encoding values  - 2'b00 - Reserved  - 2'b01 - Reserved  - 2'b10 - 50% Vref (Default)  - 2'b11 - Reserved RESET:0x2"
          
rgroup.long 0x138++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALCMPR5, Impedance Calibration Cmpr control RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALCMPR5_CALCMPR5 ,Returns the offset-compensated DAC code for the cmpana circuit at VRef == 0.5 * VDDQ. RESET:0x0"
          
rgroup.long 0x13a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALNINT, Observation of calibration engine pull-down calibration code. RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALNINT_CALNINTTHB ,The value here is the number of thermometer bits which are set. RESET:0x0"
          
rgroup.long 0x13c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALPEXT, Observation of calibration engine pull-up calibration code. RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALPEXT_CALPEXTTHB ,The value here is the number of thermometer bits which are set. RESET:0x0"
          
group.long  0x150++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALCMPINVERT, A safety bit for each calibration target, which controls the inversion (or not) of the comparator output before it is sampled. A 1 in the CSR causes the comparator output to be inverted. RESET:0x3"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALCMPINVERT_CMPINVERTCALDAC50 ,Impedance Calibration Cmp Invert control RESET:0x1"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALCMPINVERT_CMPINVERTCALDRVPD50 ,Impedance Calibration Cmp Invert control RESET:0x1"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALCMPINVERT_CMPINVERTCALDRVPU50 ,Impedance Calibration Cmp Invert control RESET:0x0"
          
         bitfld.long 0x00 3. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALCMPINVERT_CMPINVERTCALODTPD ,Impedance Calibration Cmp Invert control RESET:0x0"
          
         bitfld.long 0x00 4. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALCMPINVERT_CMPINVERTCALODTPU ,Impedance Calibration Cmp Invert control RESET:0x0"
          
group.long  0x15c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALCMPANACNTRL, This register control the cmpana custom circuit analog control. It is not recommended to change their values from the reset values. RESET:0x112"
         hexmask.long 0x00 0.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALCMPANACNTRL_CMPRGAINCURRADJ ,Impedance Calibration Cmpana control RESET:0x12"
          
         bitfld.long 0x00 8. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALCMPANACNTRL_CMPRGAINRESADJ ,Impedance Calibration Cmpana control RESET:0x1"
          
         bitfld.long 0x00 9. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CALCMPANACNTRL_CMPRBIASBYPASSEN ,Impedance Calibration Cmpana control RESET:0x0"
          
group.long  0x160++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIRDDATACSDESTMAP_P0, This CSR must be default values in LPDDR3 and LPDDR4 modes. Maps dfi_rddata_cs_n (read chip-select asserted low) to destination dimm timing group. RESET:0xe4"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIRDDATACSDESTMAP_P0_DFIRDDESTM0 ,Maps dfi_rddata_cs_n_p0[0] to dest DfiRdDestm0 timing.  For example, if 0 dfi_rddata_cs_n_p0[0] will use Register Rx[En,Clk]DlyTg0 timing. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIRDDATACSDESTMAP_P0_DFIRDDESTM1 ,Maps dfi_rddata_cs_n_p0[1] to dest DfiRdDestm1 timing.  For example, if 1 dfi_rddata_cs_n[_p01] will use Register Rx[En,Clk]DlyTg1 timing. RESET:0x1"
          
         hexmask.long 0x00 4.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIRDDATACSDESTMAP_P0_DFIRDDESTM2 ,Maps dfi_rddata_cs_n_p0[2] to dest DfiRdDestm2 timing.  For example, if 2 dfi_rddata_cs_n_p0[2] will use Register Rx[En,Clk]DlyTg2 timing. RESET:0x2"
          
         hexmask.long 0x00 6.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIRDDATACSDESTMAP_P0_DFIRDDESTM3 ,Maps dfi_rddata_cs_n_p0[3] to dest DfiRdDestm3 timing.  For example, if 3 dfi_rddata_cs_n_p0[3] will use Register Rx[En,Clk]DlyTg3 timing. RESET:0x3"
          
group.long  0x164++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_VREFINGLOBAL_P0, This Register controls the PHY global VREF generator, and the PHY analog pad BP_VREF. The mission mode function of the PHY VREF generator is to generate VrefDQ for the PHY RX function. This register is written and configured by the PHY training firmware for mission mode function. RESET:0x200"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_VREFINGLOBAL_P0_GLOBALVREFINSEL ,GlobalVrefInSel[1:0] controls the mode of the PHY VREF DAC and the BP_VREF pin  - 2'b00 - PHY Vref DAC Range0 -- BP_VREF = Hi-Z  - 2'b01 - Reserved Encoding  - 2'b10 - PHY Vref DAC Range0 -- BP_VREF connected to PLL Analog Bus  - 2'b11 - PHY Vref DAC Range0 -- BP_VREF connected to PHY Vref DAC GlobalVrefInSel[2] controls the DAC range for internal Vref generation RESET:0x0"
          
         hexmask.long 0x00 3.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_VREFINGLOBAL_P0_GLOBALVREFINDAC ,DAC code for internal Vref generation. The DAC has two ranges; the range is set by GlobalVrefInSel[2]  - RANGE0 : [GlobalVrefInSel[2] = 0]  -- DAC Output Voltage = GlobalVrefInDAC == 6'h00 ? Hi-Z : 0.345*VDDQ + (0.005*GlobalVrefInDAC)*VDDQ  - RANGE1 : [GlobalVrefInSel[2] = 1]  -- DAC Output Voltage = GlobalVrefInDAC == 6'h00 ? Hi-Z : (0.005*(GlobalVrefInDAC-1))*VDDQ RESET:0x40"
          
         hexmask.long 0x00 10.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_VREFINGLOBAL_P0_GLOBALVREFINTRIM ,RSVD RESET:0x0"
          
         bitfld.long 0x00 14. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_VREFINGLOBAL_P0_GLOBALVREFINMODE ,RSVD RESET:0x0"
          
group.long  0x168++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIWRDATACSDESTMAP_P0, This CSR must be default values in LPDDR3 and LPDDR4 modes Maps dfi_wrdata_cs_n (write chip-select asserted low) to destination dimm timing group. The full dfi interface has 72 values of dfi_wrdata_cs_n, with 8 per byte. Byte db (0..8) uses values dfi_wrdata_cs_n[(db*8 + 7):(db*8 + 0)] and this register, which is per byte, to determine the timing-control registers to use for the asserted chip-select. For simplicity, the subfield description does not include the byte offset for dfi_wrdata_cs_n.  Note: The example values below are the default/reset values. If this register is written to all zeroes, then all writes will use Register Tx[Dq,Dqs]Dlyd0 timing. RESET:0xe4"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIWRDATACSDESTMAP_P0_DFIWRDESTM0 ,Maps dfi_wrdata_cs_n_p0[0] to dest DfiWrDestm0 timing  For example, if 0 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg0 timing. RESET:0x0"
          
         hexmask.long 0x00 2.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIWRDATACSDESTMAP_P0_DFIWRDESTM1 ,Maps dfi_wrdata_cs_n_p0[1] to dest DfiWrDestm1 timing  For example, if 1 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg1 timing. RESET:0x1"
          
         hexmask.long 0x00 4.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIWRDATACSDESTMAP_P0_DFIWRDESTM2 ,Maps dfi_wrdata_cs_n_p0[2] to dest DfiWrDestm2 timing  For example, if 2 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg2 timing. RESET:0x2"
          
         hexmask.long 0x00 6.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIWRDATACSDESTMAP_P0_DFIWRDESTM3 ,Maps dfi_wrdata_cs_n_p0[3] to dest DfiWrDestm3 timing (use Register Tx[Dq,Dqs]DlyTg3)  For example, if 3 dfi_wrdata_cs_n_p0[0] will use Register Tx[Dq,Dqs]DlyTg3 timing. RESET:0x3"
          
rgroup.long 0x16a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MASUPDGOODCTR, Counts successful PHY Master Interface Updates (PPTs) RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MASUPDGOODCTR_MASUPDGOODCTR ,This register increments whenever the Memory Controller acknowledges a PHY Master Interface request ,i.e. a request for the PHY to take over the DFI for Periodic Phase Training (PPT).  (As per section 11 of the Preliminary DFI 4.0 Specification Rev. 2) In a 2-channel system, both MC channels must ack. The counter saturates at max value 65535. RESET:0x0"
          
rgroup.long 0x16c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYUPD0GOODCTR, Counts successful PHY-initiated DFI0 Interface Updates RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYUPD0GOODCTR_PHYUPD0GOODCTR ,This register increments whenever the Memory Controller acknowledges a PHY-initiated DFI0 interface update request. The counter saturates at max value 65535. RESET:0x0"
          
rgroup.long 0x16e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYUPD1GOODCTR, Counts successful PHY-initiated DFI1 Interface Updates RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYUPD1GOODCTR_PHYUPD1GOODCTR ,This register increments whenever the Memory Controller acknowledges a PHY-initiated DFI1 interface update request. The counter saturates at max value 65535. RESET:0x0"
          
rgroup.long 0x170++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CTLUPD0GOODCTR, Counts successful Memory Controller DFI0 Interface Updates RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CTLUPD0GOODCTR_CTLUPD0GOODCTR ,This register increments whenever the PHY acknowledges a Memory Controller-initiated DFI0 interface update request. The counter saturates at max value 65535. RESET:0x0"
          
rgroup.long 0x172++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CTLUPD1GOODCTR, Counts successful Memory Controller DFI1 Interface Updates RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CTLUPD1GOODCTR_CTLUPD1GOODCTR ,This register increments whenever the PHY acknowledges a. Memory Controller-initiated DFI1 interface update request. The counter saturates at max value 65535. RESET:0x0"
          
rgroup.long 0x174++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MASUPDFAILCTR, Counts unsuccessful PHY Master Interface Updates RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MASUPDFAILCTR_MASUPDFAILCTR ,This register increments whenever the PHY asserts a PHY Master. Interface request, but the Memory Controller doesn't acknowledge the request within the allowed interval. (As per section 11 of the Preliminary DFI 4.0 Specification Rev. 2) The counter saturates at max value 65535. In a 2-channel system, a failure occurs if either MC channels fails to ack. RESET:0x0"
          
rgroup.long 0x176++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYUPD0FAILCTR, Counts unsuccessful PHY-initiated DFI0 Interface Updates RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYUPD0FAILCTR_PHYUPD0FAILCTR ,This register increments whenever the PHY asserts a DFI0. Interface update request, but the Memory Controller doesn't acknowledge the request within the allowed interval. (As per section 11 of the Preliminary DFI 4.0 Specification Rev. 2) The counter saturates at max value 65535. RESET:0x0"
          
rgroup.long 0x178++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYUPD1FAILCTR, Counts unsuccessful PHY-initiated DFI1 Interface Updates RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYUPD1FAILCTR_PHYUPD1FAILCTR ,This register increments whenever the PHY asserts a DFI1. Interface update request, but the Memory Controller doesn't acknowledge the request within the allowed interval. (As per section 11 of the Preliminary DFI 4.0 Specification Rev. 2) The counter saturates at max value 65535. RESET:0x0"
          
group.long  0x17a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYPERFCTRENABLE, Each bit corresponds to one performance counter. Set the bit to enable the counter. Clearing the bit stops and clears the counter. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYPERFCTRENABLE_MASUPDGOODCTL ,Enables MasUpdGoodCtr RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYPERFCTRENABLE_PHYUPD0GOODCTL ,Enables PhyUpd0GoodCtr RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYPERFCTRENABLE_PHYUPD1GOODCTL ,Enables PhyUpd1GoodCtr RESET:0x0"
          
         bitfld.long 0x00 3. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYPERFCTRENABLE_CTLUPD0GOODCTL ,Enables CtlUpd0GoodCtr RESET:0x0"
          
         bitfld.long 0x00 4. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYPERFCTRENABLE_CTLUPD1GOODCTL ,Enables CtlUpd1GoodCtr RESET:0x0"
          
         bitfld.long 0x00 5. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYPERFCTRENABLE_MASUPDFAILCTL ,Enables MasUpdFailCtr RESET:0x0"
          
         bitfld.long 0x00 6. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYPERFCTRENABLE_PHYUPD0FAILCTL ,Enables PhyUpd0FailCtr RESET:0x0"
          
         bitfld.long 0x00 7. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYPERFCTRENABLE_PHYUPD1FAILCTL ,Enables PhyUpd1FailCtr RESET:0x0"
          
group.long  0x17c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIWRRDDATACSCONFIG, By default, dfi_wrdata_cs and dfi_rddata_cs are interpreted as active low signals. For LPDDR4, the polarity of dfi_wrdata_cs and dfi_rddata_cs can be inverted. All other protocols shall use the default values. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIWRRDDATACSCONFIG_DFIWRDATACSPOLARITY ,Specifify the dfi_wrdata_cs polarity 1'b0 - Active low 1'b1 - Active high RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIWRRDDATACSCONFIG_DFIRDDATACSPOLARITY ,Specifify the dfi_rddata_cs polarity 1'b0 - Active low 1'b1 - Active high RESET:0x0"
          
group.long  0x186++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLPWRDN, PLL Power Down RESET:0x1"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLPWRDN_PLLPWRDN ,This CSR is written by PHY Initialization Engine (PIE) and the data in here will be overwritten. Places the PLL in Power Down when asserted. RESET:0x1"
          
group.long  0x188++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLRESET, PLL Reset RESET:0x1"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLRESET_PLLRESET ,Reserved RESET:0x1"
          
group.long  0x18a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL2_P0, This csr is to be programmed by bios or other means to set PLL charge-pump settings in various PStates. See Technology specific PHY Databook for control setting programming. RESET:0x19"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL2_P0_PLLFREQSEL ,Adjusts the loop parameters to compensate for different VCO bias points, and input/output clock division ratios. RESET:0x19"
          
group.long  0x18c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0, Note : This CSR is written by PHY Initialization Engine (PIE) and the data in here will be overwritten. RESET:0x2008"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0_PLLSTANDBY ,Connects directly to standby pin of PLL. Puts PLL into standbymode. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0_PLLBYPSEL ,Reserved. RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0_PLLX2MODE ,connects to x2_mode pins of PLL. pllout_x4x2 output frequency selection. - 0: PLOUT_X4X2 output = 4*pllin_x1 frequency - 1: PLOUT_X4X2 output = 2*pllin_x1 frequency RESET:0x0"
          
         bitfld.long 0x00 3. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0_PLLOUTBYPEN ,Controls the antiglitch mux on the pllout_x1x2x4 path - 1: pllout_x1x2x4 = byp_pllin_x1 - 0: pllout_x1x2x4 = VCO (SCD) (selected by x2_mode) RESET:0x1"
          
         bitfld.long 0x00 4. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0_PLLPRESET ,Put PLL in preset mode. RESET:0x0"
          
         bitfld.long 0x00 5. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0_PLLBYPASSMODE ,PLL Bypass clock mux control. If set, BypassPclk input will be used as byp_pll1x_in clock for PLL. Default 0. RESET:0x0"
          
         bitfld.long 0x00 6. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0_PLLSELDFIFREQRATIO ,reserved. RESET:0x0"
          
         bitfld.long 0x00 7. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0_PLLSYNCBUSFLUSH ,Used to flush the syncbus logic of the PLL during PHY initialization or LP3 Exit sequence. Should Only be toggled when synbus is not used and Register PllOutBypEn is asserted. RESET:0x0"
          
         bitfld.long 0x00 8. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0_PLLSYNCBUSBYP ,When asserted bypasses the Pll SyncPulse and uses a synchronizer of the same latency. RESET:0x0"
          
         hexmask.long 0x00 9.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0_PLLRESERVED10X9 ,for future use. RESET:0x0"
          
         bitfld.long 0x00 11. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0_PLLGEARSHIFT ,Puts PLL in fast re-locking mode - 0: default, normal mode - 1: fast relock gear RESET:0x0"
          
         bitfld.long 0x00 12. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0_PLLLOCKCNTSEL ,Lock detect counter selection. - 0: Normal lock detector behavior phase lock - 1: Test mode (Shorten lock cycle count 16->8) RESET:0x0"
          
         hexmask.long 0x00 13.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0_PLLLOCKPHSEL ,Lock detect phase selection. - 0: Test mode reduced lock window - 1: Default operation phase lock - 2: Test mode (mismatch check) - 3: Test mode (+80ps window) RESET:0x1"
          
         bitfld.long 0x00 15. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL0_PLLSPARECTRL0 ,Spare bits for PLL control. RESET:0x0"
          
group.long  0x18e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL1_P0, This csr is to be programmed by bios or other means to set PLL charge-pump settings in various PStates. See Technology specific PHY Databook for control setting programming. RESET:0x20"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL1_P0_PLLCPINTCTRL ,connects directly to cp_int_cntrl<4:0> in PLL. Charge pump integrating current control. RESET:0x0"
          
         hexmask.long 0x00 5.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL1_P0_PLLCPPROPCTRL ,connects directly to cp_prop_cntrl<3:0> of PLL. Charge pump proportional current control. RESET:0x1"
          
group.long  0x190++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLTST, Control Register for PLL Test RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLTST_PLLANATSTEN ,Connects directly to pll_ana_test_en of PLL. Analog test port enable. - 0 = analog test port disabled (hi-Z) - 1 = analog test port enabled RESET:0x0"
          
         hexmask.long 0x00 1.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLTST_PLLANATSTSEL ,Connects directly to pll_ana_test_sel<3:0> of PLL. Control bits are decoded to enable various analog test signals to be brought out via analog test pin (pll_analog_test). Table below provides decode detail.  PllAnaTstSel : Pll Analog Pin Function : Description   - 0000: Hi-Z: This code should be set when the PLL is in normal use or when the digital test port is being used for accurate timing measurements  - 0001: core: Override vmarg_ext with analog pin  - 0010: core: Override regulator input with analog pin  - 0011: core: Observe gd voltage on analog test pin  - 0100: core: Observe vp voltage on analog test pin  - 0101: core: Observe vph voltage on analog test pin  - 0110: core: Observe vreg_cp voltage on analog test pin  - 0111: core: Observe v2i current (~10uA) on analog test pin  - 1000: core: Observe vreg_v2i voltage on analog test pin  - 1001: core: Observe vbp voltage from current source on analog pin  - 1010: core: Observe vbn voltage from current source on analog tpin  - 1011: core: NC  - 1100: core: NC  - 1101: VSS : 0v probe ir drop test  - 1110: VP : Core supply probe SCD IR drop test  - 1111: VPH : Core Supply probe Refdiv IR drop test RESET:0x0"
          
         hexmask.long 0x00 5.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLTST_PLLDIGTSTSEL ,Connects directly to pll_dig_test_sel<2:0> of PLL. Digital test mux select. Control bits are decoded to enable various digital test signals to be brought out via digital test pin, see decoder table for detail.  - PllDigTstOut[1] is observable on BP_ALERT and Digital Observation Pin via MtestMuxSel logic.  - PllDigTstOut[0] is observable on Digital Observation Pin via MtestMuxSel logic only (if enabled in this configuration).  - During mission mode PllDigTstSel should be set to 3'h0.  - Byp = PllBypassMode CSR value  - Sel = PllDigTstSel CSR value Byp | Sel | PllDigTstOut[1] | PllDigTstOut[0] | Description  - 0 | 000 | 0 | 0 | This code should be set during normal use to minimize clock jitter  - 0 | 001 | fbk_clk_ldet | pllin_x1 | Buffered version of fbk_clk at PFD input  - 0 | 010 | ref_clk_ldet | pllin_x1 | Buffered version of ref_clk at PFD input  - 0 | 011 | pllin_x1 | pllin_x1 | For calibrating delay skew between two test outputs - input reference clock  - 0 | 100 | clk_fbk | pllin_x1 | Buffered version of pllout_x1  - 0 | 101 | pllout_amux_x1x2x4 | pllin_x1 | Syncbus clock output (Fout<Fmax_dto only)  - 0 | 110 | en_count | pll_lock | Lock detector state test  - 0 | 111 | standby_eff | eoc | Calibration state test  - 1 | 000 | 0 | 0 | This code should be set during normal use to minimize clock jitter  - 1 | 001 | fbk_clk_ldet | pllin_x1 | Buffered version of fbk_clk at PFD input if PLL in mission/byp 1 modes  - 1 | 010 | ref_clk_ldet | pllin_x1 | Buffered version of ref_clk at PFD input -if PLL in mission/byp 1 modes  - 1 | 011 | pllin_x1 | pllin_x1 | For calibrating delay skew between two test outputs - input reference clock  - 1 | 100 | clk_fbk | pllin_x1 | Buffered version of pllout_x1 if PLL in mission/byp 1 modes  - 1 | 101 | pllout_amux_x1x2x4 | pllin_x1 | Syncbus clock output (Fout<Fmax_dto only)  - 1 | 110 | en_count | pll_lock | Lock detector test if PLL in mission/byp 1 modes  - 1 | 111 | standby_eff | eoc | Calibration state test if PLL in mission/byp 1 modes Note: Fmax_dto=400MHz RESET:0x0"
          
rgroup.long 0x192++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLLOCKSTATUS, PLL's pll_lock pin output RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLLOCKSTATUS_PLLLOCKSTATUS ,Directly connected to the pll_Lock output. When asserted Pll macro has asserted the Lock status. To avoid metastability issues, this register should perform a majority-vote after reading this register several times. RESET:0x0"
          
group.long  0x194++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLTESTMODE_P0, Additional controls for PLL CP/VCO modes of operation RESET:0x124"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLTESTMODE_P0_PLLTESTMODE_P0 ,It is required to use default values for this CSR unless directed otherwise by Synopsys. Directly connected to testmode[15:0] pin of PLL RESET:0x124"
          
group.long  0x196++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL3, It is recommended to use default values for this CSR. Otherwise, it can be programmed by bios or other means. RESET:0x1f0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL3_PLLSPARE ,Spare bits for future PLL control modes RESET:0x0"
          
         hexmask.long 0x00 4.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL3_PLLMAXRANGE ,connects directly to maxrange of PLL. Setting for Saturation control of PLL. RESET:0x1f"
          
         hexmask.long 0x00 9.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL3_PLLDACVALIN ,connects directly to dacval_in<4:0> of PLL. Calibration DAC input current setting, can be forced at rising edge of preset if force_cal =1 RESET:0x0"
          
         bitfld.long 0x00 14. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL3_PLLFORCECAL ,connects directly to force_cal of PLL. Forces Calibration code dacval_in<4:0> to be used at preset mode if force_cal=1 if force_cal=0 previous stored value will be used RESET:0x0"
          
         bitfld.long 0x00 15. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL3_PLLENCAL ,Calibration will run at standby rising edge if en_cal=1 if en_cal=0 calibration will not run RESET:0x0"
          
group.long  0x198++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL4_P0, This csr is to be programmed by bios or other means to set PLL charge-pump settings in various PStates. Refer to Technology specific PHY Databook for control setting programming. RESET:0x17f"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL4_P0_PLLCPINTGSCTRL ,connects directly to cp_int_gs_cntrl<4:0> in PLL. Charge pump integrating current control for fast relock and gearshift. RESET:0x1f"
          
         hexmask.long 0x00 5.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLCTRL4_P0_PLLCPPROPGSCTRL ,connects directly to cp_prop_gs_cntrl<3:0> of PLL. Charge pump proportional current control for fast relock and gearshift. RESET:0xb"
          
rgroup.long 0x19a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLENDOFCAL, PLL's eoc (end of calibration) output RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLENDOFCAL_PLLENDOFCAL ,Directly connected to the pll's eoc output. RESET:0x0"
          
rgroup.long 0x19c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLSTANDBYEFF, PLL's standby_eff (effective standby) output RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLSTANDBYEFF_PLLSTANDBYEFF ,Returns state off PLL standby. PLL will be in standby in PHY LP2 states. RESET:0x0"
          
rgroup.long 0x19e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLDACVALOUT, PLL's Dacval_out output RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PLLDACVALOUT_PLLDACVALOUT ,Directly connected to the pll's dacval_out output. Used for observation of PLL DAC code. RESET:0x0"
          
group.long  0x1a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTSEQ, Reserved for PHY test firmware use. RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTSEQ_RFU_DLYTESTSEQ ,None RESET:0x0"
          
group.long  0x1a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTRINGSELDB, Reserved for PHY test firmware use. RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTRINGSELDB_RFU_DLYTESTRINGSELDB ,None RESET:0x0"
          
group.long  0x1a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTRINGSELAC, Reserved for PHY test firmware use. RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTRINGSELAC_RFU_DLYTESTRINGSELAC ,None RESET:0x0"
          
group.long  0x1a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTDFICLKIV, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTDFICLKIV_DLYTESTCNTDFICLKIV ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x1a8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTDFICLK, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTDFICLK_DLYTESTCNTDFICLK ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x1aa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB0_DLYTESTCNTRINGOSCDB0 ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x1ac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB1_DLYTESTCNTRINGOSCDB1 ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x1ae++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB2_DLYTESTCNTRINGOSCDB2 ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x1b0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB3_DLYTESTCNTRINGOSCDB3 ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x1b2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB4_DLYTESTCNTRINGOSCDB4 ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x1b4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB5_DLYTESTCNTRINGOSCDB5 ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x1b6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB6_DLYTESTCNTRINGOSCDB6 ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x1b8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB7_DLYTESTCNTRINGOSCDB7 ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x1ba++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB8_DLYTESTCNTRINGOSCDB8 ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x1bc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB9, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCDB9_DLYTESTCNTRINGOSCDB9 ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x1be++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCAC, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DLYTESTCNTRINGOSCAC_DLYTESTCNTRINGOSCAC ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x1c0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MSTLCDLDBGCNTL, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MSTLCDLDBGCNTL_RFU_MSTLCDLDBGCNTL ,None RESET:0x0"
          
rgroup.long 0x1c2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MSTLCDL0DBGRES, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MSTLCDL0DBGRES_RFU_MSTLCDL0DBGRES ,None RESET:0x0"
          
rgroup.long 0x1c4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MSTLCDL1DBGRES, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MSTLCDL1DBGRES_RFU_MSTLCDL1DBGRES ,None RESET:0x0"
          
group.long  0x1c6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_LCDLDBGCNTL, Controls for use in observing and testing the LCDLs. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_LCDLDBGCNTL_LCDLFINEOVRVAL ,Value forced as the initial value while LcdlTstEnable=1 and LcdlFineOvr. After the deassertion of LcdlFineOvr, the locking state-machine will attempt locking. RESET:0x0"
          
         bitfld.long 0x00 9. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_LCDLDBGCNTL_LCDLFINEOVR ,Forces the value of the present LCDL 1UI estimate code to be LcdlFineOvrVal for all LCDLs. RESET:0x0"
          
         bitfld.long 0x00 10. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_LCDLDBGCNTL_LCDLFINESNAP ,Latch enable for reading the present LCDL 1UI estimate code in LcdlFineSnapVal and the present phase-detector value in LcdlPhdSnapVal RESET:0x0"
          
         bitfld.long 0x00 11. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_LCDLDBGCNTL_LCDLTSTENABLE ,Enables the debug/test operations and status Ovr,Snap,StickyLock,StickyUnlock, and LiveLock. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_LCDLDBGCNTL_LCDLSTATUSSEL ,Selects the LCDL status, from among the status for the 16 LCDLs in the DBYTE, for reading via Register DxLcdlStatus and an LCDL from among the LCDLs in the ANIB for reading via Register AcLcdlStatus. LcdlStatusSel source for DxLcdlStatus source for AcLcdlStatus  - 15 lcdl_rxclk1t reserved  - 14 lcdl_rxclk1c reserved  - 13 lcdl_rxclk0t reserved  - 12 lcdl_rxclk0c reserved  - 11 lcdl_rxen1 anib11-tx  - 10 lcdl_rxen0 anib10-tx  - 9 lcdl_txln9 (dqs-lower) anib9-tx  - 8 lcdl_txln8 (dm/dqs-upper) anib8-tx  - 7 lcdl_txln7 (dq7) anib7-tx  - 6 lcdl_txln6 (dq6) anib6-tx  - 5 lcdl_txln5 (dq5) anib5-tx  - 4 lcdl_txln4 (dq4) anib4-tx  - 3 lcdl_txln3 (dq3) anib3-tx  - 2 lcdl_txln2 (dq2) anib2-tx  - 1 lcdl_txln1 (dq1) anib1-tx  - 0 lcdl_txln0 (dq0) anib0-tx RESET:0x0"
          
rgroup.long 0x1c8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ACLCDLSTATUS, Status of anib macro LCDL selected by Register LcdlStatusSel  Note that there is just one copy of this register, with the information from the implemented ANIBs multiplexed per csr LcdlStatus Sel RESET:0x0"
         hexmask.long 0x00 0.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ACLCDLSTATUS_ACLCDLFINESNAPVAL ,Value of the LCDL 1UI estimate code, latched by pulse on csrLcdlFineSnap while csr LcdlTstEnable=1. Index 9 is reserved for growth. RESET:0x0"
          
         bitfld.long 0x00 10. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ACLCDLSTATUS_ACLCDLPHDSNAPVAL ,Value of the LCDL phase-detector output, latched by pulse on LcdlFineSnap while csr LcdlTstEnable=1. RESET:0x0"
          
         bitfld.long 0x00 11. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ACLCDLSTATUS_ACLCDLSTICKYLOCK ,latched value of whether the LCDL ever achieved lock after the assertion of LcdlTstEnable. RESET:0x0"
          
         bitfld.long 0x00 12. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ACLCDLSTATUS_ACLCDLSTICKYUNLOCK ,latched value of whether the LCDL ever lost lock after the assertion of LcdlTstEnable. RESET:0x0"
          
         bitfld.long 0x00 13. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ACLCDLSTATUS_ACLCDLLIVELOCK ,present value of whether the LCDL is locked, valid when LcdlTstEnable=1. RESET:0x0"
          
rgroup.long 0x1da++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CUSTPHYREV, Customer settable PHY version number RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_CUSTPHYREV_CUSTPHYREV ,The customer settable PHY version number. The value is derived from the `define DWC_DDRPHY_CUST_PHYREV RESET:0x0"
          
rgroup.long 0x1dc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYREV, The hardware version of this PHY, excluding the PUB RESET:0x100"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYREV_PHYMNR ,Indicates minor update of the PHY. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYREV_PHYMDR ,Indicates moderate revision of the PHY. RESET:0x0"
          
         hexmask.long 0x00 8.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYREV_PHYMJR ,Indicates major revision of the PHY. RESET:0x1"
          
group.long  0x1de++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_LP3EXITSEQ0BSTARTVECTOR, Programmed by dwc_ddrphy_phyinit_C_initPhyConfig() to support frequency changes. Set the start vector to be used in LP3-exit or Init PIE sequence. RESET:0xde"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_LP3EXITSEQ0BSTARTVECTOR_LP3EXITSEQ0BSTARTVECPLLENABLED ,PIE Start Vector value to be used for LP3-exit or Init and target P-state has PLL enabled RESET:0xe"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_LP3EXITSEQ0BSTARTVECTOR_LP3EXITSEQ0BSTARTVECPLLBYPASSED ,PIE Start Vector value to be used for LP3-exit or Init and target P-state has PLL bypassed RESET:0xd"
          
group.long  0x1e0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT0, DFI Frequency Translation Register 0 Programmed by dwc_ddrphy_phyinit_C_initPhyConfig() to support frequency changes. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT0_DFIFREQXLATVAL0 ,The sequencer start vector used when dfi_freq value is 0. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT0_DFIFREQXLATVAL1 ,The sequencer start vector used when dfi_freq value is 1. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT0_DFIFREQXLATVAL2 ,The sequencer start vector used when dfi_freq value is 2. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT0_DFIFREQXLATVAL3 ,The sequencer start vector used when dfi_freq value is 3. RESET:0x0"
          
group.long  0x1e2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT1, DFI Frequency Translation Register 1 Programmed by dwc_ddrphy_phyinit_C_initPhyConfig() to support frequency changes. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT1_DFIFREQXLATVAL4 ,The sequencer start vector used when dfi_freq value is 4. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT1_DFIFREQXLATVAL5 ,The sequencer start vector used when dfi_freq value is 5. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT1_DFIFREQXLATVAL6 ,The sequencer start vector used when dfi_freq value is 6. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT1_DFIFREQXLATVAL7 ,The sequencer start vector used when dfi_freq value is 7. RESET:0x0"
          
group.long  0x1e4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT2, DFI Frequency Translation Register 2 Programmed by dwc_ddrphy_phyinit_C_initPhyConfig() to support frequency changes. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT2_DFIFREQXLATVAL8 ,The sequencer start vector used when dfi_freq value is 8. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT2_DFIFREQXLATVAL9 ,The sequencer start vector used when dfi_freq value is 9. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT2_DFIFREQXLATVAL10 ,The sequencer start vector used when dfi_freq value is 10. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT2_DFIFREQXLATVAL11 ,The sequencer start vector used when dfi_freq value is 11. RESET:0x0"
          
group.long  0x1e6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT3, DFI Frequency Translation Register 3 Programmed by dwc_ddrphy_phyinit_C_initPhyConfig() to support frequency changes. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT3_DFIFREQXLATVAL12 ,The sequencer start vector used when dfi_freq value is 12. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT3_DFIFREQXLATVAL13 ,The sequencer start vector used when dfi_freq value is 13. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT3_DFIFREQXLATVAL14 ,The sequencer start vector used when dfi_freq value is 14. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT3_DFIFREQXLATVAL15 ,The sequencer start vector used when dfi_freq value is 15. RESET:0x0"
          
group.long  0x1e8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT4, DFI Frequency Translation Register 4 Programmed by dwc_ddrphy_phyinit_C_initPhyConfig() to support frequency changes. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT4_DFIFREQXLATVAL16 ,The sequencer start vector used when dfi_freq value is 16. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT4_DFIFREQXLATVAL17 ,The sequencer start vector used when dfi_freq value is 17. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT4_DFIFREQXLATVAL18 ,The sequencer start vector used when dfi_freq value is 18. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT4_DFIFREQXLATVAL19 ,The sequencer start vector used when dfi_freq value is 19. RESET:0x0"
          
group.long  0x1ea++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT5, DFI Frequency Translation Register 5 Programmed by dwc_ddrphy_phyinit_C_initPhyConfig() to support frequency changes. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT5_DFIFREQXLATVAL20 ,The sequencer start vector used when dfi_freq value is 20. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT5_DFIFREQXLATVAL21 ,The sequencer start vector used when dfi_freq value is 21. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT5_DFIFREQXLATVAL22 ,The sequencer start vector used when dfi_freq value is 22. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT5_DFIFREQXLATVAL23 ,The sequencer start vector used when dfi_freq value is 23. RESET:0x0"
          
group.long  0x1ec++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT6, DFI Frequency Translation Register 6 Programmed by dwc_ddrphy_phyinit_C_initPhyConfig() to support frequency changes. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT6_DFIFREQXLATVAL24 ,The sequencer start vector used when dfi_freq value is 24. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT6_DFIFREQXLATVAL25 ,The sequencer start vector used when dfi_freq value is 25. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT6_DFIFREQXLATVAL26 ,The sequencer start vector used when dfi_freq value is 26. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT6_DFIFREQXLATVAL27 ,The sequencer start vector used when dfi_freq value is 27. RESET:0x0"
          
group.long  0x1ee++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT7, DFI Frequency Translation Register 7 Programmed by dwc_ddrphy_phyinit_C_initPhyConfig() to support frequency changes. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT7_DFIFREQXLATVAL28 ,The sequencer start vector used when dfi_freq value is 28. RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT7_DFIFREQXLATVAL29 ,The sequencer start vector used when dfi_freq value is 29. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT7_DFIFREQXLATVAL30 ,The sequencer start vector used when dfi_freq value is 30. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQXLAT7_DFIFREQXLATVAL31 ,The sequencer start vector used when dfi_freq value is 31. RESET:0x0"
          
group.long  0x1f0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TXRDPTRINIT, TxRdPtrInit control register RESET:0x1"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_TXRDPTRINIT_TXRDPTRINIT ,This register directly controls TxRdPtrInit, and is meant to be written by the PState sequencer as part of the power state switching sequence. It should be written to a 1 once the transition to LP2 is complete and:  - 32 cycles before the de-asserting of init_complete. Likewise it should    be written to 0 once the transition to an active PState is complete and  - 32 cycles before the assertion of init_complete. It should reset to a 1  on both warm and cold reset. RESET:0x1"
          
group.long  0x1f2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIINITCOMPLETE, DFI Init Complete control RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIINITCOMPLETE_DFIINITCOMPLETE ,This register directly controls DfiInitComplete, and is meant to be written by the PState sequencer as part of the power state switching sequence.  - It should be written to a 0 once the transition to LP2 is complete.  - Likewise it should be written to 1 once the transition to an active and PState is complete.  - It should reset to a 0 on both warm and cold reset. RESET:0x0"
          
group.long  0x1f4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQRATIO_P0, DFI Frequency Ratio RESET:0x1"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIFREQRATIO_P0_DFIFREQRATIO_P0 ,Specifies the ratio DfiCtlClk:MemClk.  - 00 = 1:1 mode  - 01 = 1:2 mode  - 1x = 1:4 mode When DWC_DDRPHY_FIXED_DFICTLCLK_RATIO is defined, this register is ignored and 1:2 mode is selected. RESET:0x1"
          
group.long  0x1f6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_RXFIFOCHECKS, Enable more frequent consistency checks of the RX FIFOs RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_RXFIFOCHECKS_DOFREQUENTRXFIFOCHECKS ,- When 0, read data FIFO pointer consistency checks are performed only during sideband transactions(i.e., phyupd, ctrlupd, lp_data, phymstr) or when dfi_init_start is asserted. This option relies upon intentional quiescing of the DFI interface in order for the check to be performed. - When 1, read data FIFO consistency checks are performed as when this bit is 0, and also  at the beginning of each break in read data traffic from the DRAM. This options provides the lowest  latency in reporting of a discrepancy in the read data FIFO pointer values. RESET:0x0"
          
group.long  0x1fe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MTESTDTOCTRL, If set, allows the MTestCombo observability signal to be routed out core-side through the dwc_ddrphy_dto pin RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MTESTDTOCTRL_MTESTDTOEN ,This field is programmed as follows: - MTESTdtoEn==[0], dwc_ddrphy_dto will be squelched (0) - MTESTdtoEn==[1], dwc_ddrphy_dto will reflect the observability signal multiplexed on MTestCombo RESET:0x0"
          
group.long  0x200++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA0TODFI, Maps PHY CAA lane 0 from dfi0_address of the index of the register contents. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA0TODFI_MAPCAA0TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi0_address to CAA 0.  Unused for DDR3 and unused for DDR4 applications. Each register in the set of MapCAAtoDfi must have a unique value within the set.  For example, if PHY CAA0 is mapped from dfi0_address[2], then Register MapCAA0toDfi should be 2.  - LPDDR4 ACX3,ACX6,ACX10,ACX12 registers MapCAA[0..5]toDfi are used  -- values 0-5 are valid,  -- values 6-15 are reserved  -- registers MapCAA[6..9]toDfi are reserved  - LPDDR3 ACX3: not supported  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved RESET:0x0"
          
group.long  0x202++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA1TODFI, Maps PHY CAA lane 1 from dfi0_address of the index of the register contents. RESET:0x1"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA1TODFI_MAPCAA1TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi0_address to CAA 1.  Unused for DDR3 and unused for DDR4 applications. Each register in the set of MapCAAtoDfi must have a unique value within the set.  For example, if PHY CAA1 is mapped from dfi0_address[2], then Register MapCAA1toDfi should be 2.  - LPDDR4 ACX3,ACX6,ACX10,ACX12 registers MapCAA[0..5]toDfi are used  -- values 0-5 are valid,  -- values 6-15 are reserved  -- registers MapCAA[6..9]toDfi are reserved  - LPDDR3 ACX3: not supported  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved RESET:0x1"
          
group.long  0x204++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA2TODFI, Maps PHY CAA lane 2 from dfi0_address of the index of the register contents. RESET:0x2"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA2TODFI_MAPCAA2TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi0_address to CAA 2.  Unused for DDR3 and unused for DDR4 applications. Each register in the set of MapCAAtoDfi must have a unique value within the set.  For example, if PHY CAA2 is mapped from dfi0_address[2], then Register MapCAA2toDfi should be 2.  - LPDDR4 ACX3,ACX6,ACX10,ACX12 registers MapCAA[0..5]toDfi are used  -- values 0-5 are valid,  -- values 6-15 are reserved  -- registers MapCAA[6..9]toDfi are reserved  - LPDDR3 ACX3: not supported  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved RESET:0x2"
          
group.long  0x206++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA3TODFI, Maps PHY CAA lane 3 from dfi0_address of the index of the register contents. RESET:0x3"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA3TODFI_MAPCAA3TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi0_address to CAA 3.  Unused for DDR3 and unused for DDR4 applications. Each register in the set of MapCAAtoDfi must have a unique value within the set.  For example, if PHY CAA3 is mapped from dfi0_address[2], then Register MapCAA3toDfi should be 2.  - LPDDR4 ACX3,ACX6,ACX10,ACX12 registers MapCAA[0..5]toDfi are used  -- values 0-5 are valid,  -- values 6-15 are reserved  -- registers MapCAA[6..9]toDfi are reserved  - LPDDR3 ACX3: not supported  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved RESET:0x3"
          
group.long  0x208++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA4TODFI, Maps PHY CAA lane 4 from dfi0_address of the index of the register contents. RESET:0x4"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA4TODFI_MAPCAA4TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi0_address to CAA 4.  Unused for DDR3 and unused for DDR4 applications. Each register in the set of MapCAAtoDfi must have a unique value within the set.  For example, if PHY CAA4 is mapped from dfi0_address[2], then Register MapCAA4toDfi should be 2.  - LPDDR4 ACX3,ACX6,ACX10,ACX12 registers MapCAA[0..5]toDfi are used  -- values 0-5 are valid,  -- values 6-15 are reserved  -- registers MapCAA[6..9]toDfi are reserved  - LPDDR3 ACX3: not supported  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved RESET:0x4"
          
group.long  0x20a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA5TODFI, Maps PHY CAA lane 5 from dfi0_address of the index of the register contents. RESET:0x5"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA5TODFI_MAPCAA5TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi0_address to CAA 5.  Unused for DDR3 and unused for DDR4 applications. Each register in the set of MapCAAtoDfi must have a unique value within the set.  For example, if PHY CAA5 is mapped from dfi0_address[2], then Register MapCAA5toDfi should be 2.  - LPDDR4 ACX3,ACX6,ACX10,ACX12 registers MapCAA[0..5]toDfi are used  -- values 0-5 are valid,  -- values 6-15 are reserved  -- registers MapCAA[6..9]toDfi are reserved  - LPDDR3 ACX3: not supported  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved RESET:0x5"
          
group.long  0x20c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA6TODFI, Maps PHY CAA lane 6 from dfi0_address of the index of the register contents. RESET:0x6"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA6TODFI_MAPCAA6TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi0_address to CAA 6.  Unused for DDR3 and unused for DDR4 applications. Each register in the set of MapCAAtoDfi must have a unique value within the set.  For example, if PHY CAA6 is mapped from dfi0_address[2], then Register MapCAA6toDfi should be 2.  - LPDDR4 ACX3,ACX6,ACX10,ACX12 registers MapCAA[0..5]toDfi are used  -- values 0-5 are valid,  -- values 6-15 are reserved  -- registers MapCAA[6..9]toDfi are reserved  - LPDDR3 ACX3: not supported  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved RESET:0x6"
          
group.long  0x20e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA7TODFI, Maps PHY CAA lane 7 from dfi0_address of the index of the register contents. RESET:0x7"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA7TODFI_MAPCAA7TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi0_address to CAA 7.  Unused for DDR3 and unused for DDR4 applications. Each register in the set of MapCAAtoDfi must have a unique value within the set.  For example, if PHY CAA7 is mapped from dfi0_address[2], then Register MapCAA7toDfi should be 2.  - LPDDR4 ACX3,ACX6,ACX10,ACX12 registers MapCAA[0..5]toDfi are used  -- values 0-5 are valid,  -- values 6-15 are reserved  -- registers MapCAA[6..9]toDfi are reserved  - LPDDR3 ACX3: not supported  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved RESET:0x7"
          
group.long  0x210++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA8TODFI, Maps PHY CAA lane 8 from dfi0_address of the index of the register contents. RESET:0x8"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA8TODFI_MAPCAA8TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi0_address to CAA 8.  Unused for DDR3 and unused for DDR4 applications. Each register in the set of MapCAAtoDfi must have a unique value within the set.  For example, if PHY CAA8 is mapped from dfi0_address[2], then Register MapCAA8toDfi should be 2.  - LPDDR4 ACX3,ACX6,ACX10,ACX12 registers MapCAA[0..5]toDfi are used  -- values 0-5 are valid,  -- values 6-15 are reserved  -- registers MapCAA[6..9]toDfi are reserved  - LPDDR3 ACX3: not supported  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved RESET:0x8"
          
group.long  0x212++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA9TODFI, Maps PHY CAA lane 9 from dfi0_address of the index of the register contents. RESET:0x9"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAA9TODFI_MAPCAA9TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi0_address to CAA 9.  Unused for DDR3 and unused for DDR4 applications. Each register in the set of MapCAAtoDfi must have a unique value within the set.  For example, if PHY CAA9 is mapped from dfi0_address[2], then Register MapCAA9toDfi should be 2.  - LPDDR4 ACX3,ACX6,ACX10,ACX12 registers MapCAA[0..5]toDfi are used  -- values 0-5 are valid,  -- values 6-15 are reserved  -- registers MapCAA[6..9]toDfi are reserved  - LPDDR3 ACX3: not supported  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved  - LPDDR3 ACX6,ACX10,ACX12: registers MapCAA[0..9]toDfi are used  -- values 0-9 are valid,  -- values 10-15 are reserved RESET:0x9"
          
group.long  0x220++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB0TODFI, Maps PHY CAB lane 0 from dfi1_address of the index of the register contents RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB0TODFI_MAPCAB0TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi1_address to CAB 0.  - Unused for DDR3 and unused for DDR4 applications.  - Unused for the 3-ANIB configuration. Each register in the set of MapCABtoDfi must have a unique value within the set.  For example, if PHY CAB0 is mapped from dfi1_address[2], then Register MapCAB0toDfi should be 2.  - LPDDR4 ACX3 registers MapCAB[0..9]toDfi are reserved, second channel not supported.  - LPDDR4 ACX6,ACX10,ACX12 registers MapCAB[0..5]toDfi are used, values 0-5 are valid,  - values 6-15 are reserved  - registers MapCAB[6..9]toDfi are reserved  - LPDDR3 ACX3 not supported.  - LPDDR3 ACX6 registers MapCAB[0..9] are unused, second channel not supported.  - LPDDR3 ACX10,ACX12 registers MapCAB[0..9]toDfi are used, values 0-9 are valid,  - values 10-15 are reserved RESET:0x0"
          
group.long  0x222++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB1TODFI, Maps PHY CAB lane 1 from dfi1_address of the index of the register contents RESET:0x1"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB1TODFI_MAPCAB1TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi1_address to CAB 1.  - Unused for DDR3 and unused for DDR4 applications.  - Unused for the 3-ANIB configuration. Each register in the set of MapCABtoDfi must have a unique value within the set.  For example, if PHY CAB1 is mapped from dfi1_address[2], then Register MapCAB1toDfi should be 2.  - LPDDR4 ACX3 registers MapCAB[0..9]toDfi are reserved, second channel not supported.  - LPDDR4 ACX6,ACX10,ACX12 registers MapCAB[0..5]toDfi are used, values 0-5 are valid,  - values 6-15 are reserved  - registers MapCAB[6..9]toDfi are reserved  - LPDDR3 ACX3 not supported.  - LPDDR3 ACX6 registers MapCAB[0..9] are unused, second channel not supported.  - LPDDR3 ACX10,ACX12 registers MapCAB[0..9]toDfi are used, values 0-9 are valid,  - values 10-15 are reserved RESET:0x1"
          
group.long  0x224++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB2TODFI, Maps PHY CAB lane 2 from dfi1_address of the index of the register contents RESET:0x2"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB2TODFI_MAPCAB2TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi1_address to CAB 2.  - Unused for DDR3 and unused for DDR4 applications.  - Unused for the 3-ANIB configuration. Each register in the set of MapCABtoDfi must have a unique value within the set.  For example, if PHY CAB2 is mapped from dfi1_address[2], then Register MapCAB2toDfi should be 2.  - LPDDR4 ACX3 registers MapCAB[0..9]toDfi are reserved, second channel not supported.  - LPDDR4 ACX6,ACX10,ACX12 registers MapCAB[0..5]toDfi are used, values 0-5 are valid,  - values 6-15 are reserved  - registers MapCAB[6..9]toDfi are reserved  - LPDDR3 ACX3 not supported.  - LPDDR3 ACX6 registers MapCAB[0..9] are unused, second channel not supported.  - LPDDR3 ACX10,ACX12 registers MapCAB[0..9]toDfi are used, values 0-9 are valid,  - values 10-15 are reserved RESET:0x2"
          
group.long  0x226++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB3TODFI, Maps PHY CAB lane 3 from dfi1_address of the index of the register contents RESET:0x3"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB3TODFI_MAPCAB3TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi1_address to CAB 3.  - Unused for DDR3 and unused for DDR4 applications.  - Unused for the 3-ANIB configuration. Each register in the set of MapCABtoDfi must have a unique value within the set.  For example, if PHY CAB3 is mapped from dfi1_address[2], then Register MapCAB3toDfi should be 2.  - LPDDR4 ACX3 registers MapCAB[0..9]toDfi are reserved, second channel not supported.  - LPDDR4 ACX6,ACX10,ACX12 registers MapCAB[0..5]toDfi are used, values 0-5 are valid,  - values 6-15 are reserved  - registers MapCAB[6..9]toDfi are reserved  - LPDDR3 ACX3 not supported.  - LPDDR3 ACX6 registers MapCAB[0..9] are unused, second channel not supported.  - LPDDR3 ACX10,ACX12 registers MapCAB[0..9]toDfi are used, values 0-9 are valid,  - values 10-15 are reserved RESET:0x3"
          
group.long  0x228++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB4TODFI, Maps PHY CAB lane 4 from dfi1_address of the index of the register contents RESET:0x4"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB4TODFI_MAPCAB4TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi1_address to CAB 4.  - Unused for DDR3 and unused for DDR4 applications.  - Unused for the 3-ANIB configuration. Each register in the set of MapCABtoDfi must have a unique value within the set.  For example, if PHY CAB4 is mapped from dfi1_address[2], then Register MapCAB4toDfi should be 2.  - LPDDR4 ACX3 registers MapCAB[0..9]toDfi are reserved, second channel not supported.  - LPDDR4 ACX6,ACX10,ACX12 registers MapCAB[0..5]toDfi are used, values 0-5 are valid,  - values 6-15 are reserved  - registers MapCAB[6..9]toDfi are reserved  - LPDDR3 ACX3 not supported.  - LPDDR3 ACX6 registers MapCAB[0..9] are unused, second channel not supported.  - LPDDR3 ACX10,ACX12 registers MapCAB[0..9]toDfi are used, values 0-9 are valid,  - values 10-15 are reserved RESET:0x4"
          
group.long  0x22a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB5TODFI, Maps PHY CAB lane 5 from dfi1_address of the index of the register contents RESET:0x5"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB5TODFI_MAPCAB5TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi1_address to CAB 5.  - Unused for DDR3 and unused for DDR4 applications.  - Unused for the 3-ANIB configuration. Each register in the set of MapCABtoDfi must have a unique value within the set.  For example, if PHY CAB5 is mapped from dfi1_address[2], then Register MapCAB5toDfi should be 2.  - LPDDR4 ACX3 registers MapCAB[0..9]toDfi are reserved, second channel not supported.  - LPDDR4 ACX6,ACX10,ACX12 registers MapCAB[0..5]toDfi are used, values 0-5 are valid,  - values 6-15 are reserved  - registers MapCAB[6..9]toDfi are reserved  - LPDDR3 ACX3 not supported.  - LPDDR3 ACX6 registers MapCAB[0..9] are unused, second channel not supported.  - LPDDR3 ACX10,ACX12 registers MapCAB[0..9]toDfi are used, values 0-9 are valid,  - values 10-15 are reserved RESET:0x5"
          
group.long  0x22c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB6TODFI, Maps PHY CAB lane 6 from dfi1_address of the index of the register contents RESET:0x6"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB6TODFI_MAPCAB6TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi1_address to CAB 6.  - Unused for DDR3 and unused for DDR4 applications.  - Unused for the 3-ANIB configuration. Each register in the set of MapCABtoDfi must have a unique value within the set.  For example, if PHY CAB6 is mapped from dfi1_address[2], then Register MapCAB6toDfi should be 2.  - LPDDR4 ACX3 registers MapCAB[0..9]toDfi are reserved, second channel not supported.  - LPDDR4 ACX6,ACX10,ACX12 registers MapCAB[0..5]toDfi are used, values 0-5 are valid,  - values 6-15 are reserved  - registers MapCAB[6..9]toDfi are reserved  - LPDDR3 ACX3 not supported.  - LPDDR3 ACX6 registers MapCAB[0..9] are unused, second channel not supported.  - LPDDR3 ACX10,ACX12 registers MapCAB[0..9]toDfi are used, values 0-9 are valid,  - values 10-15 are reserved RESET:0x6"
          
group.long  0x22e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB7TODFI, Maps PHY CAB lane 7 from dfi1_address of the index of the register contents RESET:0x7"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB7TODFI_MAPCAB7TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi1_address to CAB 7.  - Unused for DDR3 and unused for DDR4 applications.  - Unused for the 3-ANIB configuration. Each register in the set of MapCABtoDfi must have a unique value within the set.  For example, if PHY CAB7 is mapped from dfi1_address[2], then Register MapCAB7toDfi should be 2.  - LPDDR4 ACX3 registers MapCAB[0..9]toDfi are reserved, second channel not supported.  - LPDDR4 ACX6,ACX10,ACX12 registers MapCAB[0..5]toDfi are used, values 0-5 are valid,  - values 6-15 are reserved  - registers MapCAB[6..9]toDfi are reserved  - LPDDR3 ACX3 not supported.  - LPDDR3 ACX6 registers MapCAB[0..9] are unused, second channel not supported.  - LPDDR3 ACX10,ACX12 registers MapCAB[0..9]toDfi are used, values 0-9 are valid,  - values 10-15 are reserved RESET:0x7"
          
group.long  0x230++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB8TODFI, Maps PHY CAB lane 8 from dfi1_address of the index of the register contents RESET:0x8"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB8TODFI_MAPCAB8TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi1_address to CAB 8.  - Unused for DDR3 and unused for DDR4 applications.  - Unused for the 3-ANIB configuration. Each register in the set of MapCABtoDfi must have a unique value within the set.  For example, if PHY CAB8 is mapped from dfi1_address[2], then Register MapCAB8toDfi should be 2.  - LPDDR4 ACX3 registers MapCAB[0..9]toDfi are reserved, second channel not supported.  - LPDDR4 ACX6,ACX10,ACX12 registers MapCAB[0..5]toDfi are used, values 0-5 are valid,  - values 6-15 are reserved  - registers MapCAB[6..9]toDfi are reserved  - LPDDR3 ACX3 not supported.  - LPDDR3 ACX6 registers MapCAB[0..9] are unused, second channel not supported.  - LPDDR3 ACX10,ACX12 registers MapCAB[0..9]toDfi are used, values 0-9 are valid,  - values 10-15 are reserved RESET:0x8"
          
group.long  0x232++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB9TODFI, Maps PHY CAB lane 9 from dfi1_address of the index of the register contents RESET:0x9"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_MAPCAB9TODFI_MAPCAB9TODFI ,For LPDDR3 and LPDDR4 applications, these CSRs map a dfi1_address to CAB 9.  - Unused for DDR3 and unused for DDR4 applications.  - Unused for the 3-ANIB configuration. Each register in the set of MapCABtoDfi must have a unique value within the set.  For example, if PHY CAB9 is mapped from dfi1_address[2], then Register MapCAB9toDfi should be 2.  - LPDDR4 ACX3 registers MapCAB[0..9]toDfi are reserved, second channel not supported.  - LPDDR4 ACX6,ACX10,ACX12 registers MapCAB[0..5]toDfi are used, values 0-5 are valid,  - values 6-15 are reserved  - registers MapCAB[6..9]toDfi are reserved  - LPDDR3 ACX3 not supported.  - LPDDR3 ACX6 registers MapCAB[0..9] are unused, second channel not supported.  - LPDDR3 ACX10,ACX12 registers MapCAB[0..9]toDfi are used, values 0-9 are valid,  - values 10-15 are reserved RESET:0x9"
          
group.long  0x236++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTENABLE, Enables various interrupts to appear in the PhyInterruptStatus CSR. Only interrupts which are enabled by writing a 1 to the appropriate location in this CSR will be observable in the PhyInterruptStatus CSR. If a 0 is written in a particular location the corresponding interrupt will not be visible in the PhyInterruptStatus CSR. See the description of PhyInterruptStatus for more information on specific interrupts. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTENABLE_PHYTRNGCMPLTEN ,Enable for the PHY Training Complete interrupt. - 0 : Interrupt not enabled - 1 : Interrupt enabled RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTENABLE_PHYINITCMPLTEN ,Enable for the PHY Initialization Complete interrupt. - 0 : Interrupt not enabled - 1 : Interrupt enabled RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTENABLE_PHYTRNGFAILEN ,Enable for the PHY Training Failure interrupt. - 0 : Interrupt not enabled - 1 : Interrupt enabled RESET:0x0"
          
         hexmask.long 0x00 3.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTENABLE_PHYFWRESERVEDEN ,Reserved RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTENABLE_PHYVTDRIFTALARMEN ,Reserved RESET:0x0"
          
         bitfld.long 0x00 10. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTENABLE_PHYRXFIFOCHECKEN ,Enable for the RxFifo Pointers Check Interrupt - 0 : Interrupt not enabled - 1 : Interrupt enabled RESET:0x0"
          
         hexmask.long 0x00 11.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTENABLE_PHYHWRESERVEDEN ,Reserved RESET:0x0"
          
group.long  0x238++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTFWCONTROL, A 0 to 1 transition for any of the interrupts will set the corresponding bit  location in the PhyInterruptStatus CSR if the corresponding bit location in the PhyInterruptEnable CSR is set to 1. See the description of PhyInterruptStatus for more information on specific interrupts. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTFWCONTROL_PHYTRNGCMPLTFW ,PHY Training Complete Firmware interrupt. Written only by PHY Firmware. - 0 : Interrupt not asserted - 1 : Interrupt asserted RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTFWCONTROL_PHYINITCMPLTFW ,Reserved RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTFWCONTROL_PHYTRNGFAILFW ,PHY Training Failure Firmware interrupt. Written only by PHY Firmware. - 0 : Interrupt not asserted - 1 : Interrupt asserted RESET:0x0"
          
         hexmask.long 0x00 3.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTFWCONTROL_PHYFWRESERVEDFW ,Implemented, reserved for future use. - 0 : Interrupt not asserted - 1 : Interrupt asserted - Reserved RESET:0x0"
          
group.long  0x23a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTMASK, This register is used to mask various interrupts to prevent them from affecting the output pin dwc_ddrphy_int_n. Only interrupts which are not masked by clearing to 0 the corresponding location in this CSR will be able to affect the dwc_ddrphy_int_n output when asserted in the PhyInterruptStatus CSR.  If a 1 is written in a particular location that interrupt will still be visible in the PhyInterruptStatus CSR but that interrupt will not affect the output pin dwc_ddrphy_int_n. See the description of PhyInterruptStatus for more information on specific interrupts. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTMASK_PHYTRNGCMPLTMSK ,Mask for the PHY Training Complete interrupt. - 0 : Interrupt not masked - 1 : Interrupt masked RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTMASK_PHYINITCMPLTMSK ,Mask for the PHY Initialization Complete interrupt. - 0 : Interrupt not masked - 1 : Interrupt masked RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTMASK_PHYTRNGFAILMSK ,Mask for the PHY Training Failure interrupt. - 0 : Interrupt not masked - 1 : Interrupt masked RESET:0x0"
          
         hexmask.long 0x00 3.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTMASK_PHYFWRESERVEDMSK ,Reserved RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTMASK_PHYVTDRIFTALARMMSK ,Reserved RESET:0x0"
          
         bitfld.long 0x00 10. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTMASK_PHYRXFIFOCHECKMSK ,Mask for the RxFifo Pointers Check Interrupt - 0 : Interrupt not masked - 1 : Interrupt masked RESET:0x0"
          
         hexmask.long 0x00 11.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTMASK_PHYHWRESERVEDMSK ,Reserved RESET:0x0"
          
group.long  0x23c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTCLEAR, This register clears various interrupts and will negate the output pin dwc_ddrphy_int_n if the cleared interrupt was the cause of the assertion of the output pin dwc_ddrphy_int_n.  A 0 to 1 transition on a bit will clear the corresponding interrupt, and cause the hardware to immediately clear the bit. See the description of PhyInterruptStatus for more information on specific interrupts. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTCLEAR_PHYTRNGCMPLTCLR ,Clear for the PHY Training Complete interrupt. - 0 : Interrupt not affected - 1 : Interrupt cleared RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTCLEAR_PHYINITCMPLTCLR ,Clear for the PHY Initialization Complete interrupt. - 0 : Interrupt not affected - 1 : Interrupt cleared RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTCLEAR_PHYTRNGFAILCLR ,Clear for the PHY Training Failure interrupt. - 0 : Interrupt not affected - 1 : Interrupt cleared RESET:0x0"
          
         hexmask.long 0x00 3.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTCLEAR_PHYFWRESERVEDCLR ,Reserved RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTCLEAR_PHYVTDRIFTALARMCLR ,Reserved RESET:0x0"
          
         bitfld.long 0x00 10. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTCLEAR_PHYRXFIFOCHECKCLR ,Clear for the RxFifo Pointers Check Interrupt - 0 : Interrupt not affected - 1 : Interrupt cleared RESET:0x0"
          
         hexmask.long 0x00 11.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTCLEAR_PHYHWRESERVEDCLR ,Reserved RESET:0x0"
          
rgroup.long 0x23e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTSTATUS, This register displays the current status of various PHY interrupts. This is a read only CSR. The PHY is the only entity which can write to it.  In order for a bit to become set in the PhyInterruptStatus CSR the corresponding bit must be set in the PhyInterruptEnable CSR.  If an interrupt is set in the PhyInterruptStatus CSR and the corresponding bit in the PhyInterruptMask CSR is cleared the dwc_ddrphy_int_n output signal will be asserted. Once the dwc_ddrphy_int_n output signal is asserted it can only be negated when all unmasked interrupts in the PhyInterruptStatus CSR have been cleared by writing the corresponding bit in the PhyInterruptClear CSR to 1. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTSTATUS_PHYTRNGCMPLT ,PHY Training Complete interrupt. Assertion of this interrupt indicates that the PHY has successfully trained the memory interface at all indicated frequencies and is ready for the PHY Initialization Engine to be loaded.  - 0 : Interrupt not enabled and asserted  - 1 : Interrupt enabled and asserted RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTSTATUS_PHYINITCMPLT ,PHY Initialization Complete interrupt. Written by the user. Assertion of this interrupt is meant to indicate that the PHY Initialization Engine has been fully loaded and dfi_init_complete has been asserted.  - 0 : Interrupt not enabled and asserted  - 1 : Interrupt enabled and asserted RESET:0x0"
          
         bitfld.long 0x00 2. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTSTATUS_PHYTRNGFAIL ,PHY Training Failure interrupt. Assertion of this interrupt indicates there was an issue during training which did not allow the PHY to successfully complete training.  - 0 : Interrupt not enabled and asserted  - 1 : Interrupt enabled and asserted RESET:0x0"
          
         hexmask.long 0x00 3.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTSTATUS_PHYFWRESERVED ,Reserved RESET:0x0"
          
         hexmask.long 0x00 8.--9. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTSTATUS_VTDRIFTALARM ,Reserved RESET:0x0"
          
         bitfld.long 0x00 10. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTSTATUS_PHYRXFIFOCHECK ,A mechanism in the PHY checks the Read Fifo pointers for consistency at times they are idle. If a check fails, this interrupt is asserted, and detailed status is found in the RxFifoCheckStatus register.  - 0 : Interrupt not enabled and asserted  - 1 : Interrupt enabled and asserted RESET:0x0"
          
         hexmask.long 0x00 11.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_PHYINTERRUPTSTATUS_PHYHWRESERVED ,Reserved RESET:0x0"
          
group.long  0x240++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS0, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS0_HWTSWIZZLEHWTADDRESS0 ,This set of registers is used in DDR3/DDR4 mode where a user has re-mapped the DFI inputs to the PHY. This register does not affect the mapping of those signals, or remap the tristate properties of the bumps. However, when the user remaps the DFI signals, the HWT inputs must be mapped in a similar fashion using this register.  Each remappable hwt bit has a register associated with it. When the register value is zero, the bit is not re-mapped. When the register value is non-zero, the signal associated with the number in the table below is mapped to the signal associated with the register. So, for example, if the value for the register associated with hwt_act_n (HwtSwizzleHwtActN) is set to 27, then hwt_parity_in will be mapped to hwt_act_n.  Note: These registers should always be 0 for LPDDR3 and LPDDR4.  Some registers are used only for DDR3 or DDR4. These are noted in the descriptions.  - 0: No-remapping  - 1: hwt_address[0]  - 2: hwt_address[1]  - 3: hwt_address[2]  - 4: hwt_address[3]  - 5: hwt_address[4]  - 6: hwt_address[5]  - 7: hwt_address[6]  - 8: hwt_address[7]  - 9: hwt_address[8]  - 10: hwt_address[9]  - 11: hwt_address[10]  - 12: hwt_address[11]  - 13: hwt_address[12]  - 14: hwt_address[13]  - 15: hwt_address[14]  (DDR3 Only)  - 16: hwt_address[15]  (DDR3 Only)  - 17: hwt_address[17]  (DDR4 Only)  - 18: hwt_act_n  (DDR4 Only)  - 19: hwt_bank[0]  - 20: hwt_bank[1]  - 21: hwt_bank[2]  (DDR3 Only)  - 22: hwt_bg[0]  (DDR4 Only)  - 23: hwt_bg[1]  (DDR4 Only)  - 24: hwt_cas_n  - 25: hwt_ras_n  - 26: hwt_we_n  - 27: hwt_parity_in RESET:0x0"
          
group.long  0x242++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS1, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS1_HWTSWIZZLEHWTADDRESS1 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x244++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS2, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS2_HWTSWIZZLEHWTADDRESS2 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x246++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS3, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS3_HWTSWIZZLEHWTADDRESS3 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x248++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS4, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS4_HWTSWIZZLEHWTADDRESS4 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x24a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS5, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS5_HWTSWIZZLEHWTADDRESS5 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x24c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS6, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS6_HWTSWIZZLEHWTADDRESS6 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x24e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS7, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS7_HWTSWIZZLEHWTADDRESS7 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x250++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS8, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS8_HWTSWIZZLEHWTADDRESS8 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x252++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS9, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS9_HWTSWIZZLEHWTADDRESS9 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x254++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS10, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS10_HWTSWIZZLEHWTADDRESS10 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x256++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS11, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS11_HWTSWIZZLEHWTADDRESS11 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x258++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS12, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS12_HWTSWIZZLEHWTADDRESS12 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x25a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS13, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS13_HWTSWIZZLEHWTADDRESS13 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x25c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS14, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS14_HWTSWIZZLEHWTADDRESS14 ,See Description of HwtSwizzleHwtAddress0 for details. Used only for DDR3. RESET:0x0"
          
group.long  0x25e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS15, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS15_HWTSWIZZLEHWTADDRESS15 ,See Description of HwtSwizzleHwtAddress0 for details. Used only for DDR3. RESET:0x0"
          
group.long  0x260++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS17, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTADDRESS17_HWTSWIZZLEHWTADDRESS17 ,See Description of HwtSwizzleHwtAddress0 for details. Used only for DDR4. RESET:0x0"
          
group.long  0x262++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTACTN, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTACTN_HWTSWIZZLEHWTACTN ,See Description of HwtSwizzleHwtAddress0 for details. Used only for DDR4. RESET:0x0"
          
group.long  0x264++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTBANK0, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTBANK0_HWTSWIZZLEHWTBANK0 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x266++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTBANK1, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTBANK1_HWTSWIZZLEHWTBANK1 ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x268++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTBANK2, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTBANK2_HWTSWIZZLEHWTBANK2 ,See Description of HwtSwizzleHwtAddress0 for details. Used only for DDR3. RESET:0x0"
          
group.long  0x26a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTBG0, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTBG0_HWTSWIZZLEHWTBG0 ,See Description of HwtSwizzleHwtAddress0 for details. Used only for DDR4. RESET:0x0"
          
group.long  0x26c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTBG1, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTBG1_HWTSWIZZLEHWTBG1 ,See Description of HwtSwizzleHwtAddress0 for details. Used only for DDR4. RESET:0x0"
          
group.long  0x26e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTCASN, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTCASN_HWTSWIZZLEHWTCASN ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x270++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTRASN, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTRASN_HWTSWIZZLEHWTRASN ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x272++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTWEN, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTWEN_HWTSWIZZLEHWTWEN ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x274++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTPARITYIN, Signal swizzle selection for HWT swizzle RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_HWTSWIZZLEHWTPARITYIN_HWTSWIZZLEHWTPARITYIN ,See Description of HwtSwizzleHwtAddress0 for details. RESET:0x0"
          
group.long  0x278++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIHANDSHAKEDELAYS0, Add assertion/deassertion delays on handshake signals. Logic assumes that dfi signal assertions exceed the programmed delays RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIHANDSHAKEDELAYS0_PHYUPDACKDELAY0 ,Adds 0-15 DfiClks of delay after dfi0_phyupd_ack asserts, before the PHY takes any action (such as starting DDL calibration). RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIHANDSHAKEDELAYS0_PHYUPDREQDELAY0 ,Adds 0-15 DfiClks of delay after the PHY completes all PHY update activities, before de-asserting dfi0_phyupd_req. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIHANDSHAKEDELAYS0_CTRLUPDACKDELAY0 ,Adds 0-15 DfiClks of delay after dfi0_ctrlupd_req asserts, before the PHY takes any action. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIHANDSHAKEDELAYS0_CTRLUPDREQDELAY0 ,Adds 0-15 DfiClks of delay after the PHY completes all PHY update activities, before de-asserting dfi0_ctrlupd_ack. RESET:0x0"
          
group.long  0x27a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIHANDSHAKEDELAYS1, Add assertion/deassertion delays on handshake signals. Logic assumes that dfi signal assertions exceed the programmed delays RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIHANDSHAKEDELAYS1_PHYUPDACKDELAY1 ,Adds 0-15 DfiClks of delay after dfi1_phyupd_ack asserts, before the PHY takes any action (such as starting DDL calibration). RESET:0x0"
          
         hexmask.long 0x00 4.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIHANDSHAKEDELAYS1_PHYUPDREQDELAY1 ,Adds 0-15 DfiClks of delay after the PHY completes all PHY update activities, before de-asserting dfi1_phyupd_req. RESET:0x0"
          
         hexmask.long 0x00 8.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIHANDSHAKEDELAYS1_CTRLUPDACKDELAY1 ,Adds 0-15 DfiClks of delay after dfi1_ctrlupd_req asserts, before the PHY takes any action. RESET:0x0"
          
         hexmask.long 0x00 12.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_DFIHANDSHAKEDELAYS1_CTRLUPDREQDELAY1 ,Adds 0-15 DfiClks of delay after the PHY completes all PHY update activities, before de-asserting dfi1_ctrlupd_ack. RESET:0x0"
          
rgroup.long 0x27c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_REMOTEIMPCAL, This CSR is written by HW to provide information about remote impedance calibration status. The CSR value allows SW to determine if the PHY is acting as calibration slave (1) or master (0). If PHY is acting as calibration slave then this CSR can be checked to determine if calibration codes have been captured. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_REMOTEIMPCAL_CALIBSLAVE ,- if DWC_DDRPHY_REMOTE_IMP_CAL is defined, HW sets this field when the PHY is acting as calibration slave. - if DWC_DDRPHY_REMOTE_IMP_CAL is not defined, this field is reserved. RESET:0x0"
          
         bitfld.long 0x00 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_REMOTEIMPCAL_SLAVECODEUPDATED ,- if DWC_DDRPHY_REMOTE_IMP_CAL is defined, HW sets this field when PHY is acting as calibration slave and calibration codes from the master have been loaded. - if DWC_DDRPHY_REMOTE_IMP_CAL is not defined, this field is reserved. RESET:0x0"
          
group.long  0x27e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ACLOOPBACKCTL, Reserved for future use RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_MASTER0_P0_ACLOOPBACKCTL_RFU_ACLOOPBACKCTL ,None RESET:0x0"
          
tree.end
    

tree "LPDDR4_PUB__DWC_DDRPHYA_ACSM0_P0"
base e:0x42080000
width 80.
group.long  0x0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X0_RFU_ACSMSEQ0X0 ,None RESET:0x0"
          
group.long  0x2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X1_RFU_ACSMSEQ0X1 ,None RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X2_RFU_ACSMSEQ0X2 ,None RESET:0x0"
          
group.long  0x6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X3_RFU_ACSMSEQ0X3 ,None RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X4_RFU_ACSMSEQ0X4 ,None RESET:0x0"
          
group.long  0xa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X5_RFU_ACSMSEQ0X5 ,None RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X6_RFU_ACSMSEQ0X6 ,None RESET:0x0"
          
group.long  0xe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X7_RFU_ACSMSEQ0X7 ,None RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X8_RFU_ACSMSEQ0X8 ,None RESET:0x0"
          
group.long  0x12++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X9, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X9_RFU_ACSMSEQ0X9 ,None RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X10, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X10_RFU_ACSMSEQ0X10 ,None RESET:0x0"
          
group.long  0x16++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X11, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X11_RFU_ACSMSEQ0X11 ,None RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X12, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X12_RFU_ACSMSEQ0X12 ,None RESET:0x0"
          
group.long  0x1a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X13, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X13_RFU_ACSMSEQ0X13 ,None RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X14, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X14_RFU_ACSMSEQ0X14 ,None RESET:0x0"
          
group.long  0x1e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X15, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X15_RFU_ACSMSEQ0X15 ,None RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X16, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X16_RFU_ACSMSEQ0X16 ,None RESET:0x0"
          
group.long  0x22++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X17, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X17_RFU_ACSMSEQ0X17 ,None RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X18, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X18_RFU_ACSMSEQ0X18 ,None RESET:0x0"
          
group.long  0x26++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X19, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X19_RFU_ACSMSEQ0X19 ,None RESET:0x0"
          
group.long  0x28++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X20, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X20_RFU_ACSMSEQ0X20 ,None RESET:0x0"
          
group.long  0x2a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X21, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X21_RFU_ACSMSEQ0X21 ,None RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X22, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X22_RFU_ACSMSEQ0X22 ,None RESET:0x0"
          
group.long  0x2e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X23, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X23_RFU_ACSMSEQ0X23 ,None RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X24, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X24_RFU_ACSMSEQ0X24 ,None RESET:0x0"
          
group.long  0x32++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X25, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X25_RFU_ACSMSEQ0X25 ,None RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X26, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X26_RFU_ACSMSEQ0X26 ,None RESET:0x0"
          
group.long  0x36++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X27, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X27_RFU_ACSMSEQ0X27 ,None RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X28, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X28_RFU_ACSMSEQ0X28 ,None RESET:0x0"
          
group.long  0x3a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X29, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X29_RFU_ACSMSEQ0X29 ,None RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X30, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X30_RFU_ACSMSEQ0X30 ,None RESET:0x0"
          
group.long  0x3e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X31, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ0X31_RFU_ACSMSEQ0X31 ,None RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X0_RFU_ACSMSEQ1X0 ,None RESET:0x0"
          
group.long  0x42++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X1_RFU_ACSMSEQ1X1 ,None RESET:0x0"
          
group.long  0x44++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X2_RFU_ACSMSEQ1X2 ,None RESET:0x0"
          
group.long  0x46++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X3_RFU_ACSMSEQ1X3 ,None RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X4_RFU_ACSMSEQ1X4 ,None RESET:0x0"
          
group.long  0x4a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X5_RFU_ACSMSEQ1X5 ,None RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X6_RFU_ACSMSEQ1X6 ,None RESET:0x0"
          
group.long  0x4e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X7_RFU_ACSMSEQ1X7 ,None RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X8_RFU_ACSMSEQ1X8 ,None RESET:0x0"
          
group.long  0x52++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X9, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X9_RFU_ACSMSEQ1X9 ,None RESET:0x0"
          
group.long  0x54++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X10, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X10_RFU_ACSMSEQ1X10 ,None RESET:0x0"
          
group.long  0x56++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X11, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X11_RFU_ACSMSEQ1X11 ,None RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X12, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X12_RFU_ACSMSEQ1X12 ,None RESET:0x0"
          
group.long  0x5a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X13, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X13_RFU_ACSMSEQ1X13 ,None RESET:0x0"
          
group.long  0x5c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X14, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X14_RFU_ACSMSEQ1X14 ,None RESET:0x0"
          
group.long  0x5e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X15, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X15_RFU_ACSMSEQ1X15 ,None RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X16, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X16_RFU_ACSMSEQ1X16 ,None RESET:0x0"
          
group.long  0x62++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X17, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X17_RFU_ACSMSEQ1X17 ,None RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X18, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X18_RFU_ACSMSEQ1X18 ,None RESET:0x0"
          
group.long  0x66++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X19, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X19_RFU_ACSMSEQ1X19 ,None RESET:0x0"
          
group.long  0x68++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X20, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X20_RFU_ACSMSEQ1X20 ,None RESET:0x0"
          
group.long  0x6a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X21, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X21_RFU_ACSMSEQ1X21 ,None RESET:0x0"
          
group.long  0x6c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X22, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X22_RFU_ACSMSEQ1X22 ,None RESET:0x0"
          
group.long  0x6e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X23, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X23_RFU_ACSMSEQ1X23 ,None RESET:0x0"
          
group.long  0x70++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X24, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X24_RFU_ACSMSEQ1X24 ,None RESET:0x0"
          
group.long  0x72++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X25, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X25_RFU_ACSMSEQ1X25 ,None RESET:0x0"
          
group.long  0x74++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X26, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X26_RFU_ACSMSEQ1X26 ,None RESET:0x0"
          
group.long  0x76++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X27, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X27_RFU_ACSMSEQ1X27 ,None RESET:0x0"
          
group.long  0x78++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X28, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X28_RFU_ACSMSEQ1X28 ,None RESET:0x0"
          
group.long  0x7a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X29, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X29_RFU_ACSMSEQ1X29 ,None RESET:0x0"
          
group.long  0x7c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X30, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X30_RFU_ACSMSEQ1X30 ,None RESET:0x0"
          
group.long  0x7e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X31, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ1X31_RFU_ACSMSEQ1X31 ,None RESET:0x0"
          
group.long  0x80++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X0_RFU_ACSMSEQ2X0 ,None RESET:0x0"
          
group.long  0x82++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X1_RFU_ACSMSEQ2X1 ,None RESET:0x0"
          
group.long  0x84++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X2_RFU_ACSMSEQ2X2 ,None RESET:0x0"
          
group.long  0x86++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X3_RFU_ACSMSEQ2X3 ,None RESET:0x0"
          
group.long  0x88++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X4_RFU_ACSMSEQ2X4 ,None RESET:0x0"
          
group.long  0x8a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X5_RFU_ACSMSEQ2X5 ,None RESET:0x0"
          
group.long  0x8c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X6_RFU_ACSMSEQ2X6 ,None RESET:0x0"
          
group.long  0x8e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X7_RFU_ACSMSEQ2X7 ,None RESET:0x0"
          
group.long  0x90++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X8_RFU_ACSMSEQ2X8 ,None RESET:0x0"
          
group.long  0x92++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X9, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X9_RFU_ACSMSEQ2X9 ,None RESET:0x0"
          
group.long  0x94++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X10, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X10_RFU_ACSMSEQ2X10 ,None RESET:0x0"
          
group.long  0x96++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X11, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X11_RFU_ACSMSEQ2X11 ,None RESET:0x0"
          
group.long  0x98++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X12, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X12_RFU_ACSMSEQ2X12 ,None RESET:0x0"
          
group.long  0x9a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X13, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X13_RFU_ACSMSEQ2X13 ,None RESET:0x0"
          
group.long  0x9c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X14, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X14_RFU_ACSMSEQ2X14 ,None RESET:0x0"
          
group.long  0x9e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X15, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X15_RFU_ACSMSEQ2X15 ,None RESET:0x0"
          
group.long  0xa0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X16, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X16_RFU_ACSMSEQ2X16 ,None RESET:0x0"
          
group.long  0xa2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X17, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X17_RFU_ACSMSEQ2X17 ,None RESET:0x0"
          
group.long  0xa4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X18, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X18_RFU_ACSMSEQ2X18 ,None RESET:0x0"
          
group.long  0xa6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X19, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X19_RFU_ACSMSEQ2X19 ,None RESET:0x0"
          
group.long  0xa8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X20, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X20_RFU_ACSMSEQ2X20 ,None RESET:0x0"
          
group.long  0xaa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X21, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X21_RFU_ACSMSEQ2X21 ,None RESET:0x0"
          
group.long  0xac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X22, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X22_RFU_ACSMSEQ2X22 ,None RESET:0x0"
          
group.long  0xae++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X23, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X23_RFU_ACSMSEQ2X23 ,None RESET:0x0"
          
group.long  0xb0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X24, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X24_RFU_ACSMSEQ2X24 ,None RESET:0x0"
          
group.long  0xb2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X25, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X25_RFU_ACSMSEQ2X25 ,None RESET:0x0"
          
group.long  0xb4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X26, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X26_RFU_ACSMSEQ2X26 ,None RESET:0x0"
          
group.long  0xb6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X27, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X27_RFU_ACSMSEQ2X27 ,None RESET:0x0"
          
group.long  0xb8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X28, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X28_RFU_ACSMSEQ2X28 ,None RESET:0x0"
          
group.long  0xba++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X29, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X29_RFU_ACSMSEQ2X29 ,None RESET:0x0"
          
group.long  0xbc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X30, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X30_RFU_ACSMSEQ2X30 ,None RESET:0x0"
          
group.long  0xbe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X31, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ2X31_RFU_ACSMSEQ2X31 ,None RESET:0x0"
          
group.long  0xc0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X0_RFU_ACSMSEQ3X0 ,None RESET:0x0"
          
group.long  0xc2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X1_RFU_ACSMSEQ3X1 ,None RESET:0x0"
          
group.long  0xc4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X2_RFU_ACSMSEQ3X2 ,None RESET:0x0"
          
group.long  0xc6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X3_RFU_ACSMSEQ3X3 ,None RESET:0x0"
          
group.long  0xc8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X4_RFU_ACSMSEQ3X4 ,None RESET:0x0"
          
group.long  0xca++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X5_RFU_ACSMSEQ3X5 ,None RESET:0x0"
          
group.long  0xcc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X6_RFU_ACSMSEQ3X6 ,None RESET:0x0"
          
group.long  0xce++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X7_RFU_ACSMSEQ3X7 ,None RESET:0x0"
          
group.long  0xd0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X8_RFU_ACSMSEQ3X8 ,None RESET:0x0"
          
group.long  0xd2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X9, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X9_RFU_ACSMSEQ3X9 ,None RESET:0x0"
          
group.long  0xd4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X10, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X10_RFU_ACSMSEQ3X10 ,None RESET:0x0"
          
group.long  0xd6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X11, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X11_RFU_ACSMSEQ3X11 ,None RESET:0x0"
          
group.long  0xd8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X12, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X12_RFU_ACSMSEQ3X12 ,None RESET:0x0"
          
group.long  0xda++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X13, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X13_RFU_ACSMSEQ3X13 ,None RESET:0x0"
          
group.long  0xdc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X14, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X14_RFU_ACSMSEQ3X14 ,None RESET:0x0"
          
group.long  0xde++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X15, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X15_RFU_ACSMSEQ3X15 ,None RESET:0x0"
          
group.long  0xe0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X16, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X16_RFU_ACSMSEQ3X16 ,None RESET:0x0"
          
group.long  0xe2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X17, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X17_RFU_ACSMSEQ3X17 ,None RESET:0x0"
          
group.long  0xe4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X18, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X18_RFU_ACSMSEQ3X18 ,None RESET:0x0"
          
group.long  0xe6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X19, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X19_RFU_ACSMSEQ3X19 ,None RESET:0x0"
          
group.long  0xe8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X20, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X20_RFU_ACSMSEQ3X20 ,None RESET:0x0"
          
group.long  0xea++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X21, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X21_RFU_ACSMSEQ3X21 ,None RESET:0x0"
          
group.long  0xec++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X22, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X22_RFU_ACSMSEQ3X22 ,None RESET:0x0"
          
group.long  0xee++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X23, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X23_RFU_ACSMSEQ3X23 ,None RESET:0x0"
          
group.long  0xf0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X24, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X24_RFU_ACSMSEQ3X24 ,None RESET:0x0"
          
group.long  0xf2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X25, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X25_RFU_ACSMSEQ3X25 ,None RESET:0x0"
          
group.long  0xf4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X26, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X26_RFU_ACSMSEQ3X26 ,None RESET:0x0"
          
group.long  0xf6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X27, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X27_RFU_ACSMSEQ3X27 ,None RESET:0x0"
          
group.long  0xf8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X28, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X28_RFU_ACSMSEQ3X28 ,None RESET:0x0"
          
group.long  0xfa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X29, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X29_RFU_ACSMSEQ3X29 ,None RESET:0x0"
          
group.long  0xfc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X30, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X30_RFU_ACSMSEQ3X30 ,None RESET:0x0"
          
group.long  0xfe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X31, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMSEQ3X31_RFU_ACSMSEQ3X31 ,None RESET:0x0"
          
group.long  0x100++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X0_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X0_P0_ACSMPLAYBACK0X0_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x102++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X0_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X0_P0_ACSMPLAYBACK1X0_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x104++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X1_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X1_P0_ACSMPLAYBACK0X1_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x106++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X1_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X1_P0_ACSMPLAYBACK1X1_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x108++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X2_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X2_P0_ACSMPLAYBACK0X2_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x10a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X2_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X2_P0_ACSMPLAYBACK1X2_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x10c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X3_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X3_P0_ACSMPLAYBACK0X3_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x10e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X3_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X3_P0_ACSMPLAYBACK1X3_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x110++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X4_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X4_P0_ACSMPLAYBACK0X4_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x112++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X4_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X4_P0_ACSMPLAYBACK1X4_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x114++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X5_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X5_P0_ACSMPLAYBACK0X5_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x116++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X5_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X5_P0_ACSMPLAYBACK1X5_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x118++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X6_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X6_P0_ACSMPLAYBACK0X6_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x11a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X6_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X6_P0_ACSMPLAYBACK1X6_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x11c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X7_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK0X7_P0_ACSMPLAYBACK0X7_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x11e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X7_P0, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPLAYBACK1X7_P0_ACSMPLAYBACK1X7_P0 ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for protocols that support DRAM drift compensation. RESET:0x0"
          
group.long  0x120++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPSTATEOVREN, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for Controlling Playback Engine RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPSTATEOVREN_ACSMPSTATEOVREN ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for Controlling Playback Engine RESET:0x0"
          
group.long  0x122++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPSTATEOVRVAL, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for Controlling Playback Engine RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMPSTATEOVRVAL_ACSMPSTATEOVRVAL ,Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() for Controlling Playback Engine RESET:0x0"
          
group.long  0x180++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL23, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--12. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL23_RFU_ACSMCTRL23 ,None RESET:0x0"
          
group.long  0x184++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCKEVAL, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCKEVAL_ACSMCKEVAL ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x190++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_LOWSPEEDCLOCKDIVIDER, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--5. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_LOWSPEEDCLOCKDIVIDER_LOWSPEEDCLOCKDIVIDER ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x1a0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL0_RFU_ACSMCSMAPCTRL0 ,None RESET:0x0"
          
group.long  0x1a2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL1_RFU_ACSMCSMAPCTRL1 ,None RESET:0x0"
          
group.long  0x1a4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL2_RFU_ACSMCSMAPCTRL2 ,None RESET:0x0"
          
group.long  0x1a6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL3_RFU_ACSMCSMAPCTRL3 ,None RESET:0x0"
          
group.long  0x1a8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL4_RFU_ACSMCSMAPCTRL4 ,None RESET:0x0"
          
group.long  0x1aa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL5_RFU_ACSMCSMAPCTRL5 ,None RESET:0x0"
          
group.long  0x1ac++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL6_RFU_ACSMCSMAPCTRL6 ,None RESET:0x0"
          
group.long  0x1ae++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL7_RFU_ACSMCSMAPCTRL7 ,None RESET:0x0"
          
group.long  0x1b0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL8_RFU_ACSMCSMAPCTRL8 ,None RESET:0x0"
          
group.long  0x1b2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL9, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL9_RFU_ACSMCSMAPCTRL9 ,None RESET:0x0"
          
group.long  0x1b4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL10, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL10_RFU_ACSMCSMAPCTRL10 ,None RESET:0x0"
          
group.long  0x1b6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL11, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL11_RFU_ACSMCSMAPCTRL11 ,None RESET:0x0"
          
group.long  0x1b8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL12, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL12_RFU_ACSMCSMAPCTRL12 ,None RESET:0x0"
          
group.long  0x1ba++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL13, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL13_RFU_ACSMCSMAPCTRL13 ,None RESET:0x0"
          
group.long  0x1bc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL14, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL14_RFU_ACSMCSMAPCTRL14 ,None RESET:0x0"
          
group.long  0x1be++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL15, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--14. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCSMAPCTRL15_RFU_ACSMCSMAPCTRL15 ,None RESET:0x0"
          
group.long  0x1c0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL0_RFU_ACSMODTCTRL0 ,None RESET:0x0"
          
group.long  0x1c2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL1_RFU_ACSMODTCTRL1 ,None RESET:0x0"
          
group.long  0x1c4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL2_RFU_ACSMODTCTRL2 ,None RESET:0x0"
          
group.long  0x1c6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL3_RFU_ACSMODTCTRL3 ,None RESET:0x0"
          
group.long  0x1c8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL4_RFU_ACSMODTCTRL4 ,None RESET:0x0"
          
group.long  0x1ca++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL5_RFU_ACSMODTCTRL5 ,None RESET:0x0"
          
group.long  0x1cc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL6_RFU_ACSMODTCTRL6 ,None RESET:0x0"
          
group.long  0x1ce++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--7. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL7_RFU_ACSMODTCTRL7 ,None RESET:0x0"
          
group.long  0x1d0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMODTCTRL8_RFU_ACSMODTCTRL8 ,None RESET:0x0"
          
group.long  0x1d2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL16, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL16_RFU_ACSMCTRL16 ,None RESET:0x0"
          
group.long  0x1d4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_LOWSPEEDCLOCKSTOPVAL, Reserved for PHY training firmware use. RESET:0x0"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_LOWSPEEDCLOCKSTOPVAL_LOWSPEEDCLOCKSTOPVAL ,Reserved for PHY training firmware use. RESET:0x0"
          
rgroup.long 0x1d6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL18, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--1. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL18_RFU_ACSMCTRL18 ,None RESET:0x0"
          
group.long  0x1d8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL19, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL19_RFU_ACSMCTRL19 ,None RESET:0x0"
          
rgroup.long 0x1da++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL20, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL20_RFU_ACSMCTRL20 ,None RESET:0x0"
          
group.long  0x1dc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL21, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL21_RFU_ACSMCTRL21 ,None RESET:0x0"
          
group.long  0x1de++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL22, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL22_RFU_ACSMCTRL22 ,None RESET:0x0"
          
group.long  0x1e0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL0_RFU_ACSMCTRL0 ,None RESET:0x0"
          
group.long  0x1e2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL1_RFU_ACSMCTRL1 ,None RESET:0x0"
          
group.long  0x1e4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL2_RFU_ACSMCTRL2 ,None RESET:0x0"
          
group.long  0x1e6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL3_RFU_ACSMCTRL3 ,None RESET:0x0"
          
group.long  0x1e8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL4_RFU_ACSMCTRL4 ,None RESET:0x0"
          
group.long  0x1ea++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--13. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL5_RFU_ACSMCTRL5 ,None RESET:0x0"
          
group.long  0x1ec++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--10. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL6_RFU_ACSMCTRL6 ,None RESET:0x0"
          
group.long  0x1ee++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL7_RFU_ACSMCTRL7 ,None RESET:0x0"
          
group.long  0x1f0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL8_RFU_ACSMCTRL8 ,None RESET:0x0"
          
group.long  0x1f2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL9, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL9_RFU_ACSMCTRL9 ,None RESET:0x0"
          
group.long  0x1f4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL10, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL10_RFU_ACSMCTRL10 ,None RESET:0x0"
          
group.long  0x1f6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL11, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL11_RFU_ACSMCTRL11 ,None RESET:0x0"
          
group.long  0x1f8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL12, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL12_RFU_ACSMCTRL12 ,None RESET:0x0"
          
group.long  0x1fa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL13, Programmed by dwc_ddrphy_phyinit_I_loadPIEImage() to support frequency changes. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL13_RFU_ACSMCTRL13 ,None RESET:0x0"
          
group.long  0x1fc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL14, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL14_RFU_ACSMCTRL14 ,None RESET:0x0"
          
group.long  0x1fe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL15, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--3. 1. " LPDDR4_PUB_DWC_DDRPHYA_ACSM0_P0_ACSMCTRL15_RFU_ACSMCTRL15 ,None RESET:0x0"
          
tree.end
    

tree "LPDDR4_PUB__ICCM"
base e:0x420a0000
width 80.
tree.end
    

tree "LPDDR4_PUB__DCCM"
base e:0x420a8000
width 80.
tree.end
    

tree "LPDDR4_PUB__DWC_DDRPHYA_PPGC0"
base e:0x420e0000
width 80.
group.long  0x22++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PPGCCTRL1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 1.--4. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PPGCCTRL1_RFU_PPGCCTRL1 ,None RESET:0x0"
          
group.long  0x2a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PPGCLANE2CRCINMAP0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PPGCLANE2CRCINMAP0_RFU_PPGCLANE2CRCINMAP0 ,None RESET:0x0"
          
group.long  0x2c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PPGCLANE2CRCINMAP1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--11. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PPGCLANE2CRCINMAP1_RFU_PPGCLANE2CRCINMAP1 ,None RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I0_PRBSTAPDLY0_I0 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x4a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I0_PRBSTAPDLY1_I0 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I0_PRBSTAPDLY2_I0 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x4e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I0_PRBSTAPDLY3_I0 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE0, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE0_GENPRBSBYTE0 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x62++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE1_GENPRBSBYTE1 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x64++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE2_GENPRBSBYTE2 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x66++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE3_GENPRBSBYTE3 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x68++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE4_GENPRBSBYTE4 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x6a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE5_GENPRBSBYTE5 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x6c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE6_GENPRBSBYTE6 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x6e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE7_GENPRBSBYTE7 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x70++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE8_GENPRBSBYTE8 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x72++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE9, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE9_GENPRBSBYTE9 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x74++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE10, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE10_GENPRBSBYTE10 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x76++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE11, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE11_GENPRBSBYTE11 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x78++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE12, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE12_GENPRBSBYTE12 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x7a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE13, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE13_GENPRBSBYTE13 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x7c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE14, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE14_GENPRBSBYTE14 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x7e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE15, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_GENPRBSBYTE15_GENPRBSBYTE15 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xc0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSGENCTL, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSGENCTL_RFU_PRBSGENCTL ,None RESET:0x0"
          
group.long  0xc2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSGENSTATELO, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSGENSTATELO_PRBSGENSTATELO ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xc4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSGENSTATEHI, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSGENSTATEHI_PRBSGENSTATEHI ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xc6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSCHKSTATELO, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSCHKSTATELO_PRBSCHKSTATELO ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xc8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSCHKSTATEHI, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSCHKSTATEHI_PRBSCHKSTATEHI ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xca++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSGENCTL1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSGENCTL1_RFU_PRBSGENCTL1 ,None RESET:0x0"
          
group.long  0xcc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSGENCTL2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSGENCTL2_RFU_PRBSGENCTL2 ,None RESET:0x0"
          
group.long  0x248++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I1_PRBSTAPDLY0_I1 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x24a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I1_PRBSTAPDLY1_I1 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x24c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I1_PRBSTAPDLY2_I1 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x24e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I1, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I1_PRBSTAPDLY3_I1 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x448++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I2_PRBSTAPDLY0_I2 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x44a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I2_PRBSTAPDLY1_I2 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x44c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I2_PRBSTAPDLY2_I2 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x44e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I2, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I2_PRBSTAPDLY3_I2 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x648++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I3_PRBSTAPDLY0_I3 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x64a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I3_PRBSTAPDLY1_I3 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x64c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I3_PRBSTAPDLY2_I3 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x64e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I3, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I3_PRBSTAPDLY3_I3 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x848++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I4_PRBSTAPDLY0_I4 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x84a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I4_PRBSTAPDLY1_I4 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x84c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I4_PRBSTAPDLY2_I4 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x84e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I4, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I4_PRBSTAPDLY3_I4 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xa48++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I5_PRBSTAPDLY0_I5 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xa4a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I5_PRBSTAPDLY1_I5 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xa4c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I5_PRBSTAPDLY2_I5 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xa4e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I5, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I5_PRBSTAPDLY3_I5 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xc48++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I6_PRBSTAPDLY0_I6 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xc4a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I6_PRBSTAPDLY1_I6 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xc4c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I6_PRBSTAPDLY2_I6 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xc4e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I6, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I6_PRBSTAPDLY3_I6 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xe48++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I7_PRBSTAPDLY0_I7 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xe4a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I7_PRBSTAPDLY1_I7 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xe4c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I7_PRBSTAPDLY2_I7 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0xe4e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I7, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I7_PRBSTAPDLY3_I7 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x1048++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY0_I8_PRBSTAPDLY0_I8 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x104a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY1_I8_PRBSTAPDLY1_I8 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x104c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY2_I8_PRBSTAPDLY2_I8 ,Reserved for PHY training firmware use. RESET:0x0"
          
group.long  0x104e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I8, Reserved for PHY training firmware use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_PPGC0_PRBSTAPDLY3_I8_PRBSTAPDLY3_I8 ,Reserved for PHY training firmware use. RESET:0x0"
          
tree.end
    

tree "LPDDR4_PUB__DWC_DDRPHYA_INITENG0_P0"
base e:0x42120000
width 80.
group.long  0x0++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_PRESEQUENCEREG0B0S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_PRESEQUENCEREG0B0S0_PRESEQUENCEREG0B0S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_PRESEQUENCEREG0B0S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_PRESEQUENCEREG0B0S1_PRESEQUENCEREG0B0S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x4++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_PRESEQUENCEREG0B0S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_PRESEQUENCEREG0B0S2_PRESEQUENCEREG0B0S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x6++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_PRESEQUENCEREG0B1S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_PRESEQUENCEREG0B1S0_PRESEQUENCEREG0B1S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x8++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_PRESEQUENCEREG0B1S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_PRESEQUENCEREG0B1S1_PRESEQUENCEREG0B1S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xa++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_PRESEQUENCEREG0B1S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_PRESEQUENCEREG0B1S2_PRESEQUENCEREG0B1S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xc++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_POSTSEQUENCEREG0B0S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_POSTSEQUENCEREG0B0S0_POSTSEQUENCEREG0B0S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0xe++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_POSTSEQUENCEREG0B0S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_POSTSEQUENCEREG0B0S1_POSTSEQUENCEREG0B0S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x10++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_POSTSEQUENCEREG0B0S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_POSTSEQUENCEREG0B0S2_POSTSEQUENCEREG0B0S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x12++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_POSTSEQUENCEREG0B1S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_POSTSEQUENCEREG0B1S0_POSTSEQUENCEREG0B1S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x14++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_POSTSEQUENCEREG0B1S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_POSTSEQUENCEREG0B1S1_POSTSEQUENCEREG0B1S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x16++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_POSTSEQUENCEREG0B1S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_POSTSEQUENCEREG0B1S2_POSTSEQUENCEREG0B1S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x18++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG0_SEQ0BDISABLEFLAG0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG1_SEQ0BDISABLEFLAG1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG2_SEQ0BDISABLEFLAG2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x1e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG3, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG3_SEQ0BDISABLEFLAG3 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x20++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG4, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG4_SEQ0BDISABLEFLAG4 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x22++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG5, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG5_SEQ0BDISABLEFLAG5 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x24++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG6, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG6_SEQ0BDISABLEFLAG6 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x26++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG7, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BDISABLEFLAG7_SEQ0BDISABLEFLAG7 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x2e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B0_RFU_STARTVECTOR0B0 ,None RESET:0x0"
          
group.long  0x30++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B1_RFU_STARTVECTOR0B1 ,None RESET:0x0"
          
group.long  0x32++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B2_RFU_STARTVECTOR0B2 ,None RESET:0x0"
          
group.long  0x34++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B3, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B3_RFU_STARTVECTOR0B3 ,None RESET:0x0"
          
group.long  0x36++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B4, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B4_RFU_STARTVECTOR0B4 ,None RESET:0x0"
          
group.long  0x38++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B5, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B5_RFU_STARTVECTOR0B5 ,None RESET:0x0"
          
group.long  0x3a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B6, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B6_RFU_STARTVECTOR0B6 ,None RESET:0x0"
          
group.long  0x3c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B7, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B7_RFU_STARTVECTOR0B7 ,None RESET:0x0"
          
group.long  0x3e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B8, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B8_RFU_STARTVECTOR0B8 ,None RESET:0x0"
          
group.long  0x40++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B9, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B9_RFU_STARTVECTOR0B9 ,None RESET:0x0"
          
group.long  0x42++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B10, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B10_RFU_STARTVECTOR0B10 ,None RESET:0x0"
          
group.long  0x44++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B11, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B11_RFU_STARTVECTOR0B11 ,None RESET:0x0"
          
group.long  0x46++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B12, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B12_RFU_STARTVECTOR0B12 ,None RESET:0x0"
          
group.long  0x48++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B13, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B13_RFU_STARTVECTOR0B13 ,None RESET:0x0"
          
group.long  0x4a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B14, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B14_RFU_STARTVECTOR0B14 ,None RESET:0x0"
          
group.long  0x4c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B15, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--6. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_STARTVECTOR0B15_RFU_STARTVECTOR0B15 ,None RESET:0x0"
          
group.long  0x4e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BWAITCONDSEL, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--2. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQ0BWAITCONDSEL_SEQ0BWAITCONDSEL ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x50++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_PHYINLP3, Indicator for PIE Lower Power 3 (LP3) Status RESET:0x1"
         bitfld.long 0x00 0. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_PHYINLP3_PHYINLP3 ,Read Only. Set to 1 by the PIE once completed LP3 Entry sequence. Cleared during LP3 Exit sequence. System software can read this csr for the status of PIE engine. RESET:0x1"
          
group.long  0x52++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B0S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B0S0_SEQUENCEREG0B0S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x54++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B0S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B0S1_SEQUENCEREG0B0S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x56++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B0S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B0S2_SEQUENCEREG0B0S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x58++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B1S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B1S0_SEQUENCEREG0B1S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x5a++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B1S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B1S1_SEQUENCEREG0B1S1 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x5c++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B1S2, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--8. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B1S2_SEQUENCEREG0B1S2 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x5e++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B2S0, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
         hexmask.long 0x00 0.--15. 1. " LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B2S0_SEQUENCEREG0B2S0 ,Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
          
group.long  0x60++0x3
    line.long 0x00 "LPDDR4_PUB_DWC_DDRPHYA_INITENG0_P0_SEQUENCEREG0B2S1, Reserved for PHY Initialization Engine (PIE) image use. RESET:0x0"
